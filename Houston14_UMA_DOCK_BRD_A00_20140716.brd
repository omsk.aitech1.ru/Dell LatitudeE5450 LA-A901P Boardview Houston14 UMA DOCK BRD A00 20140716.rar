# Allegro board Houston14_UMA_DOCK_BRD_A00_20140716.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GNDA: length 33.3
  TOP w0.127: v4(15.07,93.19) QA2.4
  TOP w0.203: v1(23,97.5) 22.92,97.42 22.92,96.92 23.23,96.61 UA1.26
  TOP w0.381: RA44.2 v1(26.23,100.66)
  TOP w0.457: QA2.4 v1(13.25,93.19)
  TOP w0.508: v1(19.2,95.07) 19.79,94.49 CA25.2 ; v1(23.77,86.7) 24.24,86.7 24.42,86.88 CA16.2 ; CA8.2 CA35.1 v1(19.88,98.62) ; CA3.2 17.46,88.82 v1(17.46,88.9) ; CA4.2 v1(17.06,85.27) ; CA52.2 21.67,87.29 v1(20.61,87.29) CA17.2 ; QA2.1 v1(12.02,95.3)
  GND2 w0.203: 7.07,79.85 JHP1.7 ; JHP1.7 8.2,79.85 ; JHP1.7 7.07,80.57 ; JHP1.7 9.33,80.57 ; JHP1.7 9.33,79.85
  IN2 w0.508: v1(20.61,87.29) 20.87,87.54 23.33,87.54 23.77,87.1 v1(23.77,86.7)
  VCC w0.203: JHP1.7 9.33,79.85 ; JHP1.7 7.07,79.85 ; JHP1.7 8.2,79.85
  BOTTOM w0.508: v1(19.2,95.07) 19.7,94.58 CA1.2 ; v1(20.27,99.38) 20.71,99.82 CA9.2 ; v1(19.42,92.47) 19.93,91.96 CA2.2 ; RA36.1 RA37.1 23.91,97.55 v1(23.43,98.03) ; v1(26.96,102.07) 26.96,101.58 27.22,101.32 RA35.1
  vias: v1(19.27,86.12) v1(19.8,85.84) v1(22.43,100.22) v1(22.43,99.63) v1(24.04,91.94) v1(24.02,91.35) v4(19.85,86.43) v4(21.88,100.65)
GNDA_CHG: length 6
  TOP w0.102: v3(81.62,70.36) v2(81.62,70.98)
  TOP w0.508: PC703.2 81.19,81.98 80.75,81.54 PC701.1 v1(81.43,81.09) ; v3(72.8,79.45) 73.23,79.45 PC719.1 PR788.1
  BOTTOM w0.508: PC728.2 81.32,70.67 v3(81.62,70.36) ; PC726.1 v3(82.33,70.42)
  vias: v3(76.99,70.47) v3(77.03,69.84) v3(77.79,77.64) v3(77.79,76.65) v3(78.57,76.62) v3(78.63,77.61) v3(79.39,76.62) v3(79.41,77.61)
VCCSENSE: length 25.3
  BOTTOM w0.076: 128.56,68.21 128.56,68.21 128.85,67.93 129.52,67.93 129.86,67.59 UC1.E63
  BOTTOM w0.254: PR531.1 110.29,68.71 112.19,68.71 115.38,65.52 115.38,65.04 115.8,64.62 116.83,64.62 117.44,64.01 RC209.2 117.56,64.04 118.2,64.67 v2(121.84,64.67) 121.86,64.67 122.5,65.3 123.74,66.54 123.74,67.29 124.4,67.96 124.84,68.39 128.38,68.39 128.56,68.21
VDD_1.35V: length 6.7
  TOP w0.102: PR201.1 260.08,36.21 v2(260.52,36.64)
  TOP w0.508: PR202.2 261.38,33.85 v3(260.34,34.89) 260.08,35.14 PR201.1
  BOTTOM w0.203: v3(260.34,34.89) 260.24,34.99 259.83,34.99 259.66,35.16 PU200.11
  BOTTOM w0.508: PR202.2 261.66,33.84 261.39,33.84 v3(260.34,34.89)
VSSSENSE: length 25.3
  BOTTOM w0.076: 128.35,68.9 128.94,68.3 129.48,68.3 129.86,67.92 130.63,67.92 131,67.55 UC1.E62
  BOTTOM w0.254: 128.35,68.9 124.63,68.9 123.23,67.5 v2(123.23,67.49) 123.23,66.75 121.65,65.18 118.29,65.18 117.6,65.86 RC218.1 115.82,65.86 112.47,69.22 110.16,69.22 PR532.1
3301_ACAV_IN_NB: length 2.3
  BOTTOM w0.254: PR848.1 101.64,52.85 101.64,52.98 101.9,53.25 PU800.24
3301_PWRSRC: length 1.9
  BOTTOM w0.254: PR860.1 106.58,57 106.29,56.72 PU800.15
+AUX_LDO: length 4.8
  TOP w0.203: 305.97,60.34 306.15,60.52 306.15,61.48 306.3,61.62 UR1.12
  TOP w0.508: 305.97,60.34 v2(305.97,58.83) 305.63,58.49 CR17.2
+BL_PWR_SRC:
  vias: v1(91.92,99.41) v1(92.57,99.4) v1(93.31,99.37) v4(93.56,98.02)
+CAP_LDO: length 5.8
  TOP w0.254: v1(256.34,75.58) 256.17,75.58 255.92,75.33 UE1.B46 ; v1(256.18,72.25) 256.71,71.73 CE7.1
  BOTTOM w0.254: v1(256.18,72.25) 256.31,72.25 v2(256.76,72.7) 256.76,74.93 256.34,75.35 v1(256.34,75.58)
+COINCELL: length 15
  TOP w0.508: JRTC1.1 320.85,70.2 318.64,72.41 314.73,72.41 314.32,72.81 PR1.1
+CRT_VCC: length 3.3
  TOP w0.508: RV38.1 263.94,110.05 v1(263.47,109.58) 262.93,110.12 RV35.1 ; RV37.1 v1(266.23,109.67) ; RV36.1 v1(269.28,109.69)
  vias: v1(270.34,112.02) v1(271.01,112.03) v2(271.89,112.4)
+DC_IN: length 78
  TOP w0.102: v3(106.49,52.54) v4(107.1,53.15)
  TOP w0.127: v3(57,91.13) 57,91.71 v4(57.68,92.4)
  IN3 w0.508: v3(61.19,87.51) 61.54,87.51 64.79,84.25 66.08,84.25 68.62,81.71 68.62,76.6 69.58,75.63 72.41,75.63 75.35,72.7 75.35,68.55 79.77,64.12 89.87,64.12 90.46,63.53 v3(94.79,63.53) 96.86,61.46 96.88,61.46 98.72,59.62 98.72,55.27 99.9,54.09 104.94,54.09 v3(106.49,52.54)
  BOTTOM w0.406: v3(61.19,87.51) 61.19,87.5 PQ6.3
  BOTTOM w0.508: PR737.1 106.85,52.9 v3(106.49,52.54) ; v3(94.79,63.53) 95.05,63.78 PR835.1 ; PC22.1 53.28,91.67
  vias: v3(57,90.43) v4(60.21,88.76)
+DC_IN_SS: length 74.4
  TOP w0.102: v1(59.55,94.12) v4(59.55,94.86)
  TOP w0.508: PD704.2 95.85,60.06 v3(95.67,59.88)
  IN1 w0.508: v3(95.67,59.88) 95.67,60.67 92.1,64.24 89.71,64.24 88.96,64.99 82.36,64.99 80.14,67.21 79.39,67.21 79.08,67.52 79.08,69.4 78.83,69.65 78.83,70.92 77.48,72.27 77.48,73.47 77,73.95 76.62,73.95 76.09,74.49 76.09,75.88 76.14,75.93 76.14,77.92 74.49,79.57 74.49,80.34 v1(73.39,81.43)
  IN2 w0.508: v1(73.39,81.43) 71.83,83 69.09,83 64.36,87.72 63.26,87.72 61.51,89.47 61.51,92.17 v1(59.55,94.12)
  IN4 w0.508: v1(97.09,72.7) 97.09,69.38 96.44,68.73 96.44,60.66 v3(95.67,59.88)
  BOTTOM w0.508: PR831.1 v3(95.67,59.88) ; PD817.3 v1(97.09,72.7)
+DCIN: length 0.6
  TOP w0.127: 83.1,82.49 PR708.2
  vias: v1(81.85,79.99)
+DCIN_JACK:
  vias: v1(44.59,88.05) v4(43.35,89.35) v4(43.6,92.27) v4(45.12,89.35)
+DCPRRTC: length 7.4
  TOP w0.254: CC52.1 170.76,55.57 170.58,55.75 169.9,55.75 169.82,55.83 v2(168.77,55.83) 167.33,55.83 166.92,56.25 165.77,56.25 v1(165.32,56.7)
  BOTTOM w0.254: v1(165.32,56.7) 165.32,56.7 165.07,56.45 165.07,56.3 UC1.AE7
+DIMM1_VREF_DQ: length 7.8
  TOP w0.102: v4(91.22,11.75) 91.17,11.7 RD4.2
  TOP w0.508: RD4.2 CD1.1 CD5.1 87.92,11.95 v1(88.34,12.37) 88.34,12.4 87.92,12.82 RD5.1 RD6.1
  BOTTOM w0.356: v1(88.34,12.37) 88.47,12.5 88.76,12.5 88.96,12.3 JDIMM1.1
+DIMM2_VREF_DQ: length 7.7
  TOP w0.102: v2(163.87,13.15) 164.12,13.15 164.5,12.77 v1(164.73,12.77)
  TOP w0.508: RD24.1 RD23.1 RD22.2 CD33.1 CD34.1 164.73,11.85 v1(164.73,12.77)
  BOTTOM w0.305: v1(164.73,12.77) 164.83,12.66 164.83,12.34 164.96,12.22 JDIMM2.1
+DOCK_PWR_BAR: length 70.3
  TOP w0.102: v1(110.72,56.33) 110.72,57.43 v2(110.93,57.65)
  TOP w0.508: C318.1 v1(147.1,111.86) ; PD705.2 96.49,58.31 v3(95.86,58.94) ; v3(125.36,100.14) 124.9,99.68 PR814.2
  IN1 w0.508: v1(122.01,95.66) 121.96,95.71 119.37,95.71 119.19,95.53 119.19,75.62 118.47,74.9 116.2,74.9 110.36,69.07 110.36,57.64 110.72,57.28 v1(110.72,56.33)
  IN2 w0.508: v1(110.72,56.33) 107.61,56.33 106.63,57.3 106.63,57.86 104.17,60.33 98.78,60.33 97.4,58.94 v3(95.86,58.94)
  BOTTOM w0.508: v3(95.86,58.94) 95.53,58.61 PR832.2
  vias: v3(138.34,117.8) v3(138.34,116.97) v3(138.38,116.26) v3(138.39,115.62) v3(138.39,114.99) v3(138.39,114.35) v3(138.98,117.67) v3(138.98,116.91) v3(139.05,116.27) v3(139.03,115.62) v3(139.03,114.99) v3(139.03,114.35) v3(139.61,117.73) v3(139.67,116.97) v3(139.71,116.3)
+EDP_VDD: length 1.6
  TOP w0.102: v2(83.58,97.14) 85.15,97.14
+LCDVDD:
  vias: v1(86.55,99.58) v1(86.63,98.99) v1(87.22,98.97) v4(87.15,99.63)
+LOM_VCT: length 4.7
  TOP w0.127: v2(175.96,120.3) 176.66,119.6 v1(176.66,119.46)
  TOP w0.508: v1(176.66,119.46) 177.15,119.95 C316.1
  BOTTOM w0.254: JDOCK1.116 176.4,119.2 v1(176.66,119.46) 176.9,119.22 JDOCK1.118
+MIC1_VREF_OUT: length 5.1
  TOP w0.203: v1(22.42,94.82) 22.62,94.82 22.76,94.96 23.18,94.96 23.21,94.99 23.22,94.99 23.24,95.01 UA1.30
  BOTTOM w0.102: v2(24.02,95.04) 23.8,94.82 v1(22.42,94.82)
  BOTTOM w0.254: v1(22.42,94.82) 21.99,94.39 DA5.2 21.88,94.83 21.47,95.25 DA4.2
+NBDOCK_DC_IN_SS: length 136.5
  TOP w0.508: v1(155.94,108.93) 155.94,108.79 155.16,108 129.64,108 125.18,103.55 106.92,103.55 105.47,102.1 105.47,97.42 103.31,95.27 v1(103.31,94.2)
  IN1 w0.508: v3(105.02,50.55) 104.27,49.8 96.1,49.8 v1(94.69,51.21)
  IN2 w0.508: v1(106.29,89.75) 106.29,91.24 104.81,92.71 104.8,92.71 v1(103.31,94.2)
  IN3 w0.508: v1(106.29,89.75) 106.29,82.98 105.64,82.34 105.64,80.08 105.18,79.62 99.86,79.62 v1(99.45,79.21)
  IN4 w0.508: v1(99.45,79.21) 98.92,78.68 94.23,78.68 93.43,77.88 93.43,71.41 v1(92.77,70.75) 92.53,70.51 92.53,64.56 94.69,62.4 v1(94.69,51.21)
  BOTTOM w0.254: JDOCK1.41 155.9,108.97 v1(155.94,108.93)
  BOTTOM w0.508: v1(92.77,70.75) v2(93.69,70.75) 94.48,70.75 95.15,71.43 95.15,72.68 PD817.2 ; v3(105.02,50.55) 105.02,50.56 105.7,51.25 PR863.2
+PBATT: length 104.5
  TOP w0.508: v1(89.64,62) 90.16,62.52 95.86,62.52 96.6,61.79 PD702.2 ; 114.06,78.16 111.47,75.57 111.47,55.55 v1(110.87,54.96) 107.92,54.96 105.36,52.39 v4(104.43,52.39) 99.35,52.39 97.09,54.65 93.43,54.65 92.98,54.19 v1(89.71,54.19)
  IN2 w0.508: v1(78.14,69.87) 78.59,69.42 78.59,67.63 82.49,63.73 88.23,63.73 89.64,62.32 v1(89.64,62) 89.64,60.39 89.27,60.02 89.27,54.64 v1(89.71,54.19)
  IN4 w0.508: v1(89.71,54.19) 90.88,53.03 90.88,43.8 v3(93.81,40.87)
  BOTTOM w0.508: PR723.2 77.89,70.12 v1(78.14,69.87) ; v1(89.71,54.19) 90.67,53.24 95.78,53.24 96.41,53.86 PR838.2
  vias: v3(79.57,18.24) v3(79.59,17.6) v3(79.63,18.89) v3(80.26,18.9) v3(80.25,18.25) v3(80.25,17.55) v3(80.43,19.52) v3(80.96,18.85) v3(80.98,18.16) v3(80.98,17.53) v3(81.1,19.52) v3(81.55,17.87) v3(93.81,40.17) v3(93.81,39.47) v3(94.58,40.87) v3(94.58,40.17) v3(94.58,39.47) v3(95.28,40.87) v3(95.28,40.17) v3(95.28,39.47) v3(96.04,40.87) v3(96.04,40.17) v3(96.04,39.47) v3(96.79,40.91) v3(96.77,40.16) v3(96.75,39.46) v3(96.72,38.74) v3(115.79,80.61) v3(115.79,79.92) v3(115.79,79.19) v3(115.77,78.4) v3(115.76,77.69) v3(116.5,78.4) v3(116.48,77.69) v3(116.51,80.61) v3(116.51,79.92) v3(116.51,79.19) v3(117.18,80.33) v3(117.17,79.58) v3(117.16,78.78) v3(117.16,78.07) v3(126.96,96.95) v3(126.96,96.32) v3(127.15,95.67) v3(127.65,96.92) v3(127.65,96.26) v3(127.85,95.65) v3(128.32,96.88) v3(128.32,96.23) v3(128.64,95.67) v3(129.04,96.93) v3(129.02,96.29) v3(129.34,95.71) v3(129.73,96.94) v3(129.72,96.26)
+PCH_ASATA3PLL: length 18.2
  IN3 w0.381: v1(162.99,75.99) 162.99,76.79 162.76,77.02 161.76,77.02 v1(161.62,77.16) 161.62,76.85 160.96,76.19 v1(160.96,74.91)
  BOTTOM w0.203: UC1.A12 161.77,70.33 161.77,72.05 ; UC1.B11 162.23,69.65 162.23,71 162.27,71.03 162.27,71.71
  BOTTOM w0.381: v1(160.96,74.91) 160.96,74.6 161.3,74.26 161.3,73.51 161.77,73.05 161.77,72.05 ; RC17.2 161.86,77.93 161.62,77.69 v1(161.62,77.16) ; 162.27,71.71 162.32,71.76 162.32,73.65 162.99,74.32 v1(162.99,75.99)
  vias: v2(165.39,75.89)
+PCH_AUSB3PLL: length 31.7
  TOP w0.102: v1(161.99,81.7) 161.58,81.29 v2(161.58,80.71)
  TOP w0.381: v1(161.99,81.7) 162.09,81.6 LC1.2 ; v1(158.03,75.67) 158.28,75.92 CC51.1 CC47.1
  IN2 w0.381: v1(158.03,75.67) 157.61,75.25 155.32,75.25 154.69,75.89 v1(153.39,75.89)
  IN3 w0.381: v1(157.73,70.77) 157.62,70.88 157.62,71.94 158.34,72.66 158.34,75.35 v1(158.03,75.67) 158.03,77.24 161.94,81.15 161.94,81.65 v1(161.99,81.7)
  BOTTOM w0.203: UC1.B27 153.14,69.72 152.77,70.09 152.77,70.34 153.06,70.64 153.23,70.64 153.57,70.98 153.57,71.11
  BOTTOM w0.254: UC1.B18 157.87,69.83 157.87,70.41 157.73,70.55 v1(157.73,70.77)
  BOTTOM w0.381: v1(153.39,75.89) 153.33,75.82 153.33,75.33 RC149.1 153.25,73.61 154.03,72.84 154.03,71.57 153.57,71.11
+PCH_RTC_VCCSUS3_3: length 63.2
  TOP w0.102: v2(192.94,46.76) 192.94,47.2 v1(192.68,47.46)
  TOP w0.254: CC73.1 161.95,54.33 161.95,53.74 v1(161.99,53.7)
  IN2 w0.254: v1(161.99,53.7) 161.87,53.7 161.36,53.18 161.36,45.07 168.23,38.21 169.21,38.21 169.84,37.58 170.63,37.58 171.29,36.92 172.64,36.92 174.48,35.08 179.58,35.08 v1(179.74,34.91)
  IN3 w0.254: v1(189.71,35) 189.71,35.78 192.72,38.79 192.72,40.08 193.74,41.1 193.74,42.78 194.21,43.25 194.21,45.33 193.15,46.38 193.15,46.99 v1(192.68,47.46)
  BOTTOM w0.254: v1(179.74,34.91) 180.3,34.36 189.14,34.36 189.65,34.86 189.65,34.94 v1(189.71,35) ; UC1.AH11 162.09,54.33 162.09,53.8 v1(161.99,53.7) ; RC212.2 RC213.2 190.99,47.96 191.56,47.39 192.6,47.39 v1(192.68,47.46)
+PCH_VCC1P05: length 19.8
  TOP w0.076: CC78.1 157.61,64.64 v1(158.3,65.34)
  TOP w0.102: v1(155.47,75.9) 155.87,75.5 v2(156.12,75.5)
  TOP w0.508: LC4.2 153.83,76.88 154.81,75.9 v1(155.47,75.9) 156.25,76.67 CC77.1
  IN3 w0.254: 156.7,69.1 157.84,67.97 157.84,67.1 157.86,67.08 157.86,65.78 v1(158.3,65.34)
  IN3 w0.508: 156.7,69.1 156.41,69.39 156.41,74.32 155.47,75.26 v1(155.47,75.9)
  BOTTOM w0.254: UC1.J18 158.63,65.01 v1(158.3,65.34) 158.29,65.32 UC1.K19
+PCH_VCCACLKPLL: length 16.1
  BOTTOM w0.254: UC1.A20 157.46,70.24 157.26,70.44 157.26,71.66 158.48,72.88 158.48,74.25 158.9,74.67 158.9,76.05 159.5,76.65 RC69.2 159.5,77.94 v4(159.04,78.41) 158.61,78.83 158.61,79.94 159.05,80.38 CC82.1 160.93,80.38 CC81.1 163.33,80.52 LC5.2
+PCH_VCCDSW: length 5.3
  TOP w0.076: 158.38,57.77 CC97.2
  TOP w0.381: RC211.2 158.41,57.77 158.41,57.41 v1(158.19,57.19)
  IN2 w0.508: v1(158.19,57.19) 157.54,56.54 157.54,55.58 v1(158.05,55.07)
  BOTTOM w0.254: UC1.AG20 157.68,55.44 v1(158.05,55.07) 158.42,55.44 UC1.AG19
+PCH_VCCDSW3_3: length 138.6
  TOP w0.254: CC97.1 158.93,58.17 158.93,57.76 v1(159.11,57.58) ; v1(172.59,39.4) 172.62,39.42 172.82,39.42 173.02,39.63 RPC1.1
  TOP w0.508: v1(182.64,41.96) 181.84,41.96 v4(181.85,41.98) 181.01,41.98 180.2,41.16 RC216.2 RC217.2 CC80.1
  IN2 w0.254: 187.35,51.72 187.38,51.72 187.71,52.05 187.71,53.38 186.59,54.5 186,54.5 185.6,54.9 v1(185.56,54.9) ; v1(163.83,53.83) 163.33,54.32 162.12,54.32 159.11,57.33 v1(159.11,57.58)
  IN2 w0.508: 187.35,51.72 187.06,51.42 185.85,51.42 185.32,50.89 v1(185.15,50.89)
  IN3 w0.254: 166.66,48.59 166.07,49.19 166.07,49.8 165.75,50.12 165.5,50.12 165.24,50.38 165.24,50.62 165.19,50.67 165.19,53.22 164.78,53.64 164.78,53.64 164.52,53.9 163.99,53.9 163.92,53.83 v1(163.83,53.83)
  IN3 w0.508: 166.66,48.59 166.8,48.59 168.86,46.54 168.86,45.06 169.62,44.3 169.62,41.99 170.66,40.95 171.88,40.95 172.76,40.07
  IN3 w1.016: 225.43,77.57 225.4,77.55 225.4,77.09 224.7,76.39 221.12,76.39 217.89,79.62 204.99,79.62 204.58,79.21 204.58,78.58 200.79,74.79 200.79,63.82 199.59,62.63 199.59,46.62 199.92,46.29 199.92,39.02 199.01,38.1 198.42,38.1 197.6,37.28 197.6,36.17 196.58,35.16 193.26,35.16 190.88,32.78 185,32.78 183.08,34.7 183.08,40.46 183.1,40.48
  BOTTOM w0.203: v1(163.83,53.83) 163.8,53.86 163.8,54.16 163.33,54.63 UC1.AH10
  BOTTOM w0.254: RPC10.2 185.49,54.93 185.51,54.9 v1(185.56,54.9) ; RPC19.8 189.24,49.86 189.4,49.71 v1(189.5,49.71)
  BOTTOM w0.305: v1(227.2,78.09) 227.19,78.11 JAPS1.3 ; v1(229.19,77.68) JAPS1.7
  BOTTOM w0.508: RC153.2 184.65,51.45 185.15,50.94 v1(185.15,50.89) 184.78,50.52 RC92.2
+PCH_VCCDSW_R: length 3.6
  TOP w0.076: CC65.1 157.82,60.07 157.61,60.29 156.76,60.29 v2(156.12,60.92)
  TOP w0.508: CC65.1 157.82,59.36 157.52,59.06 RC211.1
+PECI_VREF: length 5.4
  TOP w0.254: RE59.1 CE25.1 250.74,53.86 v2(251.33,53.86) 252.59,55.12 252.67,55.12 253.05,55.5 UE2.B51
+PWR_SRC: length 0.7
  TOP w0.102: v3(203.15,73.32) v4(203.15,74.07)
  vias: v1(94.35,93.53) v1(94.98,93.53) v1(95.62,93.53) v3(94.21,79.5) v3(94.84,79.5) v3(95.92,79.5) v3(96.56,79.5) v3(97.76,79.5) v3(98.39,84.43) v3(98.4,83.67) v3(98.4,79.5) v3(99.07,85.68) v3(99.09,84.9) v3(99.1,84.14) v3(99.1,83.39) v3(99.7,86.08) v3(99.71,85.31) v3(99.72,84.55) v3(99.72,83.8) v3(100.29,85.83) v3(100.3,85.05) v3(100.32,84.29) v3(100.32,83.54) v3(100.94,86.24) v3(100.95,85.46) v3(100.97,84.7) v3(100.97,83.95) v3(202.49,71.83) v3(203.15,72.56) v3(203.17,71.85) v3(204.09,74.02) v3(204.09,73.32) v3(204.09,72.56) v3(204.09,71.87) v3(204.94,73.99) v3(204.93,73.32) v3(204.93,72.56) v3(204.91,71.87) v3(222.61,45.71) v3(222.61,45.07) v3(222.61,44.44) v3(243.14,39.36) v3(243.75,40.01) v3(243.78,39.36) v3(244.39,40.01) v3(244.41,39.36)
+PWR_SRC_AC: length 49.4
  TOP w0.102: v3(109.25,57.17) 108.72,57.69 v2(108.65,57.69)
  IN1 w0.508: v1(110.55,73.62) 110.55,70.27 109.69,69.41 109.69,61.05 108.65,60.01 108.65,57.81 109.25,57.22 v3(109.25,57.17)
  IN2 w0.508: v1(113.91,95.62) 115.74,95.62 117.89,93.46 117.89,77.28 117.41,76.8 113.02,76.8 110.55,74.34 v1(110.55,73.62)
  BOTTOM w0.508: PR860.2 109.08,57 v3(109.25,57.17)
  vias: v3(69.68,99.18) v3(69.7,98.49) v3(69.71,97.84) v3(69.72,97.17) v3(69.72,96.5) v3(70.33,99.21) v3(70.98,99.24) v3(71.67,99.24) v3(72.3,99.24) v3(112.99,99.84) v3(112.99,99.2) v3(113.63,99.84) v3(113.63,99.2) v3(114.26,99.84) v3(114.26,99.2) v3(114.9,99.84) v3(114.9,99.2)
+RSVD_VCC3P3_1: length 4.4
  TOP w0.203: 274.65,88.71 275.24,88.12 UL1.1
  TOP w0.508: 274.65,88.71 274.65,89.33 v2(273.86,90.12) 273.24,90.74 RL6.2
+RTC_CELL: length 466.7
  TOP w0.254: CC50.1 156.16,55.4 CC49.1 156.48,55.26 157.35,55.26 157.58,55.49 CC48.1 157.94,55.76 158.34,56.16 158.34,56.17 v1(158.47,56.3) ; RPE5.5 267.73,57.57 v1(268.24,57.57) 268.24,58.06 268.06,58.24 RPE5.6 ; v1(258.88,47.2) 259.12,47.44 RE32.1 ; RC78.2 v1(169.46,36.11)
  TOP w0.508: PD3.1 309.04,72.61 PC1.1 308.34,73.32 309.36,74.34 v1(310.1,74.34) ; RE31.1 267.25,52.57 267.35,52.47 RE62.1 268.82,52.47 v4(269.06,52.71) 269.06,53.34 v1(269.02,53.38)
  IN1 w0.508: v1(269.02,53.38) 269.61,53.96 272.26,53.96 273.01,53.22 275.65,53.22 276.43,53.99 277.01,53.99 278.23,52.77 284.35,52.77 285.55,51.58 291.73,51.58 293.08,50.23 301.35,50.23 301.57,50.46 302.93,50.46 303.2,50.19 v1(312.74,50.19)
  IN2 w0.254: v1(268.55,47.12) 268.02,46.59 266.59,46.59 266.36,46.36 264.07,46.36 263.4,45.68 259.13,45.68 258.61,46.21 258.61,46.93 v1(258.88,47.2) 257.96,48.11 256.32,48.11 256.12,48.31 252.32,48.31 250.42,50.22 246.52,50.22 244.48,48.17 243.29,48.17 242.54,47.42 242.51,47.42 242.24,47.42 239.68,44.86 239.5,44.86 237.16,42.52 237.16,41.45 232.15,36.45 231.31,36.45 226.67,31.82 192.79,31.82 192.37,31.4 185.04,31.4 179.21,37.23 179.21,38.23 177.3,40.13 177.21,40.13 174.61,42.74 170.6,42.74 168.9,41.04 v1(168.9,39.52) ; v1(169.46,36.11) 168.41,37.15 167.55,37.15 166.28,38.42 162.43,38.42 159,41.85 159,48.57 159.49,49.05 159.49,54.41 159.05,54.84 159.05,55.72 v1(158.47,56.3)
  IN3 w0.254: v1(33.74,90.19) 33.74,87.14 36.84,84.04 36.84,79.16 37.43,78.58 40.5,78.58 41.08,79.16 56.6,79.16 57.99,77.78 60.44,77.78 63.53,74.69 72.07,74.69 74.08,72.68 74.08,66.51 80.05,60.54 80.05,58.99 83.3,55.74 83.3,52.94 84.3,51.93 84.3,36.02 83.76,35.47 83.76,32.31 83.49,32.04 v1(83.49,31.97) ; v1(168.9,39.52) 168.07,39.52 162.92,44.68 162.92,45.26 162.13,46.05 162.13,48.45 162.8,49.12 162.8,50.31 163.06,50.57 163.06,53.05 163.37,53.37 163.37,54.78 v1(163.74,55.15)
  IN4 w0.254: v1(83.49,31.97) 83.67,31.79 90.59,31.79 v1(90.77,31.61) ; v1(268.24,57.57) 268.68,57.13 268.68,56.87 269.76,55.79 269.76,54.12 v1(269.02,53.38)
  BOTTOM w0.254: v1(169.46,36.11) 168.2,34.85 111.84,34.85 108.77,31.78 105.03,31.78 104.48,32.32 101.93,32.32 100.66,33.59 94.58,33.59 92.91,31.93 91.08,31.93 v1(90.77,31.61) ; v1(169.46,36.11) 168.47,37.1 168.47,39.09 v1(168.9,39.52) 169,39.52 RC1.1 ; v1(169.46,36.11) 170.98,37.63 170.98,39.03 170.94,39.07 170.94,39.49 171.7,40.25 RC10.1 RC8.1 RC9.1 ; UC1.AG10 163.43,55.44 163.73,55.15 v1(163.74,55.15) ; v1(269.02,53.38) 269.02,53.03 268.15,52.15 268.15,48.49 268.55,48.08 v1(268.55,47.12) ; RA21.1 33.62,90.31 v1(33.74,90.19)
  BOTTOM w0.508: v1(310.1,74.34) 311.04,73.4 311.04,68.18 310.91,68.05 310.91,66.66 312,65.57 312,57.37 312.74,56.63 v1(312.74,50.19)
+RTC_CELL_VBAT: length 9.6
  TOP w0.254: v1(259.18,49.47) 259.25,49.41 259.98,49.41 260.13,49.25 CE11.1 RE32.2 ; UE2.B64 v1(259.85,55.57)
  BOTTOM w0.254: v1(259.85,55.57) 259.12,54.83 v2(259.12,52.64) 259.12,49.53 v1(259.18,49.47)
+SD_IO_LDO: length 6.2
  TOP w0.102: CR14.2 315.06,57.46 v2(314.72,57.11)
  TOP w0.203: CR15.2 314.45,59.76 313.59,60.62 313.59,61.17 313.13,61.62 UR1.25
  TOP w0.508: CR15.2 315.05,58.5 CR14.2
+SDC_IN: length 130.2
  TOP w0.102: v3(63.09,91.38) v4(63.09,92.33)
  TOP w0.203: v3(78.64,80.6) 78.68,80.6 78.92,80.35 PU700.3
  TOP w0.508: PC700.1 63.03,91.32 v3(63.09,91.38)
  IN3 w0.508: v3(63.09,91.38) 63.09,89.46 64.06,88.5 66.62,88.5 68.02,87.1 69.08,87.1 71.09,85.08 74.51,85.08 76.72,82.87 76.72,82.16 76.64,82.09 76.64,80.33 77.02,79.96 77.11,79.96 77.13,79.95 77.99,79.95 v3(78.64,80.6) 78.64,80.85 77.76,81.73 77.76,88.05 80.18,90.46 105.5,90.46 106.26,91.23 108.6,91.23 110.22,92.85 110.22,93.94 110.87,94.59 116.51,94.59 117.94,93.16 117.94,77.41 117.31,76.77 110.88,76.77 110.15,77.51 105.96,77.51 105.68,77.23 101.1,77.23 99.63,75.76 99.63,67.66 99.1,67.12 99.1,66.11 99.47,65.74 100.83,65.74 102.02,64.54 v3(102.02,63.81)
  BOTTOM w0.508: PR710.2 78.22,81.26 78.64,80.84 v3(78.64,80.6) ; PR847.1 102.68,63.48 102.35,63.81 v3(102.02,63.81)
+SIM_PWR: length 52.1
  TOP w0.102: v1(286.19,91.34) 286.73,91.87 v2(286.73,92.55)
  IN3 w1.016: 232.07,96.31 232.52,96.76 240.68,96.76 242.63,98.72 245.59,98.72 246.09,98.22 246.09,97.58 246.65,97.02 248.78,97.02 249.42,96.38 251.71,96.38 254.75,99.42 279.11,99.42
  vias: v1(231.58,95.82) v1(232.23,95.82) v1(279.73,99.04) v1(280.2,98.58) v1(286.18,91.94)
+SM_VREF_CA: length 172.5
  TOP w0.508: v1(138.8,51.09) 138.8,49.95 135.32,46.46 135.32,45.59 130.64,40.92 130.44,40.71 130.44,40.22 111.47,21.25 111.47,14.56 112.12,13.91 112.12,11.46 v2(111.28,10.62) 111.15,10.49 111.15,4.92 112.11,3.95 v1(112.26,3.95) ; CD36.1 211.99,2.66 212.42,3.09 v1(212.42,4.54) ; RD19.2 v1(208.57,4.51)
  IN1 w0.508: v1(112.26,3.95) 122.46,3.95 122.48,3.98 147.8,3.98 149.14,5.32 149.14,9.84 149.9,10.6 157.46,10.6 164.19,3.88 207.73,3.88 208.36,4.51 v1(208.57,4.51) 208.95,4.13 211.79,4.13 212.19,4.54 v1(212.42,4.54)
  BOTTOM w0.254: v1(138.8,51.09) 139.08,51.37 UC1.AP49
+SM_VREF_CA_DIMM: length 92.8
  TOP w0.102: RD18.2 v2(209.59,1.49)
  TOP w0.508: v1(204.93,1.73) 205.52,2.32 CD55.1 CD56.1 RD20.1 RD19.1 RD18.2 ; v1(129.2,1.62) 129.2,3.05 129.72,3.57 CD22.1 CD23.1
  IN2 w0.508: v1(204.93,1.73) 204.93,2.07 203.47,3.53 200.81,3.53 199.9,2.62 162.78,2.62 160.27,5.12 157.02,5.12 154.5,2.59 129.86,2.59 129.2,1.93 v1(129.2,1.62)
  BOTTOM w0.356: JDIMM2.126 204.86,1.8 v1(204.93,1.73) ; v1(129.2,1.62) 128.86,1.95 JDIMM1.126
+SM_VREF_DQ0: length 66.7
  TOP w0.508: RD5.2 CD21.1 88.94,14.72 89.93,15.71 100.88,15.71 105.21,20.04 106.89,20.04 v4(118.98,32.13) 129.23,42.38 129.26,42.38 133.54,46.66 133.54,48 134.94,49.4 136.46,49.4 137.09,50.03 v1(137.11,50.03)
  BOTTOM w0.254: UC1.AR51 138.22,50.71 137.6,50.09 137.2,50.09 137.13,50.03 v1(137.11,50.03)
+SM_VREF_DQ1: length 121
  TOP w0.508: v1(161.85,9.96) 161.84,9.97 RD23.2 ; v1(167.22,4.59) 166.66,4.03 CD54.1 ; v1(111.07,12.87) 110.34,13.6 110.34,22.05 v2(122.62,34.33) 129.9,41.61 130.44,41.61 134.68,45.85 134.68,46.68 137.83,49.83 v1(137.83,51.04)
  IN3 w0.508: v1(167.22,4.59) 166.65,4.02 164.13,4.02 161.84,6.31 161.84,9.95 v1(161.85,9.96) 161.43,10.38 161.43,10.39 161.07,10.75 161.06,10.75 159.87,11.94 159.87,15.03 157.51,17.39 114.77,17.39 111.07,13.69 v1(111.07,12.87)
  BOTTOM w0.254: v1(137.83,51.04) 138.16,51.37 UC1.AP51
+USB_LEFT_PWR:
  vias: v1(60.69,105.25) v1(61.34,105.26) v1(62.01,105.26) v1(62.61,105.26) v1(63.25,105.25) v4(62.85,104.64)
+USB_RIGHT_PWR: length 0.7
  TOP w0.127: v1(245.38,117.68) v4(245.38,118.38)
  vias: v1(244.79,117.68) v1(244.79,117.1) v1(244.79,116.51) v1(245.38,117.1)
+V_DDR_REF:
  vias: v1(259.11,39.59)
+VCHGR:
  vias: v3(107.29,79.52) v3(107.3,81.6) v3(107.3,80.94) v3(107.31,80.24) v3(107.37,78.6) v3(107.85,81.28) v3(107.85,80.58) v3(107.85,79.82) v3(107.85,79.06) v3(110.48,84.51) v3(110.46,83.81) v3(110.52,83.1) v3(111.19,83.12) v3(111.84,83.15) v3(112.47,83.15) v3(113.14,83.1) v4(106.97,84.39)
+VHDMI_VCC: length 10.9
  TOP w0.508: v1(101.84,110.05) RV7.2 101.84,108.68 102.11,108.41 102.72,108.41 102.98,108.14 RV9.2
  IN1 w0.508: v1(101.84,110.05) 101.54,110.05 100.91,110.67 99.67,110.67 98.51,109.51 96,109.51 v1(95.21,110.3)
  vias: v2(95.82,109.9)
+VLDOIN_1.35V: length 2.3
  BOTTOM w0.102: v2(252.72,39.02) 252.72,38.52 253.16,38.08 254.3,38.08 254.32,38.09
+VR_CAP: length 11.4
  TOP w0.102: v2(268.01,61.53) 268.33,61.22 v1(268.53,61.22)
  TOP w0.254: v1(261.14,61.67) 261.81,61 UE2.B12 ; CE31.1 268.85,61.53 v1(268.53,61.22)
  IN1 w0.254: v1(261.14,61.67) 262.33,60.48 266.74,60.48 267.17,60.91 268.22,60.91 v1(268.53,61.22)
+VREFOUT: length 10.1
  TOP w0.203: UA1.23 24.91,98.4
  TOP w0.254: CA26.1 23.28,99.68 v1(23.86,99.1) 24.52,99.1 24.91,98.72 24.91,98.4 ; RA6.2 RA5.2 v1(20.03,96.59)
  IN2 w0.254: v1(23.86,99.1) 22.54,99.1 v1(20.03,96.59)
  BOTTOM w0.102: v2(23.46,99.51) v1(23.86,99.1)
+Z4012: length 1.1
  TOP w0.508: PR1.2 311.77,71.9 311.71,71.96 PD3.2
-DCIN_JACK:
  vias: v1(39.51,88.99)
/BATPRES: length 59.2
  TOP w0.102: v2(75.7,69.94) 75.25,70.4 75.25,71.44 75.83,72.02 PR728.2
  TOP w0.203: PU700.15 77.32,74.88 77.38,74.82 77.38,74.22 77.46,74.15
  TOP w0.254: PR728.2 76.24,72.65 76.56,72.96 76.81,72.96 v1(76.84,72.99) 77.01,72.99 77.46,73.44 77.46,74.14 77.46,74.15 ; PR816.2 87.76,44.47 v1(84.93,47.3)
  IN2 w0.254: v1(84.93,47.3) 85.06,47.43 85.06,51.92 84.11,52.87 84.11,55.88 81.47,58.53 81.47,62.46 77.62,66.31 77.62,71.33 76.84,72.11 v1(76.84,72.99)
A_ON: length 114.2
  TOP w0.102: v1(197.4,41.52) 196.98,41.52 190.8,35.35 190.8,34.59 v2(190.24,34.02) 189.43,33.21 185.76,33.21 185.25,33.73 UZ8.3 ; v1(264.72,56.76) 264.23,57.25 UE2.A4 ; RPE10.3 269.08,63.57 v1(268.82,63.83) 268.3,64.35 268.3,65.2 268.44,65.34 268.44,65.89 268.67,66.12 269.16,66.12 RZ42.1
  IN1 w0.089: v1(228.32,40.01) 227.28,38.97 221.16,38.97 220.74,38.55 216.24,38.55 215.87,38.92 213.19,38.92 212.74,38.46 202.37,38.46 199.29,41.54 197.42,41.54 v1(197.4,41.52)
  IN3 w0.122: v1(228.32,40.01) 229.51,41.19 238.92,41.19 240.6,42.88 240.6,44.01 242.2,45.6 242.2,46.56 244.65,49.01 244.65,51.3 245.91,52.56 245.91,54.24 246.28,54.61 246.28,54.97 246.75,55.44 249.19,55.44 249.5,55.13 252.05,55.13 252.17,55.25 253.15,55.25 253.3,55.1 259.26,55.1 259.52,54.83 262.26,54.83 263.74,56.31 264.27,56.31 v1(264.72,56.76)
  BOTTOM w0.102: v1(268.82,63.83) 269.04,63.62 269.04,60.21 266,57.18 265.14,57.18 v1(264.72,56.76)
AC_DIS: length 289.9
  TOP w0.102: v2(55.54,85.16) 55.5,85.19 v1(55.5,85.79) ; v1(264.76,59.95) 264.31,60.39 263.78,60.39 263.64,60.25 UE2.A10
  IN2 w0.122: v1(55.5,85.79) 60.5,80.79 61.69,80.79 66.08,76.4 69.44,76.4 69.8,76.75 72.89,76.75 75.44,74.2 75.44,73.21 75.44,68.05 81.15,62.33 81.15,58.4 83.59,55.96 83.59,51.91 84.46,51.04 84.46,47.13 85.47,46.12 v1(85.47,21.68)
  IN3 w0.122: v1(85.47,21.68) 87.12,20.03 96.77,20.03 99.56,22.82 200.2,22.82 211.54,34.15 226.18,34.15 226.98,34.95 226.98,39.96 229.02,42 237.5,42 241.4,45.9 241.4,47.38 242.39,48.36 242.39,49.11 243.09,49.81 243.09,51.48 243.85,52.24 243.85,53.38 245.48,55.01 245.48,55.51 247,57.04 248.72,57.04 248.83,57.15 251.29,57.15 253.86,59.72 254.44,59.72 254.45,59.71 254.8,59.71 254.81,59.72 255.88,59.72 256.39,60.23 260.62,60.23 260.81,60.41 264.29,60.41 v1(264.76,59.95)
  BOTTOM w0.254: v1(55.5,85.79) 55.61,85.91 PR828.1 56.1,86.68 56.22,86.55 PQ6.5
AC_PRESENT: length 141.4
  TOP w0.102: v1(238.19,74.55) 238.19,74.31 238.77,73.73 v2(238.77,70.55) 238.77,59.01 239.18,58.6 239.18,54.96 239.55,54.59 239.55,53.17 v1(240.04,52.68) ; v1(256.97,52.69) 256.82,52.69 256.55,52.96 256.55,53.45 256.6,53.5 UE2.A54
  IN2 w0.122: v1(256.97,52.69) 256.86,52.81 256.09,52.81 255.78,53.11 255.78,53.13 254.86,54.05 252.22,54.05 251.92,53.76 241.12,53.76 v1(240.04,52.68)
  IN4 w0.086: v1(164.19,54.82) 164.58,55.21 166.7,55.21 167.15,54.76 170.3,54.76 170.87,55.32 172.12,55.32 172.31,55.14 172.84,55.14
  IN4 w0.089: 172.84,55.14 173.02,55.14 173.42,54.74 180.88,54.74 181.23,55.1 182.42,55.1 v1(182.85,54.66) 183.02,54.49 188.57,54.49 188.65,54.57 189.85,54.57 190.3,55.02 195.11,55.02 195.5,55.41 195.5,56.87 196.71,58.08 199.18,58.08 201.38,60.29 201.38,73.05 204.74,76.4 204.74,79.14 205.16,79.56 228.37,79.56 230.36,77.57 232.92,77.57 235.85,74.64 238.1,74.64 v1(238.19,74.55)
  BOTTOM w0.076: v1(164.19,54.82) 164.19,54.58 UC1.AJ8
  BOTTOM w0.102: v1(182.85,54.66) 182.9,54.66 183.07,54.82 183.51,54.82 RPC10.7
ACAV_DOCK_SRC#: length 196.4
  TOP w0.102: v2(57.06,107.25) 56.43,107.25 v1(56.39,107.22)
  TOP w0.254: v3(101.41,63.62) 101.41,64.29 102.45,65.33 PR846.2
  IN2 w0.254: v1(56.39,107.22) 56.69,107.52 71.42,107.52 71.62,107.71 78.4,107.71 79.33,106.78 99.13,106.78 100.24,105.67 109.89,105.67 111.6,103.96 124.94,103.96 128.52,107.55 145.62,107.55 146.28,108.21 147.49,108.21 148.76,109.48 149.81,109.48 152.93,112.6 156.11,112.6 v1(156.36,112.85)
  IN3 w0.254: v3(101.41,63.62) 99.31,63.62 96.78,66.14 92.12,66.14 89.77,68.49 89.41,68.49 89.05,68.85 89.05,70.41 88.43,71.03 87.31,71.03 84.53,73.81 81.45,73.81 80.51,74.75 78.83,74.75 76.37,77.22 76.37,77.85 75.5,78.71 75.5,81.45 72.54,84.41 70.99,84.41 68.97,86.43 67.84,86.43 66.46,87.81 63.98,87.81 63.72,88.08 60.72,88.08 58.09,90.71 58.09,95.48 56.64,96.93 v1(53.57,96.93)
  IN4 w0.254: v1(53.57,96.93) 53.57,98.8 52.29,100.08 52.29,106.06 53.44,107.22 v1(56.39,107.22)
  BOTTOM w0.254: v3(101.41,63.62) 101.63,63.4 PR842.1 ; v1(156.36,112.85) 156.63,113.12 156.63,115.83 155.9,116.56 JDOCK1.42
ACAV_IN: length 322.1
  TOP w0.102: UE2.A64 261.6,53.69 261.72,53.57 v1(262.03,53.57)
  TOP w0.254: v1(98.03,42.84) 100.01,42.84 101.1,41.75 v2(103.14,41.75) 104.25,41.75 v1(105.19,42.69) ; v3(78.46,82.17) 78.45,82.18 PR714.1 77.76,83.2 PR713.2
  IN1 w0.254: v3(95.2,74.01) 96.11,73.09 96.11,67.63 98.59,65.15 103.1,65.15 103.42,64.84 103.42,64.2 103.76,63.86 v3(104.25,63.86)
  IN3 w0.254: v3(78.46,82.17) 79.92,80.71 79.92,77.41 80.2,77.13 81.84,77.13 84.95,74.02 v1(91.27,74.02) 91.29,74.01 v3(95.2,74.01) ; v3(104.25,63.86) 104.34,63.86 104.83,63.38 105.85,63.38 106.15,63.08 106.15,63.07 108.05,63.07 v1(108.32,63.34) ; v1(84.89,46.1) 84.89,35.42 84.14,34.67 84.14,29.34 83.23,28.44 83.23,21.32 85.19,19.36 97.17,19.36 99.85,22.04 203.72,22.04 214.76,33.07 226.31,33.07 228.13,34.88 228.13,39.13 229.87,40.88 239.05,40.88 242.58,44.41 242.58,46.48 244.98,48.88 244.98,51.18 246.44,52.64 246.44,53 246.73,53.28 248.73,53.28 249.3,53.85 254.98,53.85 255.38,54.26 258.85,54.26 259.14,53.96 261.63,53.96 v1(262.03,53.57)
  IN4 w0.254: v1(105.19,42.69) 105.65,43.14 105.65,49.8 108.17,52.31 108.17,59.58 108.32,59.73 v1(108.32,63.34)
  BOTTOM w0.254: v1(98.03,42.84) 97.24,43.63 89.55,43.63 87.07,46.1 v1(84.89,46.1) ; PR851.1 103.92,63.32 104.2,63.6 104.2,63.81 v3(104.25,63.86) ; PR715.1 77,79.73 76.56,80.18 76.56,81.92 76.81,82.17 v3(78.46,82.17) ; PQ817.5 v1(91.27,74.02)
ACAV_IN#: length 11.4
  TOP w0.102: PR864.2 94.53,73.78 94.53,74.51 v2(94.91,74.89)
  TOP w0.254: PR864.2 v3(94.48,72.96)
  BOTTOM w0.254: PQ817.3 89.32,74.67 89.59,74.4 89.59,71.82 89.99,71.41 PU806.2 92.93,71.41 v3(94.48,72.96)
ACAV_IN_NB: length 229
  TOP w0.102: UE2.B20 260.85,63.72 260.78,63.65 260.78,63.01 261.04,62.75 v1(261.1,62.75)
  TOP w0.254: v1(106.1,24.95) 107.14,24.95 108.66,26.47 v2(108.66,30.04) 108.66,34.14 v1(108.72,34.2)
  IN2 w0.254: v3(110.25,53.65) 110.25,50.23 109.75,49.74 102.37,49.74 101.56,50.55 v3(101.56,50.71)
  IN3 w0.254: v1(106.1,24.95) 198.19,24.95 208.89,35.64 212.85,35.64 213.78,34.72 225.95,34.72 226.36,35.13 226.36,37.89 226.36,40.23 228.69,42.56 234.21,42.56 234.39,42.75 237.46,42.75 240.8,46.09 240.8,47.6 241.77,48.57 241.77,49.29 242.51,50.03 242.51,53.02 244.21,54.71 244.21,55.4 244.55,55.74 244.82,55.74 245.26,56.19 245.26,56.99 246.53,58.26 247.92,58.26 248.3,58.64 250.06,58.64 250.71,59.29 252.07,59.29 252.72,59.94 252.72,60.48 253.14,60.91 253.14,61.55 253.15,61.56 253.15,61.92 253.71,62.49 254.62,62.49 254.72,62.38 254.78,62.33 254.81,62.33 255.51,61.63 260.41,61.63 261.1,62.32 v1(261.1,62.75) ; v1(108.72,34.2) 108.72,35.31 108.15,35.88 108.15,44.85 110.3,46.99 110.3,53.6 v3(110.25,53.65)
  BOTTOM w0.254: v3(101.56,50.71) 101.13,51.15 PR848.2 ; PR743.2 111.04,53.03 110.41,53.65 v3(110.25,53.65)
ACAVDK_SRC: length 2
  BOTTOM w0.254: PR842.2 101.63,61.66 101.9,61.38 PU800.4
ACAVIN: length 4.4
  BOTTOM w0.102: PR851.2 103.85,61.97 103.44,62.37 103.44,64.06 v2(103.58,64.2)
  BOTTOM w0.254: PR851.2 103.9,61.94 103.9,61.41 103.91,61.4 103.91,60.98 103.9,60.97 PU800.8
ALW_PWRGD_3V_5V: length 76.6
  TOP w0.254: v1(240.55,69.69) 241.48,70.61 RZ51.1 ; v1(236.39,61.66) 236.39,62.17 234.09,64.47 228.78,64.47 224.31,68.94 v2(222.8,68.94) 220.6,68.94 PR108.1 ; v1(264.14,55.75) 264.8,55.1 RE283.2
  IN2 w0.254: v1(236.39,61.66) 236.51,61.66 237.64,60.53 241.79,60.53 242.17,60.91 243.59,60.91 244.23,60.26 248.45,60.26 248.87,59.84 248.87,58.82 249.14,58.55 249.67,58.55 249.97,58.85 249.97,62.42 249.31,63.08 249.31,63.92 249.59,64.2 250.3,64.2 250.69,64.59 251.16,64.59 252.34,64.59 252.79,64.14 261.69,64.14 262.66,63.17 262.66,56.09 263,55.75 v1(264.14,55.75)
  IN3 w0.254: v1(236.39,61.66) 237.03,62.31 237.03,63.22 240.55,66.74 v1(240.55,69.69)
ALW_PWRGD_3V_5V_EC: length 2.5
  TOP w0.102: UE2.A1 263.49,55.75 v2(264.22,55.02) 265.06,54.18 RE283.1
ALWON: length 82.6
  TOP w0.254: v3(222.99,67.82) 223.51,68.34 224.26,68.34 228.51,64.09 233.93,64.09 235.66,62.35 v2(235.66,61.79) 235.66,47.74 234.23,46.31 v1(234.23,46.09) ; UE2.A60 v1(259.6,53.3)
  IN3 w0.254: v1(259.6,53.3) 259.14,53.3 258.6,53.85 255.73,53.85 255.35,53.47 249.71,53.47 249.54,53.31 249.54,53.31 249.04,52.81 248.1,52.81 246.12,50.82 246.12,49.4 242.98,46.26 242.98,44.27 239.16,40.45 231.86,40.45 230.47,39.06 229.01,39.06 v1(228.85,38.9)
  BOTTOM w0.254: PR113.1 223,67.81 v3(222.99,67.82) ; v1(234.23,46.09) 233.64,46.09 231.81,44.27 231.81,43.98 231.08,43.25 231.08,42.09 229.18,40.2 229.18,39.23 v1(228.85,38.9)
AUD_HP_NB_SENSE: length 314.9
  TOP w0.254: v1(33.79,101.78) 33.77,101.81 33.77,102.49 QA1.2 34.39,102.58 34.73,102.24 CA41.1 35.73,102.24 36.42,102.94 v2(36.77,102.94) 39.54,102.94 v1(40.11,102.36) ; UE1.A41 254.75,73.92 v1(254.75,73.24) ; RA2.1 v1(12.14,98.12)
  IN1 w0.254: v1(12.14,98.12) 14.72,100.7 25.06,100.7 25.59,100.17 29.62,100.17 30.11,100.66 30.63,100.66 31.75,101.78 v1(33.79,101.78)
  IN2 w0.254: JHP1.6 10.18,90.07 11.39,91.28 14.69,91.28 v1(15.07,90.9) ; v1(40.11,102.36) 41.44,102.36 43.42,104.35 58,104.35 58.38,104.73 63.75,104.73 64.35,105.32 74.03,105.32 74.2,105.16 77.04,105.16 77.43,104.77 98.13,104.77 99.42,103.48 101,103.48 103.11,101.37 103.11,99.8 103.67,99.24 104.81,99.24 106.11,100.54 109.35,100.54 111.73,98.15 116.17,98.15 116.72,98.7 124.69,98.7 128.3,102.3 132.98,102.3 133.57,101.72 136.27,101.72 138.48,99.51 138.48,97.29 139.58,96.18 139.58,92.99 140.02,92.56 141.75,92.56 141.88,92.68 146.87,92.68 147.56,91.99 148.84,91.99 149.33,91.51 155.13,91.51 155.61,91.02 156.84,91.02 157.37,90.5 157.37,89.27 158.14,88.5 168.08,88.5 168.95,87.63 173.67,87.63 174.83,88.79 178.83,88.79 180.27,87.35 186.26,87.35 188.21,89.31 193.12,89.31 199.91,96.1 216.61,96.1 218.67,94.05 222.6,94.05 240.36,76.28 242.23,76.28 244.28,74.23 248.32,74.23 248.6,73.94 248.6,73.9 249.29,73.9 249.92,74.54 253.77,74.54 254.75,73.56 v1(254.75,73.24) ; v1(33.79,101.78) 33.19,101.78 32.6,101.2 30.56,101.2 28.55,99.19 28.55,92.13 28.13,91.71 25.74,91.71 24.6,90.57 20.97,90.57 20.76,90.36 18.43,90.36 v1(18.25,90.19)
  BOTTOM w0.254: v1(15.07,90.9) 15.75,90.22 17.11,90.22 17.2,90.13 18.2,90.13 v1(18.25,90.19)
AUD_HP_OUT_L: length 30.1
  TOP w0.381: LA2.1 16.83,89.91 v1(17.54,90.62) ; CA43.2 27.85,100.76 v1(27.8,100.71) ; RA7.2 16.92,95.51 v1(16.92,95.9)
  IN1 w0.381: v1(17.54,90.62) 16.92,91.24 v1(16.92,95.9)
  IN2 w0.381: v1(17.54,90.62) 17.11,91.05 17.11,92.01 18.14,93.04 v1(20.56,93.04)
  IN4 w0.381: v1(27.8,100.71) 27.08,101.44 20.26,101.44 16.92,98.1 v1(16.92,95.9)
  BOTTOM w0.381: v1(20.56,93.04) 20.87,93.35 RA24.1
AUD_HP_OUT_L1: length 15.2
  TOP w0.127: v2(15.76,90.64) 16.08,90.32 LA2.2
  TOP w0.381: LA2.2 16.08,88.86 16.05,88.83 CA3.1 16.05,88.14 16.55,87.65 17.26,87.65 17.67,87.24 v1(17.67,87)
  BOTTOM w0.381: v1(17.67,87) 17.67,86.69 17.3,86.32 DA3.3 15.56,86.32 14.16,84.93 14.16,81.35 13.38,80.57 JHP1.1
AUD_HP_OUT_R: length 25.2
  TOP w0.381: v1(17.74,91.76) 17.18,92.32 LA3.1 ; v1(26.92,100.69) 26.92,101.11 CA44.2 ; v1(17.61,96.81) RA8.2
  IN1 w0.381: v1(17.74,91.76) 18.07,92.09 18.07,96.36 v1(17.61,96.81)
  IN2 w0.381: v1(17.74,91.76) 18.02,91.48 v1(21.64,91.48)
  IN4 w0.381: v1(26.92,100.69) 26.92,100.46 26.58,100.12 25.74,100.12 25.07,100.79 20.64,100.79 17.61,97.77 v1(17.61,96.81)
  BOTTOM w0.381: v1(21.64,91.48) 21.92,91.2 RA25.1
AUD_HP_OUT_R1: length 18.7
  TOP w0.381: v1(16.15,93.09) LA3.2 ; JHP1.2 7.67,90.07 7.67,90.49 9.14,91.96 v2(11.42,91.96) 15.3,91.96 16,91.26 v1(16.19,91.26)
  BOTTOM w0.381: v1(16.15,93.09) 16.21,93.03 DA1.2 17.18,92.22 17.31,92.34 18.55,92.34 19.01,91.89 CA2.1 18.53,91.73 18,91.2 16.26,91.2 v1(16.19,91.26)
AUD_NB_MUTE#: length 300.1
  TOP w0.102: v1(12.75,94.52) 12.08,93.84 QA2.2 11.13,93.84 CA31.1 v2(8.8,93.14) ; v1(33.93,91.23) 33.93,91.05 31.8,88.92 RA18.2 30.29,89.45 30.29,90.95 29.96,91.28 29.06,91.28 28.91,91.43 UA1.48 ; v1(253.84,73.26) 253.67,73.42 UE1.A39
  IN1 w0.089: v1(12.75,94.52) 13.88,94.52 14.85,93.55 14.85,91.81 16.54,90.12 17.72,90.12 18.48,89.35 23.31,89.35 25.31,91.35 33.81,91.35 v1(33.93,91.23)
  IN2 w0.122: v1(253.84,73.26) 253.24,73.85 250.27,73.85 249.07,72.64 248.22,72.64 247.57,73.29 243.63,73.29 v1(243.41,73.5)
  IN3 w0.122: v1(241.29,94.4) 241.38,94.4 241.69,94.08 241.69,93.54 241.01,92.85 241.01,92.71 239.86,91.56 225.15,91.56 224.03,92.68 207.47,92.68 195.46,104.7 188.45,104.7 188.37,104.61 179.54,104.61 179.33,104.4 159.97,104.4 159.35,103.77 154.62,103.77 154.37,104.03 127.7,104.03 126.19,102.52 105.02,102.52 103.89,103.65 98.51,103.65 97.54,104.63 78.04,104.63 77.7,104.97 74.37,104.97 74.05,105.29 64.35,105.29 63.59,104.53 60.01,104.53 59.5,105.04 58.03,105.04 57.01,104.03 44.7,104.03 37.5,96.83 37.5,96.46 35.66,94.61 35.66,94.04 34.49,92.88 34.49,91.79 v1(33.93,91.23)
  BOTTOM w0.102: v1(243.41,73.5) 243.55,73.5 244.76,74.72 244.76,76.35 243.65,77.46 243.65,81.69 243.79,81.83 243.79,82.58 242.74,83.63 242.74,85.6 240.98,87.35 240.98,89.21 241.69,89.92 241.69,94.05 241.34,94.4 v1(241.29,94.4)
AUD_OUT_L: length 6.2
  TOP w0.203: UA1.33 23.24,93.81 23.1,93.67 23.04,93.67 22.99,93.61 22.81,93.61 22.74,93.55 22.66,93.55 22.45,93.35 22.11,93.35 21.74,93.72 21.23,93.72
  TOP w0.381: RA7.1 18.53,94.38 v2(19.06,93.84) 19.19,93.72 21.23,93.72
AUD_OUT_R: length 6.1
  TOP w0.203: UA1.32 22.93,94.21 22.61,93.88 v1(22.3,93.88)
  TOP w0.381: v1(19.47,95.82) RA8.1
  IN2 w0.381: v1(22.3,93.88) 20.36,95.82 v1(19.47,95.82)
AUD_PC_BEEP: length 5.6
  TOP w0.102: CA28.2 CA27.2 33.35,98.5 v2(31.36,98.5) 31.36,97.94 30.43,97.01 UA1.12
AUD_SENSE_A: length 5.8
  TOP w0.203: UA1.13 28.91,98.2 29.1,98.39
  TOP w0.254: 29.1,98.39 30.09,98.39 31.27,99.57 v2(32.4,99.57) 33.21,100.38 QA1.1
AUD_SENSE_B: length 10.7
  TOP w0.203: UA1.14 28.51,98.32 29.26,99.08 v2(29.63,99.08) 30.09,99.08 v1(30.43,99.42)
  BOTTOM w0.254: RA38.1 29.44,101.32 30.43,100.33 v1(30.43,99.42) 30.43,97.72 RA28.1 RA27.1
AUX_EN_WOWL: length 59
  TOP w0.102: UZ3.3 275.01,62 275.12,62.11 275.12,62.55 274.8,62.87 273.52,62.87 RZ38.2 273.99,63.57 v1(274.08,63.57) 274.21,63.69 v2(274.74,63.69) 279.31,63.69 280.31,62.69 280.31,55.57 281.28,54.6 282.89,54.6 283.26,54.23 283.26,53.72 283.92,53.06 283.92,50.87 284.39,50.4 284.39,48.47 284.67,48.18 UZ11.1 ; v1(257.81,80.65) 258.36,81.2 258.36,82.57 258.73,82.94 UE1.B67
  IN4 w0.089: v1(257.81,80.65) 257.81,80.13 258.11,79.82 258.66,79.82 260.81,77.68 261.25,77.68 261.81,77.12 261.81,76.7 262.24,76.27 262.24,75.28 262.45,75.07 262.45,72.46 264.88,70.02 269.85,70.02 272.4,67.46 272.4,65.24 v1(274.08,63.57)
B-RAMP: length 4.7
  TOP w0.127: v3(103.8,73.98) 103.8,74.62 v2(103.67,74.74)
  TOP w0.254: PR507.2 104.43,73.35 v3(103.8,73.98)
  BOTTOM w0.203: v3(103.8,73.98) 104.01,73.77 PU500.11
  BOTTOM w0.254: PR502.1 103.67,74.11 v3(103.8,73.98)
BAT1_LED#: length 44
  TOP w0.254: RZ28.1 291.68,43.75 v1(291.34,43.41) ; UE2.B1 262.74,55.5 263.12,55.12 263.5,55.12 264.54,54.08 264.54,53.71 v1(264.66,53.6)
  IN3 w0.254: v1(265.34,42.74) 265.68,43.08 268.03,43.08 270.14,40.97 288.9,40.97 v1(291.34,43.41)
  BOTTOM w0.254: v1(265.34,42.74) 264.8,43.28 v2(264.8,44.39) 264.8,53.46 v1(264.66,53.6)
BAT2_LED#: length 51.4
  TOP w0.254: v1(256.96,53.28) 256.96,53.66 257.1,53.8 UE2.A55
  IN1 w0.254: v1(289.64,55.57) 289.32,55.25 282.02,55.25 280.53,56.73 269.94,56.73 268.81,55.6 267.55,55.6 265.01,53.06 260.97,53.06 260.17,53.87 257.71,53.87 257.12,53.28 v1(256.96,53.28)
  IN2 w0.254: v1(292.04,43.26) 292.4,43.63 292.4,47.04 290.49,48.96 290.49,53.66 289.64,54.51 v1(289.64,55.57)
  BOTTOM w0.102: v2(257.09,53.91) 257.09,53.41 v1(256.96,53.28)
  BOTTOM w0.254: v1(292.04,43.26) 292.06,43.26 292.33,42.99 RZ25.1
BATDRV#: length 42.2
  TOP w0.102: v1(89.61,68.98) v2(89.61,68.23)
  IN1 w0.508: v1(89.61,68.98) 87.05,68.98 84.95,71.07 80.95,71.07 v3(80.3,70.42)
  IN2 w0.508: v1(89.61,68.98) 89.82,68.77 93.64,68.77 93.91,68.5 94.81,68.5 94.82,68.49 95.64,68.49 97.84,70.69 97.84,74.26 98.45,74.87 98.98,74.87 100.41,76.3 104.53,76.3 105.77,77.54 105.77,81.59 106.59,82.41 107.58,82.41 v3(107.76,82.24)
  BOTTOM w0.508: v3(107.76,82.24) 107.76,82.44 107.81,82.49 PQ800.4 ; PR722.2 v3(80.3,70.42)
BATT_WHITE#: length 6.4
  TOP w0.102: v2(292.57,45) 292.98,44.59 293.87,44.59 294.4,44.06 v1(294.4,43.93) 295.58,42.75 JLED1.5
  BOTTOM w0.102: v1(294.4,43.93) 294.2,43.93 293.61,43.35 RZ25.2
BATT_YELLOW#: length 4.9
  TOP w0.102: JLED1.4 295.08,42.66 293.99,43.75 RZ28.2 293.69,43.4 292.93,42.64 v2(292.24,42.64)
BBS_BIT: length 11
  TOP w0.076: v1(164.7,64.35) 164.7,64.49 165.01,64.8 168.53,64.8 169.1,64.23 171.77,64.23
  TOP w0.102: 171.77,64.23 173.93,64.23 T109.1
  BOTTOM w0.076: UC1.L8 164.4,64.04 v1(164.7,64.35)
BC_CLK_ECE1117: length 72.5
  TOP w0.102: v1(243.79,46.36) 243.79,46.59 v2(244.13,46.93) ; v1(232.61,33.92) 232.8,33.74 JKBTP1.7 ; v1(259.6,66.32) 259.6,66.3 260.1,65.8 UE2.A20
  IN2 w0.122: v1(232.61,33.92) 232.33,34.21 232.33,34.35 232.91,34.93 233.04,34.93 233.5,34.47 233.64,34.47 233.91,34.74 233.91,34.88 233.46,35.34 233.46,35.48 233.66,35.68 233.8,35.68 234.32,35.17 234.49,35.17 234.66,35.34 234.66,35.51 234.41,35.77 234.41,35.91 234.61,36.11 234.76,36.11 235.01,35.86 235.18,35.86 235.35,36.03 235.35,36.2 234.96,36.6 234.96,36.74 235.16,36.94 235.3,36.94 235.7,36.55 235.87,36.55 236.04,36.72 236.04,36.89 235.94,36.99 235.94,37.14 236.14,37.34 236.29,37.34 236.39,37.24 236.56,37.24 236.73,37.41 236.73,37.58 236.39,37.92 236.39,38.07 236.59,38.27 236.74,38.27 237.08,37.93 237.25,37.93 237.42,38.1 237.42,38.27 237.05,38.65 237.05,38.79 237.25,38.99 237.39,38.99 237.77,38.62 237.94,38.62 239.07,39.75 239.07,41.93 240.65,43.51 240.65,44.19 242.82,46.36 v1(243.79,46.36)
  BOTTOM w0.102: v1(243.79,46.36) 244.09,46.66 244.24,46.66 244.78,46.12 244.92,46.12 245.07,46.27 245.07,46.41 244.53,46.95 244.53,47.09 244.67,47.24 244.81,47.24 245.41,46.64 245.56,46.64 245.7,46.78 245.7,46.93 245.1,47.53 245.1,47.67 245.24,47.81 245.39,47.81 245.77,47.43 245.91,47.43 246.06,47.58 246.06,48.84 249.22,52.01 249.22,52.14 250.51,53.42 251.91,53.42 252.43,53.94 253.01,53.94 253.17,54.1 253.31,54.1 254.4,53.02 254.54,53.02 254.68,53.16 254.68,53.31 253.6,54.39 253.6,54.53 253.75,54.68 253.89,54.68 254.75,53.82 254.9,53.82 255.04,53.96 255.04,54.1 254.18,54.97 254.18,55.11 254.43,55.36 254.43,57.12 254.46,57.15 254.46,57.52 255.03,58.09 255.03,60.43 257.39,62.79 257.39,63.72 257.69,64.02 257.69,64.16 256.87,64.99 256.87,65.13 257.01,65.28 257.15,65.28 257.98,64.45 258.12,64.45 258.27,64.6 258.27,64.74 257.27,65.73 257.27,65.88 257.42,66.02 257.56,66.02 258.56,65.03 258.7,65.03 259.11,65.43 259.11,65.83 v1(259.6,66.32)
BC_CLK_ECE5048: length 39.1
  TOP w0.102: v1(250.96,58.66) 251.37,58.25 UE2.A43 ; UE1.A30 v1(248.24,76.69)
  IN1 w0.089: v1(247.64,59.73) 248.72,58.65 249.83,58.65 249.85,58.66 v1(250.96,58.66)
  IN4 w0.089: v1(248.24,76.69) 247.94,76.69 247.82,76.56 247.82,74.17 247.69,74.04 245.02,74.04 244.89,73.92 244.89,71.88 245.02,71.76 246.86,71.76 246.99,71.63 246.99,71.39 246.89,71.29 244.93,71.29 244.83,71.18 244.83,71.04 244.93,70.93 248.2,70.93 248.42,70.71 248.42,69.09 248.29,68.96 246.86,68.96 246.74,68.84 246.74,68.58 246.86,68.46 248.29,68.46 248.42,68.33 248.42,64.4 248.71,64.11 248.71,63.77 248.36,63.43 247.33,63.43 247.06,63.15 247.06,60.31 v1(247.64,59.73)
  BOTTOM w0.102: v2(247.05,60.14) 247.23,60.14 v1(247.64,59.73)
BC_DAT_ECE1117: length 72.8
  TOP w0.102: v1(232.73,32.53) 232.94,32.74 JKBTP1.9 ; RPE5.2 265.48,58.74 v1(265.16,59.06) ; v1(267.23,44.6) 263.09,44.6 262.42,45.28 252.32,45.28 v2(250.89,46.71) 250.13,47.47 248.1,47.47 247.69,47.88 244.21,47.88 239.48,43.16 v1(239.48,43.14) ; UE2.B21 260.35,62.73 v1(260.24,62.62)
  IN2 w0.122: v1(232.73,32.53) 232.42,32.53 231.8,33.15 231.8,34.53 234.71,37.44 235.54,37.44 235.89,37.8 235.89,38.34 238.37,40.82 238.37,42.02 v1(239.48,43.14)
  IN4 w0.089: v1(267.23,44.6) 267.04,44.6 266.3,45.34 266.3,47.49 266.67,47.87 266.67,52.29 266.43,52.53 266.43,57.79 v1(265.16,59.06) 264.74,59.48 263.82,59.48 263.81,59.49 263.74,59.49 262.7,60.53 261.04,60.53 260.24,61.33 v1(260.24,62.62)
BC_DAT_ECE5048: length 41.9
  TOP w0.102: RE36.2 247.07,60.07 v1(247.07,58.77) ; v1(251.13,77.64) 251.13,77.46 250.61,76.94 UE1.B31 ; UE2.B45 253.85,58.5 v1(253.99,58.36)
  IN1 w0.089: v1(251.13,77.64) 251.13,77.36 250.48,76.71 249.16,76.71 248.55,76.1 246.13,76.1 244.42,77.8 v1(244.14,77.8) ; v1(247.07,58.77) 247.57,58.26 252.67,58.26 252.73,58.32 253.95,58.32 v1(253.99,58.36)
  BOTTOM w0.102: v1(244.14,77.8) 245.17,76.78 245.17,74.55 244.21,73.59 244.21,70.81 243.67,70.27 v2(243.67,65.66) 243.67,63.64 244.36,62.96 244.36,61.69 245.7,60.35 245.7,60.13 v1(247.07,58.77)
BC_INT#_ECE1117: length 77.8
  TOP w0.102: v1(232.77,39.89) 231.83,39.89 231.52,39.59 225.62,39.59 224.96,38.93 223.15,38.93 v1(222.68,38.46) ; UE2.A19 v2(260.6,66.18) 260.77,66.35 v1(261.24,66.35) ; v1(234.53,32.48) 234.3,32.24 JKBTP1.10
  IN3 w0.122: v1(222.68,38.46) 222.73,38.46 229.25,44.97 229.7,44.97 229.93,44.74 236.45,44.74 238.66,46.95 238.66,49.96 239.25,50.55 239.25,54.13 245.91,60.79 245.91,62.5 246.85,63.44 249.16,63.44 250.08,62.52 251.8,62.52 252.41,63.14 252.41,63.51 253.77,64.87 259.75,64.87 261.22,66.35 v1(261.24,66.35)
  IN4 w0.089: v1(234.53,32.48) 233.86,33.15 233.86,38.8 v1(232.77,39.89)
BC_INT#_ECE5048: length 26.7
  TOP w0.102: v1(251.54,58.74) 251.54,58.74 251.56,58.74 251.57,58.75 UE2.A42 ; UE1.A29 247.66,77.19 247.35,76.88 v1(247.35,76.8) 247.18,76.63 v2(247.18,76.14)
  BOTTOM w0.102: v1(251.54,58.74) 251.54,58.74 251.11,59.17 250.72,59.17 248.96,60.94 248.96,62.97 248.64,63.29 246.67,63.29 245.43,64.52 245.43,65.32 244.81,65.95 244.81,69.93 245.17,70.3 245.17,73.18 246.3,74.32 246.3,75.76 v1(247.35,76.8)
BCM5882_ALERT#: length 89
  TOP w0.102: v2(249.09,47.95) 249.5,48.36 v1(249.5,48.38) ; JUSH1.14 239.27,18.8 v1(239.31,18.76) ; UE1.B62 v1(258.35,80.44)
  IN2 w0.122: v1(249.5,48.38) 248.62,47.49 246.15,47.49 241.4,42.74 240.94,42.74 239.82,41.62 239.82,35.35 239.48,35.01 239.48,23.77 240.2,23.05 240.2,19.65 v1(239.31,18.76)
  BOTTOM w0.102: v1(249.5,48.38) 249.94,47.95 260.78,47.95 263.03,50.19 263.03,53.72 262.66,54.09 262.66,54.79 262.8,54.93 262.8,56.61 262.29,57.11 262.29,57.12 261.82,57.6 260.65,57.6 258.64,59.61 258.64,62.17 259.18,62.72 259.18,63.99 260.63,65.43 260.63,66 260.82,66.19 260.82,67.63 260.63,67.82 260.63,70.26 259.86,71.02 259.86,72.37 259.41,72.82 259.41,79.38 v1(258.35,80.44)
BEEP: length 277.9
  TOP w0.102: v2(38.01,100.93) 37.41,100.93 v1(37.02,100.54) 36.82,100.33 RA13.2 ; UE2.B19 261.35,63.54 v1(261.19,63.38)
  IN3 w0.122: v1(37.02,100.54) 37.72,101.23 39.9,101.23 43.79,105.12 56.67,105.12 58.28,106.73 77.71,106.73 78.8,105.65 98.07,105.65 99.08,104.65 104.39,104.65 105.52,103.52 125.78,103.52 128.08,105.81 134.5,105.81 135.18,105.13 144.92,105.13 145.88,106.1 181.06,106.1 181.46,105.7 181.46,105.67 181.58,105.54 191.62,105.54 192.32,106.24 196.15,106.24 208.92,93.47 224.49,93.47 224.84,93.12 229.3,93.12 229.59,93.41 234.42,93.41 234.78,93.06 239.41,93.06 240.77,94.41 240.77,95.16 241.02,95.42 243.56,95.42 244.46,96.32 248.25,96.32 248.89,95.67 253.28,95.67 253.92,96.32 256.92,96.32 258.29,97.69 259.37,97.69 v1(260.22,98.54)
  BOTTOM w0.102: v1(261.19,63.38) 261.67,63.86 261.67,66.72 261.49,66.89 261.49,68.47 260.86,69.1 260.86,70.37 260.11,71.12 260.11,72.47 259.72,72.86 259.72,74.26 260.32,74.87 260.32,80.08 260.11,80.29 260.11,88.36 260.77,89.02 260.77,98 v1(260.22,98.54)
BIA_PWM: length 6.2
  TOP w0.102: DV1.1 88.24,98.47 RV1.1 88.94,97.75 v1(88.84,97.65)
  BOTTOM w0.102: v1(88.84,97.65) 90,96.48 v2(91.12,96.48) 91.54,96.91 LV1.2
BIA_PWM_EC: length 370.4
  TOP w0.102: v1(258.74,62.85) 258.27,63.32 258.27,63.74 258.35,63.82 UE2.B25 ; v1(86.37,94.81) 86.37,95.42 87.12,96.17 DV1.2
  IN2 w0.122: v1(86.37,94.81) 86.37,95.9 82.64,99.63 75.16,99.63 74.04,100.75 66.04,100.75 65.49,100.21 61.04,100.21 60.27,99.44 50.57,99.44 49.49,98.36 47.33,98.36 38.04,89.07 38.04,83.63 36.79,82.39 36.79,79.8 37.6,78.98 55.98,78.98 57.63,77.33 60.22,77.33 63.03,74.51 72.88,74.51 73.92,73.47 73.92,72.59 73.93,72.58 73.93,67.4 73.93,66.33 78.43,61.83 80.03,61.83 v1(80.06,61.8)
  IN3 w0.122: v1(258.74,62.85) 258.73,62.85 258.28,63.31 258.28,63.61 258.04,63.86 254.16,63.86 253.45,63.15 253.45,62.77 252.83,62.15 252.83,61.04 252.4,60.61 252.4,60.07 251.94,59.6 250.58,59.6 250.58,59.6 250.57,59.6 250.01,60.16 247.21,60.16 246.25,59.19 246.25,58.57 243.47,55.79 243.18,55.79 242.32,54.93 242.32,54.64 241.04,53.36 241.04,52.09 240.24,51.3 240.24,49.97 239.66,49.39 239.66,46.54 236.87,43.75 231.09,43.75 230.45,43.11 228.8,43.11 226.05,40.36 226.05,37.76 226.05,35.37 225.71,35.03 218.05,35.03 217.03,36.05 208.85,36.05 198.31,25.5 105.61,25.5 104.86,24.75 99.83,24.75 96.5,21.43 92.87,21.43 92.2,22.09 88.2,22.09 87.63,22.66 85.32,22.66 84.76,22.1 83.99,22.1 83.73,22.35 83.73,28.3 85.46,30.03 85.46,51.81 84.35,52.91 84.35,55.9 80.74,59.51 80.74,61.03 80.32,61.45 80.32,61.54 v1(80.06,61.8)
  BOTTOM w0.102: v2(79.82,62.35) 80.06,62.11 v1(80.06,61.8)
BLUE: length 13.1
  TOP w0.102: v2(261.87,107.38) LV18.2 260.56,107.46 CV56.1 259.42,107.51 DV6.2 259.42,113.67 261.28,115.52 261.28,115.78 JCRT1.3
BLUE_2320: length 24.9
  TOP w0.102: UV16.5 177.69,91.97 177.43,91.71 177.43,91.34 v1(177.85,90.92) ; RV78.1 162.85,88.34 v1(162.19,89) 162.19,89.33 161.3,90.21 161.3,91.14 UV8.M8
  BOTTOM w0.102: v1(162.19,89) v2(163.5,87.69) 163.67,87.52 168.28,87.52 168.72,87.07 170.57,87.07 171.06,87.56 175.18,87.56 178,90.38 178,90.77 v1(177.85,90.92)
BLUE_CRT: length 96.8
  TOP w0.102: UV16.22 178.09,96.38 178.56,96.85 178.56,97.61 178.71,97.77 181.57,97.77 182.16,97.18 v1(182.16,97.16) ; v1(261.51,98.52) 261.51,100.27 260.59,101.18 RV34.1 CV53.1 260.59,106.57 LV18.1
  IN1 w0.089: v1(182.16,97.16) 182.22,97.22 185.95,97.22 187.68,98.95 190.31,98.95 190.8,98.45 201.18,98.45 201.36,98.28 225.76,98.28 226.22,98.73 229.15,98.73 229.56,99.15 239.83,99.15 240.8,100.11 241.84,100.11 242.7,100.11 243.21,100.62 249.39,100.62 250.77,99.24 260.78,99.24 v1(261.51,98.52)
