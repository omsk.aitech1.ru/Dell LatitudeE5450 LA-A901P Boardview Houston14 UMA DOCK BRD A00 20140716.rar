# Allegro board Houston14_UMA_DOCK_BRD_A00_20140716.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SIO_SLP_S3#: length 189.3
  TOP w0.102: UE2.A35 252.17,62.25 251.89,62.54 251.49,62.54 v1(250.99,62.04) ; v1(226.67,77.85) v2(225.91,77.85)
  IN2 w0.086: v1(167.28,50.64) 168.11,49.81 168.11,46.24 169.41,44.94 170.65,44.94
  IN2 w0.122: v1(250.99,62.04) 250.68,62.04 250.3,61.65 250.3,58.72 249.81,58.24 248.91,58.24 247.91,59.24 247.17,59.24 246.49,59.91 244.13,59.91 243.45,60.59 242.3,60.59 241.92,60.21 237.16,60.21 v1(236.47,60.9) ; v1(215.76,35.63) 215.38,36 201.9,36 201.64,35.74 187.09,35.74 186.34,36.49 185.56,36.49 179.21,42.84 176.93,42.84 174.83,44.94 170.65,44.94
  IN4 w0.089: v1(226.76,46.01) 228.53,47.78 235.76,47.78 236.93,48.95 236.93,57.48 237.87,58.42 237.87,59.5 v1(236.47,60.9) 236.47,61.05 236.88,61.46 236.88,64.61 233.5,67.99 233.5,74.88 231.81,76.57 227.95,76.57 v1(226.67,77.85) ; v1(250.99,62.04) 250.99,62.01 251.44,61.56 251.5,61.56 251.5,61.57 251.83,61.57 252.09,61.31 252.09,55.81 250.98,54.7 250.98,52.04 252.16,50.85 254.03,50.85 255.46,49.43 255.46,46.95 255.82,46.59 258.12,46.59 258.9,45.8 259.68,45.8 260.08,46.21 261.75,46.21 v1(261.77,46.23)
  BOTTOM w0.076: v1(167.28,50.64) 167.03,50.4 UC1.AT4
  BOTTOM w0.102: v1(215.76,35.63) 216.09,35.3 222.59,35.3 224.19,36.9 224.19,40.55 226.76,43.12 v1(226.76,46.01) ; v1(226.67,77.85) 226.69,77.88 JAPS1.2 ; RE280.1 262.65,60.29 263.39,59.55 263.39,57.27 263.49,57.17 263.49,55.03 263.77,54.75 263.77,53.69 263.52,53.44 263.52,49.8 261.77,48.05 v1(261.77,46.23)
SIO_SLP_S4#: length 164
  TOP w0.076: 172.84,54.2 172.38,53.74 v1(171.72,53.74)
  TOP w0.102: v1(253.91,63.02) 253.89,63.02 253.91,63 UE2.B36 ; T9.1 172.84,54.2
  IN1 w0.086: v1(171.72,53.74) 171.63,53.74 170.68,54.69 169.37,54.69 168.28,55.78 167.26,55.78 166.85,55.37 166.32,55.37 165.98,55.03 v1(165.98,54.85)
  IN1 w0.089: v1(253.91,63.02) 253.91,63.43 252.55,64.79 247.36,64.79 247.14,64.57 241.72,64.57 241.26,65.03 237.9,65.03 v1(235.78,67.15)
  IN2 w0.122: v1(253.91,63.02) 254.03,63.02 256.14,60.9 256.14,57.95 257.15,56.94 260.63,56.94 261.28,56.3 261.28,54.89 261.92,54.24 263.27,54.24 v1(263.35,54.32)
  IN4 w0.086: 172.84,53.74 v1(171.72,53.74)
  IN4 w0.089: 172.84,53.74 173.85,53.74 174.91,52.68 176.8,52.68 177.1,52.38 181.55,52.38 181.62,52.31 184.76,52.31 185.25,52.8 187.58,52.8 187.74,52.64 190.26,52.64 190.56,52.34 192.66,52.34 193.93,51.07 198.12,51.07 199.81,49.38 199.81,46.33 202.61,43.53 202.64,43.53 207.48,38.69 212.24,38.69 213.7,40.15 224.64,40.15 228.03,43.54 229.04,43.54 229.49,44 v1(229.49,44.55)
  BOTTOM w0.076: UC1.AJ6 165.7,54.5 165.98,54.78 v1(165.98,54.85)
  BOTTOM w0.102: v1(229.49,44.55) 229.49,44.8 232.92,48.22 234.62,48.22 235.88,49.48 235.88,54.97 237.69,56.79 237.69,58.21 238.13,58.64 238.13,59.23 238.12,59.23 238.12,60.32 237.71,60.74 237.71,65.06 v2(236.27,66.5) 235.78,66.99 v1(235.78,67.15) 234.75,68.18 234.75,69.54 232.51,71.78 232.51,74.78 230.82,76.47 228.89,76.47 228.19,77.17 JAPS1.5 ; v1(263.35,54.32) 263.26,54.41 263.26,56.99 262.89,57.36 RE282.2
SIO_SLP_S5#: length 172.8
  TOP w0.076: T8.1 169.67,43.82 169.67,44.7 169.04,45.32 169.04,45.68 168.24,46.48 168.24,48.28 166.92,49.6 166.92,50.75 v1(166.53,51.13)
  TOP w0.102: UE2.A18 261.1,65.64 v1(261.15,65.69)
  IN2 w0.122: v1(209.23,39.83) 208.9,40.16 207,40.16 207,40.15 199.09,40.15 198.95,40.01 196.75,40.01 196.13,40.63 193.27,40.63 192.43,39.79 190.42,39.79 190.4,39.78 187.09,39.78 185.38,41.49 185.38,42.33 184.44,43.26 183.36,43.26 v1(182.99,42.89)
  IN3 w0.089: 170.65,45.57 167.34,48.88 167.34,50.07 166.91,50.49 166.91,50.75 v1(166.53,51.13)
  IN3 w0.122: 170.65,45.57 173.2,43.02 182.87,43.02 v1(182.99,42.89) ; v1(229.01,44.11) 230.39,44.11 230.78,44.5 236.56,44.5 238.91,46.85 238.91,49.81 239.5,50.4 239.5,54.03 243.5,58.03 244.53,58.03 245.45,58.95 245.45,59.45 247.05,61.05 248.57,61.05 249.1,61.58 251.83,61.58 252.08,61.83 252.08,62.46 252.66,63.03 252.66,63.41 253.87,64.62 260.09,64.62 v1(261.15,65.69)
  IN4 w0.089: v1(209.23,39.83) 209.91,40.5 224.6,40.5 228.15,44.05 228.87,44.05 228.93,44.11 v1(229.01,44.11)
  BOTTOM w0.076: v1(166.53,51.13) 166.52,51.14 166.52,51.17 166.19,51.51 UC1.AP5
  BOTTOM w0.102: v1(229.01,44.11) 229.01,44.87 232.59,48.45 234.53,48.45 235.65,49.58 235.65,55.07 237.46,56.89 237.46,58.3 237.9,58.73 237.9,59.13 237.9,60.22 237.45,60.67 237.45,64.11 234.37,67.19 234.37,69.6 232.28,71.68 232.28,74.68 230.75,76.22 228.73,76.22 227.69,77.25 JAPS1.4
SIO_SLP_SUS#: length 115.5
  TOP w0.102: v1(253.98,55.57) 253.98,55.31 253.85,55.18 UE2.B52
  IN2 w0.086: v1(170.06,51.67) 168.95,50.56 168.95,46.93 170.17,45.71 170.65,45.71
  IN2 w0.122: 170.65,45.71 174.87,45.71 177.24,43.34 179.49,43.34 185.73,37.09 186.44,37.09 187.29,36.24 196.44,36.24 197.64,37.43 199.64,37.43 200.27,36.81 215.89,36.81 217.91,34.79 226.22,34.79 234.21,42.79 234.21,43.58 238.56,47.93 238.56,49.09 240.75,51.28 244.91,51.28 245.11,51.08 250.68,51.08 250.79,51.19 254.5,51.19 v1(254.51,51.17)
  IN4 w0.089: v1(253.98,55.57) 253.98,54.49 255.46,53.01 255.46,51.67 254.97,51.17 v1(254.51,51.17)
  BOTTOM w0.076: UC1.AP4 167.34,51.37 167.81,51.37 167.86,51.32 168.52,51.32 168.68,51.47 169.19,51.47 169.35,51.31 169.7,51.31 v1(170.06,51.67)
  BOTTOM w0.102: v2(253.78,51.25) 254.44,51.25 v1(254.51,51.17)
SIO_SLP_WLAN#: length 146
  TOP w0.102: v1(252.72,86.17) 252.18,85.64 252.01,85.64 251.67,85.3 UE1.A14
  IN2 w0.086: v1(166.51,52.4) 167.13,52.4 167.24,52.51 168.17,52.51 168.38,52.3 168.38,51.39 168.41,51.35 168.41,46.21 169.43,45.19 170.65,45.19
  IN2 w0.122: v1(245.48,50.36) 244.81,51.03 240.85,51.03 238.87,49.05 238.87,47.89 234.46,43.48 234.46,42.68 226.32,34.54 217.81,34.54 215.79,36.56 200.16,36.56 199.71,37.01 199.54,37.19 197.88,37.19 196.68,35.99 187.19,35.99 186.34,36.85 185.59,36.85 179.34,43.09 177.11,43.09 175,45.19 170.65,45.19
  BOTTOM w0.076: v1(166.51,52.4) 166.1,52.81 UC1.AM5
  BOTTOM w0.102: v1(252.72,86.17) 252.79,86.1 252.79,82.67 252.69,82.57 252.69,77.57 253.38,76.88 253.38,75.47 251.24,73.33 251.24,71.02 v2(251.73,70.53) 252.22,70.04 252.22,65.42 250.58,63.78 250.58,61.02 250.9,60.71 251.25,60.71 251.28,60.68 251.87,60.68 252.6,59.95 252.6,56.54 250.91,54.85 249.22,54.85 248.06,53.69 246.61,53.69 246.3,53.38 246.3,52.36 245.48,51.54 v1(245.48,50.36)
SKIP#: length 5.6
  BOTTOM w0.102: PR520.2 100.32,73.17 99.86,72.71 98.21,72.71 v2(97.96,72.46)
  BOTTOM w0.203: 101.83,71.88 101.97,71.74 PU500.7
  BOTTOM w0.254: 101.83,71.88 100.5,73.22 PR520.2
SKIP#1: length 58.7
  TOP w0.102: v3(98.72,73.22) 98.84,73.35 v2(99.35,73.35)
  IN4 w0.254: v3(98.72,73.22) 99.48,73.98 99.48,74.46 100.41,75.39 104.48,75.39 106.81,77.71 110.31,77.71 111.78,76.24 117.03,76.24 117.92,77.13 117.92,91.56 119.47,93.11 130.38,93.11 131.15,92.33 131.15,87.16 v3(130.98,86.98)
  BOTTOM w0.203: PU501.1 130.54,87.39 130.95,86.98 v3(130.98,86.98)
  BOTTOM w0.254: PR520.1 v3(98.72,73.22)
SL_BAT_PRES#: length 6.5
  BOTTOM w0.102: PR854.1 104.61,52.34 105.02,51.93 105.02,51.17 104.53,50.69 104.53,49.01 v2(104.71,48.83)
  BOTTOM w0.254: PR854.1 103.4,53.37 PU800.21
SLATE_MODE: length 19.8
  TOP w0.076: v2(166.97,52.77) 166.97,52.92 166.76,53.14 v1(166.57,53.14)
  IN4 w0.086: 172.84,54.17 172.74,54.27 166.82,54.27 166.41,53.87 166.41,53.79 166.35,53.73 166.35,53.51 166.57,53.29 v1(166.57,53.14)
  IN4 w0.089: v1(182.23,53.85) 179.95,53.85 179.62,54.17 172.85,54.17 172.84,54.17
  BOTTOM w0.076: v1(166.57,53.14) 166.67,53.23 UC1.AL4
  BOTTOM w0.102: RPC10.6 183.3,54.43 183.1,54.22 182.56,54.22 182.23,53.89 v1(182.23,53.85)
SLEEVE: length 11.7
  TOP w0.457: v1(12.75,93.64) 12.3,93.19 QA2.3
  IN4 w0.508: v1(22.19,95.43) 20.83,95.43 18.66,93.26 17.08,93.26 16.4,93.94 13.06,93.94 v1(12.75,93.64)
  vias: v1(18.94,90.87) v1(19.52,90.87) v1(22.8,95.43)
SLEEVE_R:
  vias: v1(5.78,92.37)
SLEWA: length 6.5
  TOP w0.102: v2(108.76,74.04) v3(107.8,74.04)
  TOP w0.254: v3(107.8,74.04) 107.48,73.73 PR510.2
  BOTTOM w0.203: 106.11,73.73 105.61,73.23 PU500.15
  BOTTOM w0.254: PR500.1 108.24,74.49 v3(107.8,74.04) 107.48,73.73 106.11,73.73
SLICE_BAT_ON: length 197
  TOP w0.102: UE1.A31 247.99,76.19 247.47,75.67 247.32,75.67 246.77,75.12 v1(246.75,75.12) 246.74,75.14 246.71,75.14 246.21,75.63 RE17.2
  TOP w0.254: v3(99.76,50.65) 99.28,50.17 98.76,50.17 v2(98.2,50.73)
  IN3 w0.254: v1(246.75,75.12) 246.75,73.74 244.03,71.02 244.03,69.64 237.64,63.25 237.64,56.35 236.16,54.87 236.16,48.96 234.78,47.59 227.63,47.59 226.02,45.98 226.02,45.07 222.67,41.72 207.2,41.72 196.63,31.16 184.43,31.16 183.89,31.69 107.07,31.69 105.41,33.35 105.41,38.01 103.52,39.9 103.52,45.19 104.05,45.72 v3(104.05,45.61)
  IN4 w0.254: v3(99.76,50.65) 104.05,46.36 v3(104.05,45.61)
  BOTTOM w0.254: v3(99.76,50.65) 100.11,51.01 PR845.2
SLICE_BAT_PRES#: length 433.8
  TOP w0.254: RE5.2 246.27,74.34 247.64,74.34 248.26,74.96 248.26,75.05 v1(248.31,75.1) ; UE1.B33 250.28,75.94 v1(250.46,76.11) ; v1(86.04,6.06) 86.89,6.06 87.48,5.48 PR6.1
  IN1 w0.254: v1(248.31,75.1) 249.19,75.97 250.32,75.97 v1(250.46,76.11) ; v1(53.46,82.69) 59.04,82.69 61.7,80.03 73.06,80.03 73.37,79.72 73.37,79.02 73.14,78.79 v3(72.85,78.79)
  IN2 w0.254: v1(252.18,103.11) 252.18,103.53 251.27,104.45 241.15,104.45 240.51,105.08 226.14,105.08 224.32,103.27 205.07,103.27 199.28,109.06 185.15,109.06 184.57,109.64 184.57,110.68 183.55,111.7 v1(183.55,112.59)
  IN3 w0.254: v3(72.85,78.79) 73.16,78.48 73.16,77.22 76.4,73.98 77.2,73.98 78.16,73.03 78.16,72.68 79.48,71.35 83.41,71.35 87.3,67.46 88.6,67.46 90.97,65.09 96.38,65.09 97.76,63.71 97.76,63.06 99.03,61.79 103.53,61.79 104.16,61.15 v3(107.61,61.15) ; v1(51.96,107.13) 52.44,106.64 52.88,106.64 53.99,107.75 78.74,107.75 79.51,106.97 93.42,106.97 94.96,108.51 103.8,108.51 107.21,105.1 124.53,105.1 131.82,112.39 131.82,112.59 131.82,113.12 138.84,120.14 144.57,120.14 146.67,118.04 156.46,118.04 158.13,116.37 159.78,116.37 161.35,117.95 168.5,117.95 169.49,116.96 171.54,116.96 172.07,117.49 174.46,117.49 174.97,116.98 174.97,114.87 176.8,113.03 183.11,113.03 v1(183.55,112.59)
  IN4 w0.254: v3(107.61,61.15) 107.61,52.45 106.93,51.78 105.14,51.78 v3(103.99,50.62) 103.99,48.4 105.12,47.27 105.12,44.55 104.67,44.1 104.67,38.74 103.31,37.38 103.31,35.84 103.06,35.58 95.64,35.58 93.99,33.94 93.99,31.02 91.97,29 89.55,29 89.46,29.09 87.06,29.09 86.61,28.64 86.61,19.2 85.45,18.04 85.45,6.64 86.04,6.05 v1(86.04,6.06) ; v1(53.46,82.69) 53.29,82.86 53.29,94.54 52.67,95.16 52.67,97.18 51.49,98.36 51.49,106.5 51.96,106.97 v1(51.96,107.13)
  BOTTOM w0.102: v2(72.25,78.4) 72.64,78.79 v3(72.85,78.79)
  BOTTOM w0.254: v3(103.99,50.62) 103.99,50.85 104.43,51.3 PR854.2 ; v1(252.18,103.11) 252.18,102.66 250.53,101.01 250.53,98.21 250.34,98.02 250.34,96.42 251.27,95.49 251.27,90.39 250.44,89.56 250.44,88.53 249.72,87.81 249.72,85.81 248.59,84.68 248.59,80.98 248.64,80.93 248.64,80.91 249.29,80.27 249.29,77.13 249.21,77.05 249.21,75.97 248.42,75.19 248.4,75.19 v1(248.31,75.1) ; JDOCK1.143 183.4,110.78 183.55,110.94 183.55,111.7 ; JDOCK1.141 182.9,111.58 183.16,111.84 183.41,111.84 183.55,111.7 ; 183.55,111.7 v1(183.55,112.59)
SM_RCOMP0: length 12.2
  TOP w0.381: v1(132.21,50.06) 132.21,50 131.45,49.24 131.45,49.2 126.85,44.6 v1(126.85,42.9)
  BOTTOM w0.254: UC1.AU60 132.42,49.86 v1(132.21,50.06)
  BOTTOM w0.381: v1(126.85,42.9) 126.85,42.83 v2(127.43,42.25) 128.05,41.62 RC130.1
SM_RCOMP1: length 10.1
  TOP w0.381: v1(131.94,48.72) 131.94,48.04 128.17,44.26 v1(128.17,43)
  BOTTOM w0.254: UC1.AV60 132.13,48.91 v1(131.94,48.72)
  BOTTOM w0.381: v1(128.17,43) 128.23,43 v2(129.07,42.17) RC131.1
SM_RCOMP2: length 12.7
  TOP w0.381: v1(125.54,42.7) 125.54,44.83 130.73,50.03 v1(131.23,50.03)
  BOTTOM w0.254: v1(131.23,50.03) 131.42,49.83 UC1.AU61
  BOTTOM w0.381: v1(125.54,42.7) v2(126,42.24) 127.04,41.2 RC132.1
SMART_DET#: length 1.2
  TOP w0.102: UE1.A15 251.17,85.59 T99.1
SML0_SMBCLK: length 208.2
  TOP w0.076: 171.57,52.16 169.99,52.16 v1(169.49,51.67)
  TOP w0.102: 171.57,52.16 173.75,52.16 176.35,54.76 v2(177.21,54.76) 178.3,55.85 178.3,55.91 v1(178.45,56.06) 178.59,56.2 RC33.2 ; UL1.28 282.95,84.92 v1(283.24,85.21)
  IN2 w0.122: v1(186.56,52.31) 186.56,52.53 186.09,53 185.44,53 184.82,52.38 184.82,52.36 184.45,52 180.89,52 179.67,53.21 179.67,54.95 178.56,56.06 v1(178.45,56.06)
  IN4 w0.089: v1(186.56,52.31) 186.73,52.15 186.73,52.14 186.85,52.02 186.85,52.02 186.99,51.88 187.89,50.98 188.82,50.98 190.33,49.47 198.54,49.47 198.79,49.22 198.79,46.38 207.17,38 221.32,38 222.41,39.09 224.75,39.09 228.25,42.6 229.13,42.6 231.75,45.21 238.12,45.21 239.32,46.41 242.46,46.41 243.28,47.23 247.25,47.23 247.74,46.74 252.9,46.74 255.1,44.54 257.46,44.54 258.07,43.93 265.26,43.93 266,43.19 266,38.12 268.77,35.36 288.07,35.36 289.32,36.61 289.32,43.79 293.73,48.2 293.73,48.43 v1(293.79,48.49)
  BOTTOM w0.076: UC1.AN1 169.39,51.77 v1(169.49,51.67)
  BOTTOM w0.102: v1(283.24,85.21) 283.24,85.36 282.8,85.79 280.86,85.79 280.29,85.22 280.29,82.24 280.52,82.01 280.52,80.39 284.24,76.67 284.24,76.39 289.08,71.55 289.08,62.93 290.93,61.08 290.93,57.57 292.7,55.8 292.7,51.23 293.69,50.24 293.69,48.59 v1(293.79,48.49)
SML0_SMBDATA: length 208.2
  TOP w0.076: 171.57,52.64 v1(171.39,52.83)
  TOP w0.102: UL1.31 282.48,86.12 v1(282.64,86.27) ; 171.57,52.64 173.55,52.64 176.15,55.25 177.01,55.25 177.81,56.05 v1(177.81,56.06) 177.81,56.18 v2(178.47,56.84) 178.85,57.22 RC34.2
  IN2 w0.122: v1(187.2,52.33) 187.2,52.34 187.07,52.47 187.07,52.74 186.29,53.51 185.23,53.51 184.32,52.59 184.32,52.57 184.25,52.5 181.1,52.5 180.17,53.42 180.17,55.16 180.03,55.31 178.77,56.56 178.17,56.56 177.85,56.24 177.85,56.1 v1(177.81,56.06)
  IN4 w0.089: v1(293.19,48.54) 293.26,48.48 293.26,48.39 288.85,43.99 288.85,36.81 287.87,35.83 268.96,35.83 266.47,38.32 266.47,43.39 265.46,44.4 258.27,44.4 257.8,44.87 257.66,45.01 255.3,45.01 253.1,47.21 247.94,47.21 247.44,47.7 243.09,47.7 242.26,46.88 239.12,46.88 237.93,45.68 231.55,45.68 228.94,43.07 228.06,43.07 224.55,39.56 222.22,39.56 221.13,38.47 207.36,38.47 199.26,46.57 199.26,48.1 199.26,48.1 199.26,49.41 198.73,49.94 198.34,49.94 198.34,49.94 197.82,49.94 197.81,49.94 197.43,49.94 197.43,49.94 190.46,49.94 189.12,51.28 188.25,51.28 v1(187.2,52.33)
  BOTTOM w0.076: UC1.AK1 169.11,53.9 169.25,53.9 170.15,53 171.21,53 171.38,52.83 v1(171.39,52.83)
  BOTTOM w0.102: v1(293.19,48.54) 293.2,48.55 293.2,50.04 292.21,51.03 292.21,55.6 290.44,57.37 290.44,60.88 288.59,62.73 288.59,71.35 283.76,76.19 283.76,76.44 279.69,80.51 279.69,82.22 279.81,82.34 279.81,85.42 280.66,86.27 v1(282.64,86.27)
SML1_SMBCLK: length 143.4
  TOP w0.102: UE2.B6 v1(261.79,58) ; v1(177.95,58.89) 177.95,59.02 179.2,60.27 RPC14.3
  IN2 w0.122: v1(196.88,56.92) 196.43,56.48 195.1,56.48 194.38,57.2 192.34,57.2 192.01,57.53 185.07,57.53 183.52,55.98 181.49,55.98 179.52,57.95 179.15,57.95 178.56,58.54 178.49,58.54 178.13,58.89 v1(177.95,58.89) 176.76,57.7 176.76,55.9 178.61,54.05 178.61,52.87 178.07,52.33 174.89,52.33 174.1,51.55 174.1,49.94 172.86,48.69 v1(172.86,48.67)
  IN4 w0.089: v1(261.79,58) UE2.B6 263.11,57.35 263.11,55.41 263.77,54.75 263.77,52.58 265.81,50.54 265.81,49.37 265.02,48.58 265.02,47.08 264.67,46.73 264.03,46.73 262.41,45.1 258.63,45.1 257.87,45.86 255.44,45.86 253.38,47.92 248.37,47.92 247.9,48.39 242.68,48.39 241.99,47.69 238.91,47.69 237.74,46.52 236.32,46.52 235.8,47.04 230.17,47.04 224.32,41.19 206.75,41.19 201.18,46.76 201.18,50.34 196.88,54.64 v1(196.88,56.92)
  BOTTOM w0.076: UC1.AU3 168,49.26 169.17,49.26 169.45,48.98 169.45,48.75 169.97,48.23 170.65,48.23
  BOTTOM w0.102: 170.65,48.23 172.47,48.23 172.86,48.62 v1(172.86,48.67)
SML1_SMBDATA: length 140.5
  TOP w0.102: UE2.A5 v1(264.03,57.75) ; RPC14.4 179.53,59.77 179.29,59.53 179.26,59.53 178.84,59.11 v1(178.84,58.89)
  IN2 w0.086: v1(171.09,53.69) 171.09,53.63 171.41,53.32 171.77,53.32
  IN2 w0.122: 171.77,53.32 172.25,52.84 177.86,52.84 178.1,53.08 178.1,53.84 176.26,55.69 176.26,57.91 177.74,59.4 178.34,59.4 v1(178.84,58.89) 178.92,58.89 179.36,58.45 179.73,58.45 181.7,56.48 183.31,56.48 184.86,58.03 192.22,58.03 192.55,57.7 194.59,57.7 195.33,56.96 196.26,56.96 v1(196.27,56.95)
  IN4 w0.089: v1(264.03,57.75) 263.58,57.29 263.58,55.61 264.24,54.95 264.24,52.59 266.28,50.55 266.28,49.11 265.49,48.33 265.49,46.89 264.86,46.26 264.23,46.26 262.6,44.63 258.44,44.63 257.68,45.39 255.24,45.39 253.18,47.45 248.18,47.45 247.71,47.92 242.88,47.92 242.18,47.22 239.1,47.22 237.93,46.05 236.13,46.05 235.61,46.57 230.37,46.57 224.51,40.72 206.56,40.72 200.71,46.57 200.71,50.14 196.27,54.59 v1(196.27,56.95)
  BOTTOM w0.076: v2(171.26,54.22) 171.09,54.05 v1(171.09,53.69) 170.78,53.37 170.35,53.37 169.99,53.72 169.98,53.72 169.21,54.49 167.92,54.49 UC1.AH3
SNUB_1.35V: length 1.8
  TOP w0.102: v2(248.07,28.01) 247.99,28.08 247.99,29.77 PR203.2
SNUB_3V:
  vias: v2(213.78,71.57)
SNUB_5V: length 1.8
  TOP w0.102: PR112.2 213.91,58.26 v2(213.91,56.45)
SOFT_START_GC: length 61.5
  TOP w0.102: v3(100.65,61.2) 100.65,61.18 v2(99.99,60.52)
  TOP w0.254: PR17.2 56.68,86.3 v3(56.17,85.79)
  IN1 w0.254: v3(56.17,85.79) 57.73,85.79 60.91,82.62 73.09,82.62 75.2,80.5 75.2,79.69 76.72,78.17 76.72,75.43 78.05,74.09 78.05,72.58 79.34,71.29 79.34,69.87 80,69.2 80.54,69.2 84.09,65.66 89.1,65.66 89.99,64.77 94.53,64.77 98.09,61.2 v3(100.65,61.2)
  BOTTOM w0.254: v3(100.65,61.2) 100.9,60.95 PU800.2
SPI_CLK32: length 17.8
  TOP w0.102: v1(195.41,59.76) RC61.2 ; v1(190.8,61.23) 190.84,61.19 v1(190.84,59.2)
  BOTTOM w0.102: v1(190.8,61.23) 190.98,61.41 192.85,61.41 194.5,59.76 v1(195.41,59.76) 195.41,60.11 194.56,60.96 194.56,62.23 193.05,63.74 UC3.6 ; v1(190.84,59.2) 190.84,58.19 190.25,57.6 189.58,57.6 189.46,57.47 RPC12.7
SPI_CLK64: length 16.2
  TOP w0.102: v1(189.57,54.1) 189.58,54.1 190.16,54.68 RC62.2
  BOTTOM w0.102: UC2.6 192.98,53.03 193.18,53.23 194.32,53.23 194.45,53.1 196.3,53.1 196.51,53.3 196.51,53.86 196.3,54.07 194.07,54.07 193.59,53.58 190.83,53.58 190.72,53.47 190.72,53.42 190.6,53.3 190.45,53.3 190.33,53.42 190.33,53.53 190.28,53.58 190.13,53.58 190.03,53.69 190.03,53.96 189.9,54.1 v1(189.57,54.1) 189.38,53.91 RPC11.6
SPI_CLKTPM: length 4.5
  TOP w0.102: RZ35.2 RZ26.2 185.28,64.33 185.45,64.16 v2(185.85,64.16) 186.42,64.16 186.95,63.64 UZ1.21
SPI_DIN32: length 17.5
  IN2 w0.122: v1(189.95,59.12) 190.03,59.12 190.68,59.77 193.68,59.77 194.09,60.19 198.55,60.19 200.3,61.94 v1(200.67,61.94)
  BOTTOM w0.102: v1(200.67,61.94) 200.55,62.07 200.55,63.85 200.37,64.02 200.37,64.68 200.04,65.01 UC3.2 ; v1(189.95,59.12) 189.73,59.12 189.08,58.47 RPC12.5
SPI_DIN64: length 18
  BOTTOM w0.102: RPC11.8 189.73,52.91 190.33,52.3 190.35,52.3 190.7,51.95 190.7,51.6 191.16,51.13 192.98,51.13 193.18,50.93 193.18,49.82 193.35,49.65 193.6,49.65 193.78,49.82 193.78,50.49 193.93,50.64 194.14,50.64 194.29,50.49 194.29,49.8 194.43,49.65 194.64,49.65 194.79,49.8 194.79,50.46 194.94,50.61 v1(195.82,50.61) 196.38,50.61 197.09,51.32 197.09,54.09 197.29,54.3 UC2.2
SPI_DINTPM: length 3.4
  TOP w0.102: UZ1.26 187.21,60.39 187.08,60.52 v2(186.6,60.52) 185.29,60.52 185.04,60.26 RZ30.2
SPI_DO32: length 12.8
  BOTTOM w0.102: UC3.5 191.29,62.47 190.56,61.74 190.28,61.74 190.14,61.61 190.14,61.33 189.88,61.06 189.88,60.81 189.75,60.68 187.71,60.68 187.58,60.56 187.58,60.35 187.71,60.23 190.27,60.23 190.36,60.14 v2(190.36,59.53) 190.36,58.39 190.08,58.12 189.97,58.12 189.9,58.18 189.9,58.5 189.79,58.61 189.62,58.61 189.51,58.5 189.51,58.22 189.26,57.97 RPC12.6
SPI_DO64: length 13.1
  BOTTOM w0.102: UC2.5 193.13,51.76 193.28,51.6 193.49,51.6 193.59,51.5 193.59,51.24 193.74,51.09 193.95,51.09 194.1,51.24 194.1,51.5 194.2,51.6 194.51,51.6 194.61,51.5 194.61,51.37 194.76,51.22 194.97,51.22 195.12,51.37 195.12,51.5 195.22,51.6 195.29,51.6 195.49,51.81 v1(195.49,51.96) 195.49,52.54 195.41,52.62 194.25,52.62 194.12,52.75 193.4,52.75 193.11,52.45 190.57,52.45 189.61,53.41 RPC11.7
SPI_DOTPM: length 3.4
  TOP w0.102: RZ29.2 185.06,62.13 187.11,62.13 187.31,62.34 UZ1.23
SPI_PCH_CLK: length 48.1
  IN1 w0.089: v1(195.88,69.84) 196.37,69.84 196.98,69.23 198.13,69.23 v1(198.23,69.13)
  IN4 w0.089: v1(187.19,56.43) 187.75,56.43 187.99,56.67 192.16,56.67 194.74,59.25 195.52,59.25 195.98,59.71 197.75,59.71 198.93,60.88 198.93,65.68 199.34,66.09 199.34,68.08 198.29,69.13 v1(198.23,69.13)
  BOTTOM w0.102: JSPI1.14 206.11,82.82 205.92,82.63 RC227.1 205.92,81.77 205.46,81.31 205.46,80.7 204.9,80.14 204.48,80.14 v2(199.08,74.74) 196.28,71.94 196.28,70.23 v1(195.88,69.84) ; RPC12.2 187.46,57.47 187.03,57.05 187.03,56.59 v1(187.19,56.43) 187.38,56.24 187.38,54.94 187.17,54.73 187.17,54.24 187.49,53.91 RPC11.3
SPI_PCH_CS0#: length 43.1
  IN3 w0.122: v1(194.08,55.67) 193.87,55.88 193.87,66.21 194.81,67.15 v1(195.9,67.15)
  BOTTOM w0.102: v1(195.9,67.15) 196.48,67.73 196.48,68.51 197.36,69.39 197.36,71.63 v2(198.23,72.51) 204.81,79.09 205.23,79.09 206.88,80.74 RC228.1 206.88,81.28 207.33,81.73 207.33,82.57 207.11,82.78 JSPI1.12 ; v1(194.08,55.67) 194.32,55.91 196.56,55.91 197.61,56.96 198.01,56.96 198.97,57.93 RC35.1
SPI_PCH_CS0#_R: length 14.1
  BOTTOM w0.102: UC2.1 200.01,55.57 200.84,56.39 202.46,56.39 202.69,56.62 202.69,59.72 202.55,59.86 202.18,59.86 202.11,59.78 202.11,58.88 v1(202.01,58.77) 200.52,58.77 200.42,58.67 200.42,58.47 200.52,58.37 202.01,58.37 202.11,58.27 202.11,57.66 RC35.2
SPI_PCH_CS1#: length 32.4
  IN2 w0.122: v1(199.35,70.94) 199.06,71.24 v1(192.81,71.24)
  BOTTOM w0.102: JSPI1.20 203.11,83.17 201.64,81.7 RC224.1 200.15,81 v2(196.46,77.31) 195.94,76.79 195.94,74.96 192.81,71.83 v1(192.81,71.24) ; v1(199.35,70.94) 199.91,70.94 200.83,70.02 200.83,64.63 RC50.1
SPI_PCH_CS1#_R: length 15.7
  BOTTOM w0.102: UC3.1 200.36,66.28 200.6,66.04 200.6,64.42 200.77,64.25 200.77,62.69 200.91,62.55 v2(203.67,62.55) 204.5,62.55 204.62,62.68 204.62,63.24 204.5,63.36 204.04,63.36 203.94,63.46 203.94,64.06 203.83,64.16 203.63,64.16 203.53,64.06 203.53,63.46 203.43,63.36 203.22,63.36 203.12,63.46 203.12,64.06 203.02,64.16 202.82,64.16 202.72,64.06 202.72,63.28 202.6,63.16 RC50.2
SPI_PCH_DIN: length 48.3
  TOP w0.102: v1(186.56,58.9) 186.56,56.48 186.89,56.15 186.89,54.14 186.1,53.34 185.73,53.34 185.32,52.93 v1(185.32,52.26)
  IN4 w0.089: v1(186.56,58.9) 186.6,58.94 187.12,58.94 188.72,60.53 191.63,60.53 195.73,64.63 195.73,65.14 v1(195.81,65.22)
  BOTTOM w0.102: v1(186.56,58.9) 186.63,58.9 186.68,58.85 187.3,58.85 RPC12.4 ; v1(195.81,65.22) 194.93,66.1 194.93,67.67 194.17,68.43 194.17,70.3 194.61,70.74 194.61,72.07 199.72,77.17 199.72,77.86 201.04,79.19 v2(201.49,79.19) 201.98,79.68 202.76,79.68 204.06,80.99 RC226.1 204.06,81.17 204.88,81.98 204.88,82.83 205.11,83.07 JSPI1.16 ; RPC11.1 185.95,52.91 185.32,52.28 v1(185.32,52.26)
SPI_PCH_DO: length 52
  TOP w0.102: v1(196.88,62.32) 197.35,62.32 197.78,61.89 197.78,58.04 v1(197.42,57.68)
  IN2 w0.122: v1(197.42,57.68) 196.33,58.78 194.32,58.78 193.99,58.45 v1(186.97,58.45)
  BOTTOM w0.102: RPC12.3 187.54,57.97 187.14,58.37 187.05,58.37 v1(186.97,58.45) 186.97,58.41 186.79,58.23 186.79,57.97 186.55,57.72 186.55,56.93 186.54,56.92 186.54,56.4 186.89,56.04 186.89,55.14 186.69,54.93 186.69,54.03 186.83,53.89 186.83,53.88 187.3,53.41 187.67,53.41 RPC11.2 ; JSPI1.18 204.11,82.97 RC225.1 202.98,81.84 202.98,80.63 202.59,80.24 201.24,80.24 199.06,78.06 199.06,77.26 193.55,71.75 193.55,68.13 193.92,67.75 194.45,67.22 194.45,65.15 195.28,64.33 196.19,64.33 196.88,63.65 v1(196.88,62.32)
SPI_PCH_DO2: length 37.8
  IN2 w0.122: v1(198.42,67.66) 198.49,67.59 198.49,66.8 199.06,66.23 199.06,64.19 202.43,60.83 v1(202.43,60.7)
  BOTTOM w0.102: JSPI1.10 208.11,82.84 208.31,82.64 RC229.1 208.31,80.74 207.87,80.3 207.4,80.3 204.89,77.79 v2(204.71,77.79) 204.57,77.79 197.83,71.05 197.83,68.86 198.42,68.27 v1(198.42,67.66) ; RC55.1 202.43,61.41 v1(202.43,60.7) 203.1,60.02 203.1,55.86 RC29.2 RC38.1
SPI_PCH_DO2_32: length 12.9
  BOTTOM w0.102: RC55.2 201.78,61.14 v1(201.78,60.14) 201.78,59.27 201.65,59.15 199.06,59.15 198.93,59.28 198.93,59.46 199.06,59.59 200.88,59.59 201.04,59.76 201.04,60.86 200.24,61.66 200.24,63.33 199.83,63.74 UC3.3
SPI_PCH_DO2_64: length 12.9
  BOTTOM w0.102: RC38.2 201.61,54.07 v1(201.61,51.02) 201.61,50.79 201.43,50.61 198.75,50.61 198.59,50.78 198.59,51.01 198.75,51.17 200.77,51.17 201,51.4 201,52.9 200.88,53.03 UC2.3
SPI_PCH_DO3: length 45.8
  IN4 w0.089: v1(198.23,69.73) 198.27,69.69 198.4,69.69 199.81,68.28 199.81,65.1 199.51,64.81 199.51,60.8 197.95,59.24 196.17,59.24 194.61,57.67 193.98,57.67 192.49,56.19 188.82,56.19 188.78,56.15 v1(188.14,56.15)
  BOTTOM w0.102: RPC11.4 187.68,54.56 187.86,54.74 RC31.2 187.86,55.97 188.04,56.15 v1(188.14,56.15) 187.96,56.33 187.96,56.4 187.68,56.69 RPC12.1 ; JSPI1.8 209.11,83.12 209.73,82.5 209.73,81.79 209.46,81.52 RC230.1 209.14,80.9 208.05,79.81 207.63,79.81 203.68,75.86 203.31,75.86 198.64,71.19 198.64,70.13 v1(198.23,69.73)
SPI_PCH_DO3_32: length 12.8
  TOP w0.102: v1(190.5,62.3) 190.36,62.16 190.36,58.03 190.21,57.88 189.19,57.88 189.01,57.7 189.01,57.39 189.24,57.17 189.78,57.17 v1(189.84,57.1)
  BOTTOM w0.102: RPC12.8 189.71,56.97 v1(189.84,57.1) ; UC3.7 190.88,65.01 190.71,64.84 190.29,64.84 189.9,64.46 189.9,62.89 v1(190.5,62.3)
SPI_PCH_DO3_64: length 13.1
  BOTTOM w0.102: RPC11.5 188.62,54.41 188.49,54.54 188.49,54.92 188.62,55.04 188.76,55.04 188.93,54.88 192.85,54.88 193.21,55.23 195.7,55.23 195.9,55.03 195.9,54.75 195.7,54.55 193.51,54.55 v1(193.33,54.37) 193.26,54.3 UC2.7
SPKR: length 220.1
  TOP w0.102: v1(181.04,105.53) 182.33,104.23 182.33,102.05 181.44,101.16 181.44,98.95 v1(181.25,98.76) ; v1(37.63,100.45) 37.63,99.68 RA12.2 36.82,98 v2(37.12,97.69)
  IN1 w0.086: 171.77,61.27 170.37,61.27 168.76,59.65 v1(168.66,59.65)
  IN1 w0.089: v1(178.66,65.69) 177.43,66.92 175.51,66.92 174.33,65.74 174.33,64.67 172.05,62.38 172.05,61.55 171.77,61.27
  IN3 w0.122: v1(181.04,105.53) 180.73,105.83 145.99,105.83 145.04,104.88 134.83,104.88 134.15,105.56 128.18,105.56 125.88,103.27 105.33,103.27 104.2,104.4 98.95,104.4 97.95,105.4 78.6,105.4 77.53,106.47 58.37,106.47 56.77,104.87 44.09,104.87 40.15,100.94 38.13,100.94 v1(37.63,100.45)
  BOTTOM w0.076: v1(168.66,59.65) 168.66,59.68 168.33,60 UC1.V2
  BOTTOM w0.102: v1(181.25,98.76) 181.25,98.69 181.76,98.19 186.21,98.19 187.07,97.32 187.07,93.91 188.44,92.53 188.44,90.59 188.07,90.22 188.07,74.12 184.68,70.73 184.68,67.89 183.89,67.1 182.02,67.1 181.68,66.77 181.29,66.77 180.8,66.27 180.14,66.27 179.46,65.6 RC180.2 178.75,65.6 v1(178.66,65.69)
SRCDET: length 5.2
  TOP w0.102: UV8.C2 157.18,97.4 156.26,97.4 155.75,97.91 155.16,97.91 v2(154.9,98.16) 154.38,98.16 153.96,98.58 153.96,98.82 RV84.1
SRTCRST#: length 13.7
  TOP w0.076: v1(165.24,48.66) 165.37,48.66 166.4,47.63 166.4,46.81 166.98,46.23 166.98,44.85 167.26,44.57 168.43,44.57 168.96,44.03 168.96,43.45 169.72,42.69 169.94,42.69 170.65,41.98 ; 170.65,41.27 v2(170.35,40.96)
  TOP w0.102: 170.65,41.27 170.68,41.29 v1(170.68,41.93) 170.68,41.95 170.65,41.98
  BOTTOM w0.076: UC1.AV6 165.53,48.91 165.32,48.69 165.27,48.69 v1(165.24,48.66)
  BOTTOM w0.102: CC3.2 170.73,41.87 v1(170.68,41.93) 170.78,41.93 171.54,41.16 RC10.2
STSTART_DCBLOCK_GC: length 68.6
  TOP w0.102: v3(106.51,56.22) v2(106.51,56.92)
  TOP w0.254: PR811.2 117.6,99.89 117.08,99.37 v3(117.08,99.3)
  IN4 w0.254: v3(117.08,99.3) 117.21,99.18 117.21,98.68 115.35,96.83 110.85,96.83 109.31,95.29 109.31,91.63 108.5,90.82 108.5,84.28 106.11,81.89 106.11,77.55 104.34,75.78 99.24,75.78 97.93,74.48 97.93,66.4 98.93,65.39 106.55,65.39 107.15,64.8 107.15,61.41 107.1,61.36 107.1,60.94 107.15,60.89 107.15,56.86 v3(106.51,56.22)
  BOTTOM w0.254: PU800.16 v3(106.51,56.22)
SUS_ON: length 49.6
  TOP w0.102: v1(274.1,62.37) 274.21,62.26 UZ3.5 ; v1(263.94,41.79) 263.94,41.29 v4(263.72,41.06) 263.49,40.83 263.49,38.5 v1(263.94,38.04) ; RPE10.2 269.23,64.07 268.76,64.54 v1(268.76,64.73)
  IN3 w0.122: v1(274.1,62.37) 272.53,63.95 269.38,63.95 268.76,64.57 v1(268.76,64.73) 267.3,66.19 265.37,66.19 263.54,64.37 260.97,64.37 260.24,63.64 260.24,63.47 v1(259.66,62.89)
  BOTTOM w0.102: PR207.1 v1(263.94,38.04) ; v1(259.66,62.89) 259.83,62.73 259.83,62.19 260.3,61.72 RE281.1 260.3,59.32 260.87,58.75 RE282.1 262.22,58.51 262.22,57.6 263.03,56.78 263.03,54.83 262.89,54.69 262.89,54.19 263.26,53.83 263.26,50 261.35,48.1 261.35,44.88 263.94,42.29 v1(263.94,41.79)
SUS_ON_EC: length 4.5
  TOP w0.102: v1(259.42,62.36) 259.21,62.58 259.21,63.67 259.35,63.81 UE2.B23
  BOTTOM w0.102: v1(259.42,62.36) 259.38,62.32 RE281.2 259.38,60.15 v2(259.63,59.91)
SUS_STAT#/LPCPD#: length 14
  TOP w0.102: v2(178.59,54.6) v1(178.59,55.17) 178.6,55.18 RC82.2
  IN4 w0.086: 172.84,55.37 172.52,55.37 172.38,55.51 170.52,55.51 170.38,55.66 169.42,55.66 169.41,55.66 168.46,55.66 168.39,55.59 167.83,55.59 v1(167.36,55.12)
  IN4 w0.089: 172.84,55.37 173.09,55.37 173.41,55.06 178.47,55.06 v1(178.59,55.17)
  BOTTOM w0.076: v1(167.36,55.12) 167.32,55.12 167.03,55.41 UC1.AG4
SUSACK#: length 123.3
  TOP w0.102: RC81.2 178.33,54.17 177.46,53.29 v1(177.39,53.29) ; UE2.A23 v1(258.6,65.7) ; v1(193.57,52.33) 193.78,52.12 v2(193.78,51.72)
  IN2 w0.086: 172.84,54.36 170.37,54.36 169.66,53.65 v1(168.67,53.65)
  IN2 w0.122: 172.84,54.36 173.55,54.36 174.65,53.25 177.36,53.25 v1(177.39,53.29) ; v1(239.66,61.76) 240.58,61.76 243.36,64.54 245.52,64.54 246.37,65.39 247.74,65.39 249.47,67.12 250.74,67.12 251.16,67.55 257.41,67.55 258.13,66.83 258.13,66.17 v1(258.6,65.7) ; v1(241.24,58.84) 241.74,58.34 241.74,56.7 239.28,54.24 238.35,54.24 237.08,52.98 237.08,52.61 230.14,45.66 229.25,45.66 225.62,42.04 201.21,42.04 199.63,43.61 196.39,43.61 193.4,46.6 193.4,47.37 192.14,48.63 192.14,50.97 193.5,52.33 v1(193.57,52.33)
  IN4 w0.089: v1(193.57,52.33) 192.67,53.23 191.49,53.23 191.12,52.86 187.87,52.86 187.55,53.18 185.15,53.18 184.49,52.52 181.71,52.52 181.62,52.61 178.08,52.61 v1(177.39,53.29) ; v1(239.66,61.76) 239.66,60.42 v1(241.24,58.84)
  BOTTOM w0.076: v1(168.67,53.65) 168.64,53.67 168.64,53.69 168.33,54 UC1.AK2
SUSCLK: length 119.7
  TOP w0.102: v1(181.58,57.88) 181.24,58.23 RC136.2 ; RZ56.1 282.6,49.04 v1(281.99,49.65)
  IN1 w0.089: v1(181.58,57.88) 182.16,58.46 184.09,58.46 185.17,59.54 186.6,59.54 187.78,58.36 192.93,58.36 198.22,53.06 198.22,52.61 199.67,51.16 199.67,47.74 206.93,40.48 225.81,40.48 227.75,42.42 229.87,42.42 234.45,47.01 235.74,47.01 239.56,50.83 249.9,50.83 250.38,50.35 254.88,50.35 255.66,51.13 267.63,51.13 267.73,51.23 275.4,51.23 276.35,50.28 277.3,50.28 278.37,49.22 278.9,49.22 279.2,49.51 279.2,49.7 279.59,50.09 281.55,50.09 v1(281.99,49.65)
SUSCLK_R: length 18.1
  TOP w0.102: v1(179.69,58.94) 179.69,58.69 179.67,58.66 RC136.1 178.6,58.23 v2(178.35,58.49)
  IN1 w0.086: v1(165.93,55.79) 166.32,56.17 167.96,56.17 170.37,58.59 171.77,58.59
  IN1 w0.089: 171.77,58.59 173.19,58.59 173.89,59.29 179.34,59.29 v1(179.69,58.94)
  BOTTOM w0.076: UC1.AE6 165.7,56.2 165.93,55.96 v1(165.93,55.79)
SW1: length 9.9
  IN1 w1.016: 211.11,57.72 212.64,57.72 213.35,57.01 217.38,57.01 218.73,58.36 218.73,59.76
  vias: v2(206.67,58.23) v3(207.66,58.31) v3(207.66,57.62) v3(207.66,56.89) v3(208.5,58.31) v3(208.5,57.62) v3(208.5,56.89) v3(209.31,58.31) v3(209.31,57.62) v3(209.31,56.89) v3(210.2,58.33) v3(210.2,57.65) v3(210.2,56.91) v3(218.5,61.43) v3(218.5,60.8)
SW2: length 10.6
  IN1 w1.016: 210.55,73.9 214.44,73.9 218.6,69.74 218.6,68.87
  vias: v2(206.92,74.87) v3(207.43,75.3) v3(207.45,74.49) v3(207.45,73.7) v3(208.17,75.33) v3(208.19,74.51) v3(208.19,73.73) v3(208.93,75.33) v3(208.95,74.51) v3(208.95,73.73) v3(209.72,75.33) v3(209.74,74.51) v3(209.74,73.73) v3(218.45,67.88) v3(219.11,67.88)
SW_1.35V: length 1.5
  IN1 w1.016: 255.13,34.79 253.58,34.79
  vias: v2(252.9,35.25) v3(251.98,30.34) v3(251.98,29.58) v3(251.98,28.77) v3(252.06,33.85) v3(252.06,33.09) v3(252.64,30.34) v3(252.64,29.58) v3(252.67,28.74) v3(252.77,33.87) v3(252.77,33.11) v3(253.3,30.34) v3(253.3,29.57) v3(253.3,28.74) v3(253.45,33.86) v3(253.45,33.1) v3(256.12,35.07) v3(256.5,35.58)
SW_10_GRN#: length 5
  TOP w0.102: RL30.2 QL2.1 238.05,102.29 v2(239,103.24) 239.26,103.24 239.95,102.54 UL4.41
SW_100_ORG#: length 5.9
  TOP w0.102: UL4.18 250.93,102.04 251.16,101.81 v2(251.64,101.81) 252.1,102.26 RL29.2 252.31,101.78 252.31,101.39 253.04,100.66 QL1.4
SW_+V1.05SP: length 1.5
  TOP w0.102: v3(213.39,46.99) 212.17,46.99 v2(212,46.83)
  vias: v3(213.36,47.63)
SW_ACTLED_YEL#: length 5.2
  TOP w0.102: UL4.17 249.55,100.52 249.73,100.33 250.45,100.33 251.74,99.04 QL1.1 v2(251.74,97.15)
SW_DPB_AUX: length 29
  TOP w0.102: RV75.1 168.8,93.06 168.49,93.06 v1(168.33,93.22) 168.33,93.15 168.03,92.85 166.29,92.85 165.63,93.51 164.98,93.51 UV8.J13
  IN1 w0.089: v1(183.91,101.08) 184.29,101.08 184.37,101 184.37,100.81 184.24,100.68 173.47,100.68 172.72,99.93 172.23,99.93 169.63,97.34 169.63,93.61 169.08,93.06 168.49,93.06 v1(168.33,93.22)
  BOTTOM w0.102: v1(183.91,101.08) 183.97,101.14 184.36,101.14 184.49,101.01 CV119.2
SW_DPB_AUX#: length 28.8
  TOP w0.102: RV82.1 168.99,92.81 168.58,92.81 v1(168.38,92.61) 168.34,92.64 166.21,92.64 165.67,93.18 UV8.J14
  IN1 w0.089: v1(168.38,92.61) 168.65,92.89 169.15,92.89 169.8,93.54 169.8,97.26 172.3,99.76 172.79,99.76 173.54,100.51 184.31,100.51 184.54,100.74 184.54,101.07 184.36,101.25 184.3,101.25 183.91,101.65 v1(183.91,101.67)
  BOTTOM w0.102: v1(183.91,101.67) 183.91,101.66 184.22,101.35 184.39,101.35 184.49,101.45 CV120.2
SW_DPB_AUX#_C: length 3.3
  BOTTOM w0.102: UV11.5 186.34,102.32 186.22,102.2 186.22,101.64 186.01,101.43 185.62,101.43 185.41,101.64 CV120.1
SW_DPB_AUX_C: length 3.3
  BOTTOM w0.102: CV119.1 185.41,101.08 185.55,101.22 185.95,101.22 186.22,100.95 186.22,100.56 186.42,100.37 UV11.2
SW_DPC_AUX: length 11.8
  TOP w0.102: UV8.B11 163.68,98.07 163.68,98.69 163.92,98.92 163.92,100.12 164.73,100.93 165.37,100.93 165.79,101.35 v3(166.92,101.35) v1(168.17,101.35) 168.41,101.59 168.57,101.59 RV74.1
  BOTTOM w0.102: v1(168.17,101.35) 169.28,101.35 169.44,101.19 170.45,101.19 170.78,100.87 CV122.2
SW_DPC_AUX#: length 11.8
  TOP w0.102: UV8.A11 163.35,98.69 163.69,99.03 163.69,99.78 163.71,99.8 163.71,100.2 164.65,101.14 165.28,101.14 165.7,101.56 166.62,101.56 166.64,101.58 167.19,101.58 167.21,101.56 167.65,101.56 v1(168.14,102.05) 168.34,101.84 168.68,101.84 RV85.1
  BOTTOM w0.102: v1(168.14,102.05) 168.57,101.62 169.31,101.62 169.52,101.4 170.48,101.4 170.78,101.69 CV123.2
SW_DPC_AUX#_C: length 2.3
  BOTTOM w0.102: CV123.1 172.96,102.17 173.1,102.32 UV12.5
SW_DPC_AUX_C: length 2.2
  BOTTOM w0.102: CV122.1 172.58,100.4 172.61,100.37 UV12.2
SW_LAN_TX0+: length 83.5
  TOP w0.094: v1(241.85,106.11) 241.85,106.1 241.6,105.86 241.6,105.18 241.55,105.12 UL4.38
  IN4 w0.081: v1(241.85,106.11) 241.85,106.1 242,106.26 242,106.57 243.64,108.21 247.42,108.21 247.84,108.63 251.08,108.63 256.34,103.37 267.24,103.37 269.12,101.49 281.52,101.49 286.64,96.37 286.64,93.56 286.89,93.31 286.89,90.2 290.19,86.91 290.81,86.91 291.51,86.2 291.51,85.92 293.72,83.72 300.73,83.72 303.63,86.62 303.63,87.73 v1(303.51,87.85)
  BOTTOM w0.094: v1(303.51,87.85) 303.55,87.89 303.55,88.44 303.04,88.95 TL1.6
SW_LAN_TX0-: length 83.7
  TOP w0.094: v1(242.49,106.11) 241.99,105.6 241.99,105.17 242.05,105.11 UL4.37
  IN4 w0.081: v1(242.49,106.11) 242.25,106.35 242.25,106.47 243.74,107.96 247.53,107.96 247.94,108.37 250.97,108.37 256.24,103.11 267.13,103.11 269.01,101.23 281.42,101.23 286.39,96.27 286.39,93.46 286.64,93.21 286.64,90.1 290.08,86.65 290.71,86.65 291.26,86.1 291.26,85.82 293.61,83.47 300.84,83.47 303.89,86.51 303.89,87.64 v1(304.1,87.85)
  BOTTOM w0.094: v1(304.1,87.85) 303.93,88.01 303.93,88.58 304.31,88.95 TL1.5
SW_LAN_TX1+: length 85.6
  TOP w0.094: UL4.34 243.55,105.27 243.67,105.39 243.67,105.99 243.77,106.09 243.77,106.41 v1(243.71,106.47)
  IN4 w0.081: v1(308.05,88.5) 308.37,88.18 308.37,87.86 308.08,87.57 306.36,87.57 301.61,82.82 293.07,82.82 285.77,90.11 285.77,96 283.49,98.29 281.52,98.29 279.76,100.05 269.29,100.05 266.85,102.49 255.99,102.49 250.75,107.74 248.18,107.74 247.79,107.34 244.34,107.34 243.89,106.9 243.89,106.65 v1(243.71,106.47)
  BOTTOM w0.094: TL1.2 308.12,88.56 v1(308.05,88.5)
SW_LAN_TX1-: length 85.7
  TOP w0.094: v1(244.29,106.47) 244.11,106.28 244.11,105.89 244.05,105.83 UL4.33
  IN4 w0.081: v1(244.29,106.47) 244.14,106.62 244.14,106.8 244.44,107.09 247.89,107.09 248.29,107.49 250.64,107.49 255.89,102.24 266.75,102.24 269.19,99.8 279.65,99.8 281.42,98.03 283.39,98.03 285.52,95.9 285.52,90.01 292.96,82.57 301.71,82.57 306.47,87.32 308.19,87.32 308.62,87.75 308.62,88.38 v1(308.7,88.46)
  BOTTOM w0.094: v1(308.7,88.46) 309.39,89.14 TL1.1
SW_LAN_TX2+: length 73.2
  TOP w0.094: v1(246.03,109.62) 246.12,109.53 246.12,105.34 246.05,105.27 UL4.29
  IN4 w0.081: v1(295.77,88.2) 295.94,88.04 295.94,87.7 295.67,87.43 293.81,87.43 291.87,89.38 290.34,89.38 289.21,90.51 289.21,96.33 282.18,103.37 276.77,103.37 275.81,104.33 274.75,104.33 273.63,103.21 270.82,103.21 268.28,105.76 268.28,105.77 266.65,107.4 256.7,107.4 252.6,111.5 247.27,111.5 246.24,110.47 246.24,109.82 v1(246.03,109.62)
  BOTTOM w0.094: v1(295.77,88.2) 295.77,88.7 295.42,89.05 TL1.12
SW_LAN_TX2-: length 73.1
  TOP w0.094: v1(246.62,109.62) 246.5,109.5 246.5,105.31 246.55,105.27 UL4.28
  IN4 w0.081: v1(246.62,109.62) 246.49,109.74 246.49,110.37 247.37,111.24 252.5,111.24 256.59,107.15 266.54,107.15 268.03,105.66 268.03,105.65 270.72,102.96 273.74,102.96 274.86,104.08 275.7,104.08 276.67,103.12 282.08,103.12 288.96,96.23 288.96,90.4 290.24,89.13 291.76,89.13 293.71,87.18 295.77,87.18 296.19,87.59 296.19,88.04 v1(296.35,88.2)
  BOTTOM w0.094: v1(296.35,88.2) 296.35,88.67 296.69,89 TL1.11
SW_LAN_TX3+: length 76.7
  TOP w0.094: v1(247.88,109.62) 247.9,109.6 247.9,105.82 247.99,105.73 247.99,105.06 248.05,105.01 UL4.25
  IN4 w0.081: v1(247.88,109.62) 247.83,109.67 247.83,110.19 248.18,110.54 250.48,110.54 254.85,106.17 266.04,106.17 269.86,102.35 281.91,102.35 288.33,95.94 288.33,90.13 290.21,88.25 290.39,88.25 290.88,87.76 291.3,87.76 293.15,85.91 300.24,85.91 301.05,86.72 301.05,87.74 v1(300.84,87.95)
  BOTTOM w0.094: v1(300.84,87.95) 300.96,88.07 300.96,88.56 300.5,89.03 TL1.8
SW_LAN_TX3-: length 76.9
  TOP w0.094: UL4.24 248.55,105.05 248.37,105.22 248.37,105.89 248.29,105.98 248.29,109.44 v1(248.46,109.62)
  IN4 w0.081: v1(301.42,87.95) 301.3,87.83 301.3,86.61 300.35,85.65 293.05,85.65 291.2,87.51 290.78,87.51 290.28,88 290.1,88 288.08,90.03 288.08,95.83 281.81,102.1 269.76,102.1 265.94,105.92 254.75,105.92 250.38,110.29 248.29,110.29 248.08,110.08 248.08,110.01 v1(248.46,109.62)
  BOTTOM w0.094: TL1.7 301.77,89.06 301.34,88.63 301.34,88.03 v1(301.42,87.95)
SW_USB3RN1: length 134.8
  TOP w0.102: LI1.4 73.27,100.29 73.55,100.01 73.55,99.8 v1(73.4,99.65) ; UI4.26 187.92,96 187.81,96.11 187.81,96.42 187.31,96.92 187.06,96.92 186.61,97.36 186.61,100.27 186.01,100.87 186.01,106.87 186.12,106.97 186.12,107.41 v1(186.39,107.67)
  IN1 w0.089: v1(73.4,99.65) 73.6,99.86 73.6,102.21 76.94,105.54 100.14,105.54 100.63,105.04 105.52,105.04 106.14,104.43 123.33,104.43 123.76,104.85 125.21,104.85 128.32,107.97 145.02,107.97 145.4,108.34 156.29,108.34 156.43,108.48 171.33,108.48 172.47,109.62 184.26,109.62 185.42,108.46 186.14,108.46 186.39,108.22 v1(186.39,107.67)
SW_USB3RP1: length 134.7
  TOP w0.102: LI1.1 74.12,100.3 73.76,99.94 73.76,99.88 v1(73.99,99.65) ; v1(185.61,107.67) 185.91,107.37 185.91,107.06 185.8,106.95 185.8,100.79 186.4,100.18 186.4,97.28 186.97,96.71 187.22,96.71 187.6,96.33 187.6,96.14 187.52,96.07 UI4.27
  IN1 w0.089: v1(185.61,107.67) 185.82,107.67 186.22,108.07 186.22,108.15 186.07,108.29 185.35,108.29 184.19,109.45 172.54,109.45 171.4,108.31 156.5,108.31 156.36,108.17 145.47,108.17 145.09,107.8 128.39,107.8 125.28,104.68 123.83,104.68 123.4,104.26 106.07,104.26 105.45,104.87 100.56,104.87 100.07,105.37 77.01,105.37 73.77,102.14 73.77,99.87 v1(73.99,99.65)
SW_USB3TN1: length 134.9
  TOP w0.102: v1(75.69,97.18) 75.88,97.37 75.88,97.51 CI4.2 ; UI4.30 185.75,94.05 185.59,93.88 185.28,93.88 185.16,94.01 185.16,97.34 185.2,97.39 185.2,99.94 184.73,100.41 v3(184.73,104.28) 184.73,107.51 v1(184.89,107.66)
  IN1 w0.089: v1(75.69,97.18) 75.9,97.39 75.9,99.21 75.6,99.51 75.6,102.65 77.81,104.87 99.91,104.87 100.38,104.4 105.22,104.4 105.83,103.79 123.6,103.79 124.01,104.21 125.5,104.21 127.98,106.69 144.73,106.69 145.73,107.69 156.72,107.69 156.83,107.8 183.18,107.8 183.72,108.34 184.31,108.34 184.66,107.99 184.66,107.88 v1(184.89,107.66)
SW_USB3TP1: length 134.7
  TOP w0.102: v1(184.3,107.66) 184.32,107.66 184.53,107.45 184.53,104.58 184.51,104.56 184.51,104.01 184.53,103.98 184.53,100.32 185,99.85 185,97.47 184.95,97.43 184.95,93.92 185.2,93.67 185.71,93.67 185.74,93.65 UI4.31 ; v1(76.27,97.18) 76.09,97.37 76.09,97.51 76.48,97.91 CI5.2
  IN1 w0.089: v1(76.27,97.18) 76.07,97.39 76.07,99.28 75.77,99.58 75.77,102.58 77.88,104.7 99.83,104.7 100.3,104.23 105.15,104.23 105.76,103.62 123.67,103.62 124.08,104.04 125.57,104.04 128.05,106.52 144.8,106.52 145.8,107.52 156.79,107.52 156.9,107.63 183.26,107.63 183.79,108.17 184.24,108.17 184.49,107.91 184.49,107.85 v1(184.3,107.66)
SW_USBP0+: length 150
  TOP w0.102: UI4.19 190.72,96.26 191.17,96.71 192.41,96.71 192.86,97.17 192.86,99.61 193.14,99.89 193.14,103.13 190.44,105.84 190.44,107.48 v1(190.25,107.67) ; v1(71.78,103.08) 71.68,103.17 71.06,103.17 67.55,99.66 64.13,99.66 63.81,99.34 LI3.4
  IN1 w0.089: v1(71.78,103.08) 72.04,103.34 73.99,103.34 76.66,106.01 100.33,106.01 100.82,105.52 105.78,105.52 106.38,104.93 123.16,104.93 123.57,105.33 125.01,105.33 128.16,108.47 144.75,108.47 145.82,109.53 157.18,109.53 157.64,109.07 159.83,109.07 160.17,109.41 169.63,109.41 169.97,109.07 171.14,109.07 172.24,110.16 184.47,110.16 185.55,109.08 190.31,109.08 190.48,108.91 190.48,107.91 v1(190.25,107.67)
SW_USBP0-: length 150.2
  TOP w0.102: LI3.1 63.81,100.19 64.13,99.87 67.46,99.87 70.98,103.38 71.5,103.38 v1(71.78,103.66) ; UI4.18 191.12,96.33 191.3,96.5 192.49,96.5 193.07,97.08 193.07,99.52 193.35,99.8 193.35,103.22 190.64,105.92 190.64,107.42 v1(190.89,107.67)
  IN1 w0.089: v1(190.89,107.67) 190.65,107.91 190.65,108.98 190.38,109.25 185.62,109.25 184.54,110.33 172.17,110.33 171.07,109.24 170.04,109.24 169.7,109.58 160.1,109.58 159.76,109.24 157.71,109.24 157.25,109.71 145.75,109.71 144.68,108.64 128.09,108.64 124.94,105.5 123.5,105.5 123.09,105.1 106.45,105.1 105.85,105.69 100.89,105.69 100.4,106.18 76.59,106.18 73.92,103.51 71.93,103.51 v1(71.78,103.66)
SW_USBP3+: length 77.2
  IN1 w0.089: v1(215.59,106.15) 215.59,105.59 215.38,105.39 204.94,105.39 201.85,108.48 192.7,108.48 191.14,106.92 178.47,106.92 178.07,106.53 158.35,106.53 158.2,106.67 158.2,107.04 v1(158.12,107.13)
  BOTTOM w0.102: v1(158.12,107.13) 158.53,106.72 158.53,106.29 158.82,106 162.01,106 162.03,105.98 162.58,105.98 162.6,106 163.05,106 163.16,105.89 163.16,105.81 162.84,105.49 UI5.1 ; v1(215.59,106.15) 215.21,105.77 215.21,100.35 216.39,99.17 217.25,99.17 217.34,99.25 217.34,99.41 217.28,99.46 217,99.46 216.94,99.53 LI4.1
SW_USBP3-: length 77.4
  IN1 w0.089: v1(215,106.15) 215.41,105.74 215.41,105.66 215.31,105.56 214.65,105.56 214.47,105.73 214.2,105.73 214.03,105.56 213.76,105.56 213.56,105.76 213.34,105.76 213.14,105.56 212.87,105.56 212.67,105.76 212.45,105.76 212.25,105.56 205.01,105.56 201.92,108.65 192.63,108.65 191.07,107.09 178.4,107.09 178,106.7 158.42,106.7 158.37,106.74 158.37,106.81 158.69,107.13 v1(158.7,107.13)
  BOTTOM w0.102: LI4.4 217.79,99.7 217.54,99.46 217.54,99.17 217.34,98.96 216.3,98.96 215,100.26 v1(215,106.15) ; UI5.2 163.36,105.98 163.13,106.21 v3(162.31,106.21) 158.9,106.21 158.74,106.38 158.74,107.09 v1(158.7,107.13)
SYS_LED_MASK#: length 172
  TOP w0.102: RE21.2 257.98,71.92 v1(257.67,72.23) ; UZ10.1 295.42,45.15 v1(295.01,45.56) ; UE1.B48 v1(256.92,75.52) ; v1(284.99,68.62) 285.04,68.57 v2(285.83,68.57) 288.77,68.57 294.96,74.75 v1(294.96,84.66) ; QL1.2 QL1.5 252.39,100.4 252.45,100.46 252.45,100.87 252.03,101.29 v1(251.92,101.29) ; QL2.2 238.14,102.94 238.7,103.49 v1(238.7,103.65) ; v1(252.4,90.4) 252.4,91.11 252.67,91.38 254.34,91.38 255.03,90.69 v1(255.03,90.68) 254.8,90.45 QZ3.2
  IN2 w0.122: v1(294.96,84.66) 296.98,84.66 299.12,82.52 299.12,73.92 294.06,68.85 294.06,54.49 295.49,53.05 295.49,51.04 295.97,50.56 295.97,46.52 v1(295.01,45.56) ; v1(251.92,101.29) 251.24,101.29 248.89,103.63 240.81,103.63 240.3,104.15 239.19,104.15 v1(238.7,103.65)
  IN3 w0.122: v1(284.99,68.62) 284.63,68.98 273.89,68.98 272.64,70.22 269.2,70.22 268.41,71.01 258.89,71.01 v1(257.67,72.23)
  BOTTOM w0.102: v1(252.4,90.4) 252.06,90.74 252.06,95.96 251.59,96.43 251.59,100.95 v1(251.92,101.29) ; v1(257.67,72.23) 257.19,72.71 257.19,75.25 v1(256.92,75.52) 256.72,75.72 256.72,82.14 257.42,82.84 257.84,82.84 258.28,83.29 258.28,84.69 257.48,85.49 257.48,86.64 255.03,89.09 v1(255.03,90.68) ; v1(294.96,84.66) 294.96,85.13 296.74,86.91 304.66,86.91 305.44,87.68 308.94,87.68 309.25,87.38 309.52,87.38 309.66,87.24 QZ7.2
SYS_PWROK: length 270.1
  TOP w0.102: v1(95.76,24.44) 95.17,25.03 JXDP1.47 90.6,25.03 CC22.1 RC120.1 ; v1(261.02,58) 261.52,58.5 UE2.B7 ; v1(177.81,37.99) v4(177.81,36.64)
  IN1 w0.086: v1(170.26,55.22) 170.41,55.38 171.98,55.38 172.36,55.01 172.84,55.01
  IN1 w0.089: 172.84,55.01 172.97,55.01 173.14,55.17 177.46,55.17 177.93,54.7 178.99,54.7 181.16,52.52 184.97,52.52 185.32,52.87 189.95,52.87 190.41,52.42 190.92,52.42 191.81,51.53 191.81,50.81 193.55,49.07 193.55,46.79 195.55,44.78 195.55,40.43 198.04,37.94 199.46,37.94 200.95,36.45 212.85,36.45 215.38,33.92 225.7,33.92 231.32,39.54 231.32,39.93 236,44.61 239.25,44.61 242.53,47.9 247.77,47.9 248.71,46.97 255.14,46.97 255.68,47.5 258.36,47.5 258.45,47.6 260.11,47.6 v1(260.57,47.13) ; v1(177.81,37.99) 177.88,37.92 177.88,27.24 178.64,26.48 v1(178.73,26.48)
  IN2 w0.086: v1(170.26,55.22) 169.46,54.42 165.54,54.42 164.88,53.76 164.88,49.96 164.16,49.24 164.16,48.52 163.81,48.17 163.4,48.17 162.15,46.92 162.15,45.41 168.64,38.92 169.86,38.92 170.35,38.43 170.65,38.43
  IN2 w0.122: 170.65,38.43 170.93,38.43 171.06,38.3 171.07,38.3 171.63,37.74 174.86,37.74 174.99,37.61 177.44,37.61 177.73,37.91 177.73,37.91 v1(177.81,37.99)
  IN4 w0.089: v1(261.02,58) 261.02,57.99 261.51,57.51 262.28,57.51 262.55,57.24 262.55,54.39 263.17,53.77 263.17,50.22 262.35,49.4 261.29,49.4 260.76,48.87 260.76,47.31 v1(260.57,47.13)
  BOTTOM w0.076: UC1.AG2 168.43,55.52 168.73,55.22 169.21,55.22 169.52,54.9 169.94,54.9 v1(170.26,55.22)
  BOTTOM w0.102: v1(95.76,24.44) 96.01,24.18 96.01,24.17 97.13,23.05 102.55,23.05 103.44,23.94 108.62,23.94 112.36,27.68 174.36,27.68 176.44,25.59 177.84,25.59 v1(178.73,26.48)
SYS_RESET#: length 135.2
  TOP w0.102: UC4.4 174.91,59.65 174.74,59.48 174.52,59.48 173.16,58.12 172.56,58.12 v1(172.09,57.64) 172.64,57.09 173.8,57.09 174.46,56.43 174.46,56.35 v1(174.6,56.21) 174.6,56.25 175.06,56.71 RC77.2
  IN1 w0.089: v1(174.6,56.21) 175.08,55.74 175.36,55.74 176.22,56.6 178.98,56.6 181.32,54.26 185.25,54.26 185.36,54.37 185.69,54.37 185.69,54.36 186.38,54.36 186.52,54.51 191.42,54.51 191.99,53.94 193.5,53.94 194.02,53.42 194.02,46.98 196.02,44.98 196.02,40.62 198.21,38.44 199.67,38.44 201.16,36.94 213.06,36.94 v1(214.49,35.51)
  BOTTOM w0.076: 171.77,57.64 171.12,57.64 170.79,57.3 169.44,57.3 169.27,57.48 167.94,57.48 UC1.AC3
  BOTTOM w0.102: JAPS1.13 232.19,78.58 232.49,78.29 232.71,78.29 233.2,77.8 233.49,77.8 235.75,75.54 235.75,72.86 238.67,69.94 238.67,61.14 239.09,60.72 239.09,59.63 239.09,56.82 236.96,54.69 236.96,49.14 235.05,47.23 233.34,47.23 230.59,44.48 230.59,44.21 229.74,43.36 229.74,42.75 227.42,40.42 227.42,36.14 225.61,34.33 215.67,34.33 v1(214.49,35.51) ; 171.77,57.64 v1(172.09,57.64)
TDI_IREF: length 8.6
  BOTTOM w0.254: 161.39,70.73 161.39,69.93 161.52,69.81 UC1.B12
  BOTTOM w0.381: 161.39,70.73 161.39,70.93 161.3,71.02 161.3,72.24 161,72.54 161,72.56 159.87,73.69 v2(159.87,75.73) 160.57,76.43 160.57,76.82 RC186.2
TDI_XDP_R: length 3.8
  TOP w0.102: UC7.5 v2(109.39,37.14) 110.06,37.14 RC118.1 RC99.2
TDO_XDP: length 25.3
  TOP w0.102: RC115.1 108.03,35.63 UC7.2 ; RC115.1 RC98.2 ; RC115.1 109.46,34.51 v2(109.46,34.36) 109.46,26.56 105.58,22.67 103.21,22.67 RC117.2 101.86,24.03 JXDP1.52
THERMATRIP2#: length 6.3
  TOP w0.102: QE4.1 251.52,67.38 251.57,67.43 RE69.2 CE36.1 252.87,67.02 v2(252.87,66.19) 252.87,65.37 253.85,64.39 UE2.B34
THERMATRIP3#: length 21.2
  TOP w0.102: UE2.A2 264.32,56.25 v1(264.77,55.81) ; v1(250.23,56.37) 250.04,56.56 250.04,56.77 249.83,56.97 RPE6.1
  IN1 w0.089: v1(250.23,56.37) 250.23,56.96 250.55,57.28 252.96,57.28 253.4,57.72 255.24,57.72 255.37,57.6 262.27,57.6 262.56,57.3 265.33,57.3 265.77,56.86 265.77,56.43 265.53,56.19 265.15,56.19 v1(264.77,55.81)
THSEL_STRAP: length 7.3
  TOP w0.102: UE2.B29 256.35,63.23 256.73,62.85 v1(256.87,62.85) ; v1(256.92,66.31) 256.92,66.78 257.09,66.94 RE78.1
  IN4 w0.089: v1(256.92,66.31) 257.42,65.81 257.42,63.17 257.1,62.85 v1(256.87,62.85)
  BOTTOM w0.102: v1(256.92,66.31) 256.83,66.4 v2(256.83,66.87)
TMDS_CLK#_C: length 3
  TOP w0.102: CV13.1 94.85,104.83 94.46,105.22 94.46,105.39 RV17.1 94.46,106.05 94.46,106.3 94.33,106.42 94.33,106.78 LV3.1
TMDS_CLK_C: length 3
  TOP w0.102: LV3.4 94.12,106.78 94.12,106.34 94.25,106.21 94.25,106.05 RV16.1 94.25,105.39 94.25,105.06 94.02,104.83 CV14.1
TMDS_CON_CLK: length 6.5
  TOP w0.102: LV3.3 93.8,109.18 94.14,109.52 94.14,109.66 93.95,109.84 93.65,109.84 93.63,109.82 93.03,109.82 93.01,109.84 92.08,109.84 v3(91.76,110.16) 91.46,110.46 90.64,110.46 90.13,110.98 90.13,111.29 JHDMI1.10
TMDS_CON_CLK#: length 6.4
  TOP w0.102: JHDMI1.12 90.34,111.36 90.34,111.07 90.73,110.67 91.54,110.67 91.69,110.53 91.71,110.53 92.14,110.11 92.14,110.08 92.16,110.05 v3(93.33,110.05) 94.04,110.05 94.35,109.74 94.35,109.59 94.65,109.29 LV3.2
TMDS_CON_N0: length 13.9
  TOP w0.102: LV6.3 85.73,108.44 86.06,108.76 86.06,109.08 85.85,109.29 v1(85.84,109.29)
  IN1 w0.089: v1(85.84,109.29) 86.15,108.97 86.15,108.6 86.38,108.38 86.93,108.38 87.34,108.8 87.34,109.51 86.83,110.03 85.21,110.03 84.73,110.51 84.73,111.66 85.5,112.43 88.57,112.43 88.78,112.65 88.78,112.81 JHDMI1.9
TMDS_CON_N1: length 7.6
  TOP w0.102: LV9.2 92.02,108.49 91.73,108.77 91.73,109.25 91.42,109.56 v3(90.62,109.56) 89.99,109.56 89.87,109.68 89.87,110.29 89.09,111.06 87.48,111.06 87.34,111.2 87.34,111.37 JHDMI1.6
