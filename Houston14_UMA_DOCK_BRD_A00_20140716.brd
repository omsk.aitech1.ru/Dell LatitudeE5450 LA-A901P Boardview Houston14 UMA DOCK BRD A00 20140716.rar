# Allegro board Houston14_UMA_DOCK_BRD_A00_20140716.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_A_D4: length 66.2
  IN4 w0.086: 125.05,54.13 124.97,54.13
  IN4 w0.089: v1(131.69,5.01) 130.25,6.46 130.25,9.27 120.14,19.37 120.14,43.46 123.95,47.27 123.95,51.03 123.46,51.52 123.46,52.69 124.89,54.13 124.97,54.13 ; v1(125.46,54.13) 125.05,54.13
  BOTTOM w0.076: UC1.AH61 131.27,55.34 130.61,55.34 130.51,55.39 130.47,55.41 130.02,55.41 129.8,55.19 127.71,55.19
  BOTTOM w0.089: v1(125.46,54.13) 126,54.67 127.18,54.67 127.71,55.19
  BOTTOM w0.102: v1(131.69,5.01) 131.54,5.01 130.66,4.13 JDIMM1.132
DDR_A_D5: length 66.6
  IN4 w0.089: v1(131.69,6.54) 131.13,6.54 130.6,7.07 130.6,9.42 120.44,19.58 120.44,43.34 124.25,47.15 124.25,51.89 v1(123.9,52.24)
  BOTTOM w0.076: UC1.AH60 132.31,54.19 132.1,53.99 131.86,53.99 131.84,54 131.47,54 131.45,53.99 131.27,53.99 131.25,54 131.22,54.01 131.2,54.02 131.11,54.06 130.9,54.06 130.83,54.03 130.74,53.99 130.61,53.99 130.59,54 130.46,54.06 130.17,54.06 129.91,53.81 129.64,53.81 129.61,53.78 127.63,53.78 126.18,52.32
  BOTTOM w0.102: v1(131.69,6.54) 130.82,5.66 130.82,5.08 130.62,4.89 130.06,4.32 JDIMM1.130 ; v1(123.9,52.24) 126.1,52.24 126.18,52.32
DDR_A_D6: length 65.1
  IN4 w0.089: v1(127.58,53.21) 128.08,52.71 128.08,51.42 126.45,49.79 126.45,45.4 123.83,42.78 123.83,42.36 123.74,42.27 123.49,42.27 123.4,42.18 123.4,41.86 123.49,41.78 123.74,41.78 123.83,41.69 123.83,41.37 123.74,41.28 123.49,41.28 123.4,41.19 123.4,40.87 123.49,40.78 123.74,40.78 123.83,40.7 123.83,40.38 123.74,40.29 123.51,40.29 123.38,40.16 123.38,39.92 123.51,39.79 123.74,39.79 123.83,39.71 123.83,39.39 123.74,39.3 123.51,39.3 123.38,39.17 123.38,38.93 123.51,38.8 123.74,38.8 123.83,38.71 123.83,38.37 123.74,38.28 123.47,38.28 123.38,38.19 123.38,37.87 123.47,37.78 123.74,37.78 123.83,37.69 123.83,37.37 123.74,37.28 123.47,37.28 123.38,37.19 123.38,36.87 123.47,36.78 123.74,36.78 123.83,36.69 123.83,22.41 124.66,21.58 124.66,21.35 133.62,12.38 133.62,11.7 133.85,11.48 133.85,11.35 133.75,11.25 133.75,11.12 133.98,10.9 134.1,10.9 134.2,11 134.33,11 135.04,10.29 135.04,8.2 134.9,8.06 v1(134.64,8.06)
  BOTTOM w0.076: UC1.AK61 131.31,53.71 131.18,53.85 131.12,53.87 131.07,53.9 130.94,53.9 130.92,53.89 130.92,53.89 130.84,53.85 130.84,53.85 130.78,53.82 130.58,53.82 130.53,53.85 130.42,53.9 130.23,53.9 129.98,53.64 129.71,53.64 129.6,53.54 127.91,53.54 v1(127.58,53.21)
  BOTTOM w0.102: JDIMM1.143 133.96,10.28 134.25,9.99 134.8,9.99 135.04,9.75 135.04,8.47 v1(134.64,8.06)
DDR_A_D7: length 66.1
  IN4 w0.089: v1(134.64,5.01) 134.22,5.01 134.11,5.12 134.11,5.82 134,5.93 133.53,5.93 133.4,5.81 133.4,5.51 133.27,5.39 132.91,5.39 132.78,5.51 132.78,6.3 132.91,6.43 133.77,6.43 133.86,6.52 133.86,9.47 129.62,13.72 129.62,14.39 123.74,20.27 123.74,21.2 122.9,22.04 122.9,23.38 122.4,23.88 122.4,42.65 125.8,46.06 125.8,51.27 v1(126,51.47)
  BOTTOM w0.076: UC1.AK60 132.07,53.71 131.78,53.42 131.53,53.42 131.52,53.44 131.25,53.44 131.13,53.31 130.71,53.31 130.55,53.15 129.92,53.15 129.8,53.03 128.55,53.03 127.62,52.1 127.42,52.1 126.8,51.47 v1(126,51.47)
  BOTTOM w0.102: v1(134.64,5.01) 134.15,5.01 133.66,4.52 JDIMM1.142
DDR_A_D8: length 70.6
  IN1 w0.089: v1(89.67,7.98) 89.78,8.09 91.14,8.09 91.27,8.22 91.27,8.5 91.14,8.63 90.22,8.63 90.09,8.75 90.09,9.04 90.22,9.17 91.14,9.17 91.27,9.3 91.27,13.24 94.68,16.65 94.68,18.53 104.34,28.19 105.69,28.19 118.09,40.6 119.55,40.6 125.16,46.2 125.16,47.37 127.28,49.5 v1(127.28,50.06)
  BOTTOM w0.076: UC1.AM63 130,52.53 129.93,52.46 128.77,52.46 128.09,51.78 128.09,51.41 127.28,50.6 v1(127.28,50.06)
  BOTTOM w0.102: v1(89.67,7.98) 90.76,9.08 JDIMM1.7
DDR_A_D9: length 71.2
  IN1 w0.089: v1(89.67,4.94) 88.94,5.67 88.94,12.24 93.75,17.06 93.75,18.9 103.99,29.14 105.34,29.14 117.73,41.52 119.17,41.52 124.24,46.6 124.24,49.05 126.48,51.29 v1(127.14,51.29)
  BOTTOM w0.076: UC1.AM62 130.77,52.53 130.48,52.82 130.06,52.82 129.93,52.69 128.77,52.69 127.93,51.84 127.93,51.53 127.68,51.29 v1(127.14,51.29)
  BOTTOM w0.102: v1(89.67,4.94) 89.86,4.74 JDIMM1.4
DDR_A_D10: length 69.6
  IN1 w0.089: v1(127.97,48.61) 127.97,47.89 126.09,46.02 126.09,45.01 119.3,38.22 117.89,38.22 105.31,25.63 103.91,25.63 102.94,24.66 102.94,24.53 103.29,24.18 103.29,24.01 103.09,23.81 102.91,23.81 102.61,24.1 102.43,24.1 102.11,23.78 102.11,23.6 102.82,22.89 102.82,22.6 100.56,20.34 100.43,20.34 99.67,21.1 99.38,21.1 97.13,18.85 97.13,18.73 97.24,18.62 97.24,18.44 97.07,18.27 96.89,18.27 96.78,18.38 96.66,18.38 96.22,17.94 96.22,17.64 96.91,16.95 96.91,16.69 93.93,13.71 93.93,8.4 93.51,7.98 v1(92.74,7.98)
  BOTTOM w0.076: UC1.AP63 129.92,51.17 129.39,50.65 129.07,50.65 127.97,49.54 v1(127.97,48.61)
  BOTTOM w0.102: JDIMM1.17 93.76,9 v1(92.74,7.98)
DDR_A_D11: length 71.1
  IN1 w0.089: v1(92.74,6.46) 94.23,7.96 94.23,13.59 97.43,16.79 97.43,16.91 96.81,17.54 96.81,17.72 96.98,17.89 97.16,17.89 97.78,17.26 97.91,17.26 98.13,17.49 98.13,17.61 97.54,18.21 97.54,18.38 97.71,18.56 97.71,19 99.3,20.59 99.63,20.59 100.25,19.97 100.61,19.97 103.12,22.48 103.12,23.37 105.08,25.33 105.43,25.33 118.01,37.91 119.42,37.91 126.74,45.23 126.74,45.35 126.48,45.61 126.48,45.75 126.59,45.86 126.74,45.86 126.99,45.6 127.12,45.6 128.36,46.85 v1(128.36,49)
  BOTTOM w0.076: UC1.AP62 130.77,51.17 130.48,50.88 129.86,50.88 129.46,50.48 129.14,50.48 128.36,49.7 v1(128.36,49)
  BOTTOM w0.102: JDIMM1.18 94.06,5.14 v1(92.74,6.46)
DDR_A_D12: length 71.5
  IN1 w0.089: v1(127.54,51.69) 127.54,51.11 124.55,48.12 124.55,46.47 119.28,41.21 117.84,41.21 105.47,28.83 104.12,28.83 94.07,18.78 94.07,16.9 89.24,12.07 89.24,6.89 v1(89.67,6.46)
  BOTTOM w0.076: v1(127.54,51.69) 127.71,51.85 127.71,51.95 128.61,52.85 129.86,52.85 129.99,52.98 130.55,52.98 130.71,52.82 131.13,52.82 131.53,52.42 UC1.AM61
  BOTTOM w0.102: JDIMM1.6 90.46,5.67 v1(89.67,6.46)
DDR_A_D13: length 72.8
  IN1 w0.089: v1(89.67,9.51) 90.77,9.51 90.97,9.71 90.97,9.99 90.84,10.12 89.69,10.12 89.6,10.21 89.6,10.52 89.69,10.61 90.84,10.61 90.97,10.74 90.97,10.98 90.84,11.11 89.74,11.11 89.61,11.24 89.61,11.48 89.74,11.6 90.84,11.6 90.97,11.73 90.97,12.03 90.84,12.16 90.44,12.16 90.31,12.28 90.31,12.52 90.44,12.65 90.84,12.65 90.97,12.78 90.97,13.37 94.37,16.78 94.37,18.66 104.21,28.49 105.56,28.49 117.97,40.9 119.41,40.9 124.85,46.34 124.85,47.59 v1(126.9,49.64)
  BOTTOM w0.076: v1(126.9,49.64) 127.6,49.64 128.94,50.98 129.23,50.98 129.89,51.63 130.46,51.63 130.59,51.57 130.63,51.57 130.66,51.56 130.74,51.56 130.83,51.6 130.9,51.63 131.11,51.63 131.2,51.59 131.22,51.58 131.25,51.57 131.27,51.56 132.1,51.56 132.31,51.76 UC1.AM60
  BOTTOM w0.102: v1(89.67,9.51) 90.16,10 JDIMM1.5
DDR_A_D14: length 70.6
  IN1 w0.089: v1(127.1,47.74) 125.9,46.54 125.9,45.25 119.17,38.52 117.76,38.52 105.18,25.94 103.79,25.94 101.45,23.6 101.45,23.47 102.29,22.63 102.29,22.51 102.06,22.28 101.94,22.28 101.1,23.12 100.97,23.12 100.75,22.9 100.75,22.77 101.59,21.93 101.59,21.81 101.36,21.58 101.24,21.58 100.4,22.42 100.27,22.42 100.05,22.2 100.05,22.07 100.89,21.23 100.89,21.1 100.66,20.88 100.54,20.88 99.7,21.72 99.57,21.72 95.91,18.06 95.91,16.13 93.62,13.84 93.62,10.39 v1(92.74,9.51)
  BOTTOM w0.076: v1(127.1,47.74) 127.1,48.91 129,50.81 129.3,50.81 129.96,51.47 130.42,51.47 130.53,51.42 130.58,51.39 130.78,51.39 130.84,51.42 130.84,51.42 130.92,51.46 130.92,51.46 130.94,51.47 131.07,51.47 131.12,51.44 131.18,51.42 131.42,51.17 UC1.AP61
  BOTTOM w0.102: v1(92.74,9.51) 93.16,9.93 JDIMM1.15
DDR_A_D15: length 71.5
  IN1 w0.089: v1(92.74,4.94) 94.54,6.74 94.54,10.36 94.63,10.45 95.34,10.45 95.43,10.54 95.43,10.85 95.34,10.94 94.63,10.94 94.54,11.03 94.54,11.35 94.63,11.44 95.34,11.44 95.43,11.53 95.43,11.84 95.34,11.93 94.63,11.93 94.54,12.02 94.54,12.46 94.63,12.55 95.01,12.55 95.1,12.63 95.1,12.95 95.01,13.04 94.63,13.04 94.54,13.13 94.54,13.46 94.68,13.6 95.2,13.6 95.38,13.79 95.38,14.3 98.83,17.75 98.98,17.75 103.43,22.21 103.43,23.24 104.96,24.77 105.3,24.77 118.14,37.61 119.55,37.61 128.76,46.82 v1(128.76,49.4)
  BOTTOM w0.076: UC1.AP60 132.08,50.95 131.84,50.95 131.78,50.88 131.53,50.88 131.52,50.89 131.14,50.89 131.13,50.88 130.71,50.88 130.55,50.72 129.97,50.72 129.57,50.32 129.21,50.32 128.76,49.87 v1(128.76,49.4)
  BOTTOM w0.102: JDIMM1.16 93.46,4.22 v1(92.74,4.94)
DDR_A_D16: length 60.1
  IN4 w0.089: v1(139.46,9.58) 139.46,9.64 138.77,10.34 138.77,10.91 138.31,11.36 138.31,11.98 137.77,12.52 137.77,13.2 134.15,16.82 134.03,16.82 133.81,16.6 133.69,16.6 133.46,16.83 133.46,16.95 133.68,17.17 133.68,17.29 133.45,17.52 133.33,17.52 133.11,17.31 132.99,17.31 132.76,17.53 132.76,17.66 132.97,17.87 132.97,17.99 132.7,18.27 132.56,18.27 132.36,18.06 132.23,18.06 132.01,18.28 132.01,18.41 132.21,18.61 132.21,18.79 132.03,18.96 131.86,18.96 131.66,18.76 131.53,18.76 131.31,18.99 131.31,19.11 131.5,19.31 131.5,19.49 131.3,19.69 131.12,19.69 130.93,19.49 130.8,19.49 130.58,19.72 130.58,19.84 130.77,20.04 130.77,20.22 130.6,20.39 130.42,20.39 130.23,20.19 130.1,20.19 129.88,20.42 129.88,20.54 130.01,20.68 130.01,20.81 129.79,21.03 129.66,21.03 129.53,20.89 129.4,20.89 129.17,21.12 129.17,21.24 129.31,21.38 129.31,21.51 129.09,21.73 128.96,21.73 128.82,21.59 128.7,21.59 128.47,21.82 128.47,21.94 128.61,22.08 128.61,22.21 128.46,22.36 128.46,22.55 128.72,22.81 128.72,22.99 128.56,23.14 128.38,23.14 127.94,22.7 127.76,22.7 127.59,22.87 127.59,23.05 128.07,23.53 128.07,23.66 127.85,23.88 127.72,23.88 127.44,23.6 127.33,23.6 127.22,23.71 127.22,24.08 127.37,24.23 127.37,24.36 127.22,24.51 127.22,41.68 127.41,41.88 127.41,43.4 130.06,46.05 130.44,46.05 133.49,49.1 133.49,50.68 v1(133.13,51.04)
  BOTTOM w0.076: UC1.AP58 133.45,51.37 v1(133.13,51.04)
  BOTTOM w0.102: v1(139.46,9.58) 138.76,10.29 JDIMM1.159
DDR_A_D17: length 59.7
  IN4 w0.089: v1(133.13,50.39) 132.96,50.22 132.96,49.22 127.21,43.48 127.21,41.99 126.91,41.69 126.91,23.26 127.28,22.89 127.28,22.58 133.68,16.18 133.85,16.18 134.04,16.37 134.16,16.37 134.32,16.22 134.32,16.09 134.1,15.88 134.1,15.76 134.33,15.53 134.45,15.53 134.67,15.74 134.79,15.74 135.02,15.52 135.02,15.39 134.81,15.18 134.81,15.06 135.03,14.83 135.16,14.83 135.37,15.04 135.49,15.04 136.59,13.95 136.59,13.31 136.68,13.22 136.91,13.22 137.06,13.38 137.15,13.38 137.47,13.07 137.47,12.91 137.26,12.7 137.26,12.59 138,11.85 138,11.24 138.4,10.84 138.4,9.88 138.53,9.75 138.93,9.75 139.05,9.62 139.05,9.38 138.93,9.25 138.82,9.25 138.69,9.12 138.69,8.83 138.82,8.7 138.93,8.7 139.05,8.58 139.05,8.28 138.93,8.16 138.75,8.16 138.66,8.07 138.66,7.57 138.8,7.43 138.98,7.43 139.23,7.68 139.34,7.68 139.46,7.8 v1(139.46,8.06)
  BOTTOM w0.076: v1(133.13,50.39) 133.45,50.72 UC1.AR58
  BOTTOM w0.102: JDIMM1.157 138.16,9.36 v1(139.46,8.06)
DDR_A_D18: length 62.8
  IN4 w0.089: v1(134.02,52.45) 133.63,52.85 133.63,53.59 133.28,53.94 132.97,53.94 132.59,53.55 132.59,53.37 130.05,50.83 130.05,49.48 126.82,46.26 126.82,44.69 125.02,42.89 125.02,42.71 124.63,42.32 124.63,22.74 125.46,21.92 125.46,21.68 134.42,12.71 134.42,12.04 136.13,10.33 136.13,7.33 v1(136.92,6.54)
  BOTTOM w0.076: UC1.AM57 134.23,52.67 v1(134.02,52.45)
  BOTTOM w0.102: JDIMM1.146 134.86,4.47 v1(136.92,6.54)
DDR_A_D19: length 63.8
  IN4 w0.089: v1(136.92,5.01) 136.92,4.85 136.79,4.73 135.94,4.73 135.81,4.85 135.81,10.22 134.12,11.91 134.12,12.58 125.15,21.55 125.15,21.79 124.32,22.62 124.32,42.58 126.64,44.9 126.64,46.47 129.77,49.6 129.77,50.81 132.25,53.28 132.25,53.61 132.75,54.11 133.7,54.11 134.02,53.79 v1(134.02,53.74)
  BOTTOM w0.076: UC1.AK57 134.21,53.97 134.02,53.78 v1(134.02,53.74)
  BOTTOM w0.102: v1(136.92,5.01) 136.86,5.01 136.5,4.65 135.92,4.65 135.46,4.2 JDIMM1.148
DDR_A_D20: length 62.2
  IN4 w0.086: 125.87,41.6 125.63,41.36 125.63,40.92
  IN4 w0.089: v1(136.92,9.58) 137.03,9.7 137.03,10.31 136.65,10.7 136.65,11.04 136.5,11.19 136.16,11.19 135.03,12.31 135.03,12.99 126.07,21.95 126.07,22.17 125.71,22.52 125.71,29.23 125.62,29.32 125.34,29.32 125.25,29.41 125.25,29.73 125.34,29.82 125.62,29.82 125.71,29.91 125.71,30.22 125.62,30.31 125.34,30.31 125.25,30.4 125.25,30.72 125.34,30.81 125.62,30.81 125.71,30.9 125.71,31.37 125.62,31.46 125.34,31.46 125.25,31.55 125.25,31.86 125.34,31.95 125.62,31.95 125.71,32.04 125.71,32.36 125.62,32.45 125.34,32.45 125.25,32.54 125.25,32.85 125.34,32.94 125.62,32.94 125.71,33.03 125.71,33.35 125.62,33.44 125.34,33.44 125.25,33.53 125.25,33.84 125.34,33.93 125.62,33.93 125.71,34.02 125.71,34.34 125.62,34.43 125.34,34.43 125.25,34.52 125.25,34.84 125.34,34.92 125.62,34.92 125.71,35.01 125.71,35.38 125.62,35.47 125.34,35.47 125.25,35.56 125.25,35.88 125.34,35.97 125.62,35.97 125.71,36.06 125.71,36.37 125.62,36.46 125.34,36.46 125.25,36.55 125.25,36.87 125.34,36.96 125.62,36.96 125.71,37.05 125.71,37.36 125.62,37.45 125.34,37.45 125.25,37.54 125.25,37.86 125.34,37.95 125.62,37.95 125.71,38.04 125.71,38.35 125.62,38.44 125.34,38.44 125.25,38.53 125.25,38.85 125.34,38.94 125.62,38.94 125.71,39.03 125.71,39.44 125.59,39.56 125.34,39.56 125.25,39.65 125.25,40.39 125.39,40.53 125.5,40.53 125.63,40.66 125.63,40.92 ; 125.87,41.6 126.08,41.81 126.08,43.45 127.24,44.61 127.24,45.82 130.75,49.33 130.75,50.74 132.96,52.95 v1(133.14,52.95)
  BOTTOM w0.076: UC1.AL58 133.5,53.32 v1(133.14,52.95)
  BOTTOM w0.102: v1(136.92,9.58) 136.6,9.58 135.76,10.42 JDIMM1.149
DDR_A_D21: length 63.2
  IN4 w0.086: 125.01,41.07 125.01,40.92
  IN4 w0.089: v1(133.13,53.56) 130.43,50.87 130.43,49.35 127.04,45.95 127.04,44.66 125.9,43.52 125.9,41.97 125.01,41.07 ; 125.01,40.92 124.95,40.86 124.95,29.1 125.06,29 125.3,29 125.41,28.89 125.41,28.55 125.32,28.46 125.02,28.46 124.93,28.37 124.93,28.05 125.02,27.96 125.32,27.96 125.41,27.88 125.41,27.56 125.32,27.47 125.02,27.47 124.93,27.38 124.93,27.06 125.02,26.97 125.32,26.97 125.41,26.89 125.41,26.56 125.32,26.47 125.02,26.47 124.93,26.38 124.93,26.07 125.02,25.98 125.32,25.98 125.41,25.89 125.41,25.57 125.32,25.48 125.02,25.48 124.93,25.39 124.93,25.08 125.02,24.99 125.32,24.99 125.41,24.9 125.41,24.47 125.32,24.38 125.02,24.38 124.93,24.29 124.93,23.98 125.02,23.89 125.32,23.89 125.41,23.8 125.41,23.43 125.32,23.34 125.07,23.34 124.94,23.21 124.94,22.97 125.07,22.85 125.32,22.85 125.41,22.76 125.41,22.4 125.76,22.04 125.76,21.8 134.73,12.84 134.73,12.16 136.51,10.38 136.51,8.47 v1(136.92,8.06)
  BOTTOM w0.076: UC1.AK58 133.53,53.97 v1(133.13,53.56)
  BOTTOM w0.102: JDIMM1.147 135.16,10.5 135.97,9.69 135.97,9.59 136.22,9.34 136.22,8.38 136.54,8.06 v1(136.92,8.06)
DDR_A_D22: length 60.5
  IN4 w0.089: v1(139.46,5.01) 139.34,5.01 139.22,4.89 139.22,4.21 139.34,4.08 140.92,4.08 141.05,4.21 141.05,4.55 140.92,4.68 140.3,4.68 140.17,4.81 140.17,10.37 138.92,11.61 138.92,12.95 131.52,20.35 131.52,21.07 127.93,24.66 127.93,41.76 128.56,42.39 128.56,44.02 129.95,45.41 130.31,45.41 134.08,49.19 v1(134.08,50.39)
  BOTTOM w0.076: UC1.AR57 134.4,50.72 v1(134.08,50.39)
  BOTTOM w0.102: JDIMM1.158 138.46,4 139.48,5.01 v1(139.46,5.01)
DDR_A_D23: length 61.8
  IN4 w0.089: v1(134.08,51.69) 133.69,51.31 133.69,49.05 130.36,45.72 130,45.72 127.72,43.45 127.72,41.87 127.52,41.67 127.52,24.64 129.19,22.97 129.19,22.85 128.86,22.52 128.86,22.4 129.08,22.17 129.21,22.17 129.54,22.5 129.66,22.5 129.89,22.27 129.89,22.15 129.56,21.82 129.56,21.7 129.78,21.47 129.91,21.47 130.24,21.8 130.36,21.8 130.59,21.57 130.59,21.45 130.26,21.12 130.26,20.99 130.48,20.77 130.61,20.77 130.94,21.1 131.06,21.1 131.22,20.94 131.22,20.69 131.03,20.5 131.03,20.41 138.62,12.82 138.62,11.49 139.14,10.96 139.14,10.4 139.3,10.24 139.77,10.24 139.86,10.14 139.86,6.67 139.73,6.54 v1(139.46,6.54)
  BOTTOM w0.076: UC1.AN57 134.4,52.02 v1(134.08,51.69)
  BOTTOM w0.102: v1(139.46,6.54) 140,6 140,4.84 139.5,4.33 139.32,4.33 139.06,4.07 JDIMM1.160
DDR_A_D24: length 67.4
  IN1 w0.089: v1(95.28,6.46) 96.24,7.42 96.24,9.31 96.64,9.71 96.64,13.85 112.92,30.13 112.92,30.67 113.43,31.18 113.56,31.18 113.66,31.08 113.79,31.08 114.01,31.3 114.01,31.43 113.91,31.53 113.91,31.66 114.09,31.84 114.24,31.84 114.44,31.64 114.61,31.64 116,33.03 116.41,33.03 119.85,36.48 120.26,36.48 126.24,42.45 126.24,43.05 130.24,47.06 131.04,47.06 133.26,49.28 133.73,49.28 134.64,50.19 134.64,50.65 v1(135.03,51.04)
  BOTTOM w0.076: UC1.AP55 135.36,51.37 v1(135.03,51.04)
  BOTTOM w0.102: v1(95.28,6.46) 95.86,5.88 JDIMM1.24
DDR_A_D25: length 66.2
  IN1 w0.086: 125.18,40.92 126.41,42.15 126.41,42.98 127.15,43.72 127.51,43.72
  IN1 w0.089: 127.51,43.72 130.67,46.88 131.11,46.88 133.33,49.1 133.8,49.1 135.03,50.33 v1(135.03,50.39) ; v1(95.28,4.94) 95.73,4.94 96.6,5.81 96.6,9.18 96.96,9.54 96.96,13.72 113.46,30.22 113.62,30.22 115.33,31.93 115.45,31.93 115.51,31.87 115.64,31.87 115.86,32.1 115.86,32.22 115.81,32.28 115.81,32.41 116.03,32.63 116.16,32.63 116.21,32.57 116.38,32.57 119.96,36.15 120.41,36.15 125.18,40.92
  BOTTOM w0.076: UC1.AR55 135.36,50.72 v1(135.03,50.39)
  BOTTOM w0.102: v1(95.28,4.94) 95.26,4.92 JDIMM1.22
DDR_A_D26: length 70
  IN1 w0.086: 128.28,41.56 128.28,41.69
  IN1 w0.089: 128.28,41.69 134.2,47.62 134.88,47.62 136.52,49.26 136.52,51.31 136.36,51.48 136.36,51.97 v1(135.98,52.34) ; v1(98.41,6.46) 98.41,6.72 98.52,6.84 99.36,6.84 99.49,6.97 99.49,7.34 99.36,7.47 98.9,7.47 98.78,7.6 98.78,7.84 98.9,7.96 99.25,7.96 99.46,8.17 99.46,8.58 99.37,8.67 99.2,8.67 99.11,8.76 99.11,9.07 99.2,9.16 99.37,9.16 99.46,9.25 99.46,9.57 99.37,9.66 99.2,9.66 99.11,9.75 99.11,10.07 99.2,10.15 99.37,10.15 99.46,10.24 99.46,13.51 105.8,19.85 106.26,19.85 119.7,33.29 120.67,33.29 128.28,40.9 128.28,41.56
  BOTTOM w0.076: UC1.AM54 136.31,52.67 v1(135.98,52.34)
  BOTTOM w0.102: JDIMM1.36 99.46,4.2 99.06,4.6 99.06,5.81 v1(98.41,6.46)
DDR_A_D27: length 71
  IN1 w0.089: v1(135.93,53.64) 136.42,53.16 136.42,52.76 136.54,52.64 136.54,51.57 136.7,51.4 136.7,48.99 134.32,46.61 133.54,46.61 128.59,41.66 128.59,40.77 120.8,32.98 119.82,32.98 106.39,19.55 105.93,19.55 100.76,14.38 100.76,14.25 100.88,14.13 100.89,13.95 100.71,13.78 100.54,13.78 100.41,13.9 100.29,13.9 99.8,13.41 99.8,6.55 99.71,6.46 99.13,6.46 99.04,6.38 99.04,6.06 99.13,5.97 99.71,5.97 99.8,5.88 99.8,5.53 99.61,5.34 98.81,5.34 v1(98.41,4.94)
  BOTTOM w0.076: UC1.AK54 136.26,53.97 v1(135.93,53.64)
  BOTTOM w0.102: JDIMM1.34 98.86,4.19 98.7,4.35 98.7,4.64 v1(98.41,4.94)
DDR_A_D28: length 69.8
  IN1 w0.089: v1(135.03,52.99) 134.47,52.43 134.47,50.27 133.65,49.45 132.16,49.45 125.96,43.26 125.96,42.61 120.13,36.78 119.73,36.78 116.96,34.02 116.84,34.02 116.65,34.21 116.47,34.21 116.35,34.08 116.35,33.9 116.44,33.81 116.44,33.68 116.21,33.46 116.08,33.46 115.74,33.8 115.62,33.8 115.34,33.52 115.34,33.4 115.56,33.18 115.56,33.05 115.34,32.83 115.21,32.83 114.99,33.05 114.86,33.05 114.64,32.82 114.64,32.7 114.86,32.48 114.86,32.35 114.64,32.13 114.51,32.13 114.29,32.35 114.16,32.35 112.61,30.79 112.61,30.26 96.33,13.98 96.33,9.84 95.94,9.44 95.94,8.64 v1(95.28,7.98)
  BOTTOM w0.076: UC1.AL55 135.36,53.32 v1(135.03,52.99)
  BOTTOM w0.102: v1(95.28,7.98) 95.78,8.49 95.78,9.79 95.56,10.02 JDIMM1.23
DDR_A_D29: length 69.9
  IN1 w0.089: v1(134.98,53.64) 134.53,54.1 133.87,54.1 133.61,53.84 133.61,50.36 132.88,49.63 131.96,49.63 125.13,42.81 125.13,42.49 119.73,37.08 119.6,37.08 119.29,36.77 119.16,36.77 118.95,36.98 118.83,36.98 118.6,36.75 118.6,36.63 118.81,36.42 118.81,36.3 118.57,36.05 118.44,36.05 118.04,36.45 117.86,36.45 117.69,36.28 117.69,36.1 118.09,35.7 118.09,35.58 117.85,35.34 117.73,35.34 117.29,35.78 117.16,35.78 116.94,35.55 116.94,35.43 117.38,34.99 117.38,34.86 117.15,34.64 117.03,34.64 116.59,35.08 116.46,35.08 116.3,34.92 116.3,34.79 116.4,34.69 116.4,34.57 116.18,34.34 116.05,34.34 115.95,34.44 115.83,34.44 112.31,30.92 112.31,30.38 95.94,14.02 95.94,10.17 95.28,9.51 v1(95.28,9.51)
  BOTTOM w0.076: UC1.AK55 135.31,53.97 v1(134.98,53.64)
  BOTTOM w0.102: v1(95.28,9.51) 94.96,9.83 JDIMM1.21
DDR_A_D30: length 67.3
  IN1 w0.089: v1(98.41,9.51) 98.31,9.6 98.31,13.38 107.13,22.2 107.25,22.2 107.42,22.03 107.55,22.03 107.77,22.25 107.77,22.38 107.6,22.55 107.6,22.67 107.83,22.9 107.95,22.9 108.12,22.73 108.25,22.73 108.47,22.95 108.47,23.08 108.31,23.25 108.31,23.37 108.53,23.6 108.66,23.6 108.82,23.43 108.95,23.43 109.17,23.65 109.17,23.78 109.01,23.95 109.01,24.07 109.23,24.3 109.36,24.3 109.52,24.13 109.65,24.13 109.87,24.35 109.87,24.48 109.71,24.65 109.71,24.77 109.93,25 110.06,25 110.22,24.83 110.35,24.83 110.57,25.05 110.57,25.18 110.41,25.35 110.41,25.47 110.63,25.7 110.76,25.7 110.92,25.53 111.05,25.53 111.28,25.76 111.28,25.89 111.12,26.06 111.12,26.18 111.34,26.41 111.47,26.41 111.63,26.24 111.76,26.24 111.98,26.46 111.98,26.59 111.82,26.76 111.82,26.88 112.04,27.11 112.17,27.11 112.33,26.94 112.46,26.94 112.68,27.17 112.68,27.29 112.54,27.43 112.54,27.61 112.72,27.78 112.89,27.78 113.03,27.64 113.16,27.64 113.41,27.89 113.41,28.02 113.27,28.16 113.27,28.34 113.44,28.51 113.62,28.51 113.76,28.37 113.89,28.37 114.11,28.59 114.11,28.72 114.05,28.78 114.05,28.96 114.22,29.13 114.4,29.13 114.46,29.07 114.59,29.07 114.77,29.25 114.77,29.38 114.69,29.47 114.69,29.59 114.91,29.82 115.04,29.82 115.12,29.73 115.25,29.73 115.47,29.95 115.47,30.08 115.39,30.17 115.39,30.29 115.61,30.52 115.74,30.52 115.82,30.43 115.95,30.43 119.42,33.9 120.42,33.9 127.67,41.15 127.67,41.96 128.63,42.92 128.63,43.81 131.04,46.22 131.26,46.22 133.01,47.97 133.85,47.97 135.98,50.1 v1(135.98,50.39)
  BOTTOM w0.076: v1(135.98,50.39) 136.31,50.72 UC1.AR54
  BOTTOM w0.102: JDIMM1.33 98.56,9.66 v1(98.41,9.51)
DDR_A_D31: length 68.7
  IN1 w0.089: v1(98.41,7.98) 98.81,8.38 98.81,9.81 98.73,9.88 98.67,9.88 98.61,9.94 98.61,10.34 98.73,10.45 99.07,10.45 99.15,10.54 99.15,10.8 99.06,10.89 98.7,10.89 98.61,10.98 98.61,11.3 98.7,11.39 99.06,11.39 99.15,11.48 99.15,11.79 99.06,11.88 98.7,11.88 98.61,11.97 98.61,12.29 98.7,12.38 99.06,12.38 99.15,12.47 99.15,13.63 105.77,20.25 105.87,20.25 105.96,20.16 106.13,20.16 106.32,20.34 106.32,20.47 106.14,20.65 106.14,20.77 106.37,21 106.49,21 106.67,20.82 106.8,20.82 107.02,21.04 107.02,21.17 106.84,21.35 106.84,21.48 107.07,21.7 107.19,21.7 107.37,21.52 107.5,21.52 119.57,33.59 120.54,33.59 127.98,41.03 127.98,41.85 128.83,42.7 128.83,43.73 131.13,46.03 131.32,46.03 133.05,47.75 133.89,47.75 136.35,50.21 136.35,51.24 135.98,51.6 v1(135.98,51.69)
  BOTTOM w0.076: UC1.AN54 136.05,51.69 v1(135.98,51.69)
  BOTTOM w0.102: v1(98.41,7.98) 99.16,8.74 JDIMM1.35
DDR_A_D32: length 54.4
  IN4 w0.086: 128.75,43.96 128.75,41.81 128.42,41.48
  IN4 w0.089: v1(131,45.08) 129.87,45.08 128.75,43.96 ; 128.42,41.48 128.42,24.87 132.02,21.28 132.02,20.55 139.42,13.15 139.42,11.82 140.66,10.57 140.66,7.21 141.21,6.66 141.21,5.09 141.36,4.94 v1(141.85,4.94)
  BOTTOM w0.076: UC1.AY58 133.43,47.49 133.43,46.82 133.14,46.53 132.65,46.53 132.49,46.68 132.14,46.68 131,45.54 v1(131,45.08)
  BOTTOM w0.102: v1(141.85,4.94) 141.35,4.43 141.21,4.43 140.86,4.08 JDIMM1.166
DDR_A_D33: length 55.3
  IN4 w0.089: v1(129.86,43.81) 129.86,43.02 129.46,42.62 129.46,41.19 129.43,41.16 129.43,25.17 136.13,18.46 136.13,18.34 135.89,18.1 135.89,17.97 136.12,17.75 136.24,17.75 136.48,17.98 136.61,17.98 136.83,17.76 136.83,17.63 136.59,17.4 136.59,17.27 136.82,17.05 136.94,17.05 137.18,17.28 137.31,17.28 137.53,17.06 137.53,16.93 137.29,16.7 137.29,16.57 137.52,16.34 137.64,16.34 137.88,16.58 138.01,16.58 138.22,16.37 138.22,16.26 138.09,16.13 138.09,15.99 140.55,13.53 140.55,13.03 140.72,12.87 141.04,12.87 141.15,12.75 141.15,12.47 141.02,12.35 140.59,12.35 140.5,12.26 140.5,12.03 140.73,11.8 141.01,11.8 141.73,11.08 141.73,10.57 141.86,10.44 142.13,10.44 142.25,10.31 142.25,10.05 142.13,9.92 141.69,9.92 141.58,9.81 141.58,9.63 141.71,9.51 v1(141.85,9.51)
  BOTTOM w0.076: v1(129.86,43.81) 129.86,44.39 130.56,45.09 130.56,45.42 132.14,47 132.42,47 132.72,46.69 133.05,46.69 133.25,46.9 133.25,47.96 UC1.AW58
  BOTTOM w0.102: JDIMM1.165 140.56,9.11 140.71,8.96 141.07,8.96 141.19,9.09 141.19,9.38 141.32,9.51 v1(141.85,9.51)
DDR_A_D34: length 55.7
  IN4 w0.089: v1(133.71,45.74) 133.86,45.59 133.86,44.85 133.71,44.69 133.27,44.69 133.15,44.57 133.15,43.47 131.29,41.61 131.29,34.16 131.38,34.07 131.61,34.07 131.7,33.99 131.7,33.67 131.61,33.58 131.38,33.58 131.29,33.49 131.29,33.17 131.38,33.08 131.61,33.08 131.7,32.99 131.7,32.68 131.61,32.59 131.38,32.59 131.29,32.5 131.29,32.18 131.38,32.09 131.61,32.09 131.7,32 131.7,31.69 131.61,31.6 131.38,31.6 131.29,31.51 131.29,31.19 131.38,31.1 131.61,31.1 131.7,31.01 131.7,30.7 131.61,30.61 131.38,30.61 131.29,30.52 131.29,30.2 131.38,30.11 131.61,30.11 131.7,30.02 131.7,29.7 131.61,29.62 131.38,29.62 131.29,29.53 131.29,29.21 131.38,29.12 131.61,29.12 131.7,29.03 131.7,28.71 131.61,28.63 131.38,28.63 131.29,28.54 131.29,28.22 131.38,28.13 131.61,28.13 131.7,28.04 131.7,27.72 131.61,27.63 131.38,27.63 131.29,27.55 131.29,27.23 131.38,27.14 131.61,27.14 131.7,27.05 131.7,26.73 131.61,26.64 131.38,26.64 131.29,26.56 131.29,26.24 131.38,26.15 131.61,26.15 131.7,26.06 131.7,25.45 141.66,15.49 141.66,15.37 141.54,15.25 141.54,15.13 141.77,14.9 141.89,14.9 142.01,15.02 142.14,15.02 142.36,14.79 142.36,14.67 142.25,14.55 142.25,14.42 142.47,14.2 142.6,14.2 142.71,14.31 142.84,14.31 143.06,14.09 143.06,13.96 142.95,13.85 142.95,13.72 143.17,13.5 143.3,13.5 143.41,13.61 143.54,13.61 143.98,13.17 143.98,12.31 144.1,12.19 144.44,12.19 144.58,12.06 144.58,11.84 144.46,11.72 144.13,11.72 144.01,11.6 144.01,11.34 144.13,11.22 144.39,11.22 144.58,11.03 144.58,9.57 v1(144.64,9.51)
  BOTTOM w0.076: v1(133.71,45.74) 133.87,45.59 134,45.59 134.47,46.05 134.47,46.29 134.88,46.71 134.88,47.59 UC1.AY56
  BOTTOM w0.102: v1(144.64,9.51) 144.44,9.51 143.56,10.38 JDIMM1.175
DDR_A_D35: length 56.3
  IN4 w0.089: v1(132.85,44.87) 132.85,43.49 130.99,41.63 130.99,25.73 139.91,16.81 139.91,16.69 139.78,16.56 139.78,16.43 140,16.21 140.13,16.21 140.26,16.34 140.38,16.34 140.61,16.11 140.61,15.99 140.48,15.86 140.48,15.73 140.7,15.51 140.83,15.51 140.96,15.64 141.08,15.64 141.26,15.46 141.26,15.35 141.12,15.21 141.12,15.09 143.14,13.07 143.4,13.07 143.68,12.8 143.68,12.37 143.55,12.25 143.39,12.25 143.26,12.12 143.26,11.93 143.39,11.81 143.55,11.81 143.68,11.68 143.68,11.24 144.2,10.71 144.2,6.24 144.33,6.11 144.52,6.11 144.64,6.24 v1(144.64,6.46)
  BOTTOM w0.076: UC1.AW56 135.19,47.96 135.19,47.49 135.05,47.34 135.05,46.64 134.63,46.22 134.63,45.98 133.52,44.87 v1(132.85,44.87)
  BOTTOM w0.102: JDIMM1.174 143.26,5.08 v1(144.64,6.46)
DDR_A_D36: length 56.5
  IN4 w0.089: v1(129.32,43.71) 129.32,42.73 129.21,42.62 129.21,41.38 129.07,41.25 129.07,25.09 132.92,21.24 132.92,21.12 132.68,20.88 132.68,20.75 132.9,20.53 133.03,20.53 133.27,20.77 133.39,20.77 133.62,20.54 133.62,20.42 133.38,20.18 133.38,20.05 133.61,19.83 133.73,19.83 133.97,20.07 134.1,20.07 134.32,19.84 134.32,19.72 134.08,19.48 134.08,19.35 134.31,19.13 134.43,19.13 134.67,19.37 134.8,19.37 135.02,19.14 135.02,19.01 134.78,18.78 134.78,18.65 135.01,18.43 135.13,18.43 135.37,18.66 135.5,18.66 135.7,18.46 135.7,18.34 135.48,18.13 135.48,17.95 140.08,13.36 140.08,12.02 141.27,10.82 141.27,8.56 v1(141.85,7.98)
  BOTTOM w0.076: v1(129.32,43.71) 129.32,43.85 129.67,44.2 129.67,44.44 130.36,45.13 130.36,45.45 132.12,47.21 132.37,47.21 132.58,47.41 132.58,47.74 133.32,48.49 133.32,48.68 UC1.AV58
  BOTTOM w0.102: v1(141.85,7.98) 140.76,7.98 139.98,8.76 139.98,10.11 139.96,10.14 JDIMM1.163
DDR_A_D37: length 57.4
  IN4 w0.089: v1(141.85,6.46) 140.97,7.34 140.97,10.7 139.72,11.95 139.72,13.28 132.32,20.68 132.32,21.4 128.73,25 128.73,41.29 128.93,41.49 128.93,43.84 129.73,44.63 v1(130.69,44.63)
  BOTTOM w0.076: 134.3,46.6 134.55,46.85 134.55,47.3 134.44,47.41 134.44,47.72 134.52,47.88 134.52,47.98 134.47,48.08 134.44,48.15 134.44,48.37 134.48,48.44 134.51,48.5 134.51,49.41 134.36,49.56 UC1.AU58
  BOTTOM w0.089: v1(130.69,44.63) 132.01,44.63 133.98,46.6 134.3,46.6
  BOTTOM w0.102: v1(141.85,6.46) 141.38,5.99 141.38,5.2 140.26,4.08 JDIMM1.164
DDR_A_D38: length 56.5
  IN4 w0.089: v1(134.1,46.2) 134.1,44.15 131.63,41.68 131.63,40.68 131.72,40.59 131.9,40.59 132,40.49 132,40.19 131.91,40.11 131.69,40.11 131.6,40.02 131.6,39.7 131.69,39.61 131.91,39.61 132,39.52 132,39.2 131.91,39.11 131.69,39.11 131.6,39.03 131.6,38.71 131.69,38.62 131.91,38.62 132,38.53 132,38.21 131.91,38.12 131.69,38.12 131.6,38.04 131.6,37.72 131.69,37.63 131.91,37.63 132,37.54 132,37.19 131.91,37.1 131.69,37.1 131.6,37.01 131.6,36.69 131.69,36.6 131.91,36.6 132,36.52 132,36.04 131.91,35.95 131.69,35.95 131.6,35.86 131.6,35.55 131.69,35.46 131.91,35.46 132,35.37 132,35.05 131.91,34.96 131.69,34.96 131.6,34.87 131.6,34.56 131.69,34.47 131.91,34.47 132,34.38 132,25.58 144.52,13.06 144.52,12.55 144.88,12.19 144.88,9.89 145.04,9.73 145.04,8.38 v1(144.64,7.98)
  BOTTOM w0.076: v1(134.1,46.2) 134.15,46.2 134.72,46.77 134.72,47.37 134.61,47.48 134.61,47.67 134.65,47.78 134.68,47.81 134.68,48.03 134.65,48.09 134.61,48.19 134.61,48.33 134.63,48.37 134.65,48.42 134.66,48.43 134.79,48.56 UC1.AV56
  BOTTOM w0.102: JDIMM1.177 144.16,10.42 144.58,10 144.88,10 145.17,9.71 145.17,7.93 145.02,7.77 144.82,7.77 144.64,7.96 v1(144.64,7.98)
DDR_A_D39: length 57.8
  IN4 w0.086: v1(132.42,44.44) 132.42,43.42 130.67,41.67 130.67,40.92
  IN4 w0.089: 130.67,40.92 130.67,25.61 139.47,16.82 139.47,16.31 142.86,12.91 142.86,11.9 143.23,11.53 143.23,11.25 143.84,10.64 143.84,4.56 143.97,4.43 145.12,4.43 145.25,4.56 145.25,4.81 145.12,4.94 v1(144.64,4.94)
  BOTTOM w0.076: UC1.AU56 135.1,49.25 135.1,48.46 135.27,48.3 135.27,48.12 135.36,48.03 135.36,47.42 135.21,47.28 135.21,46.57 134.8,46.15 134.8,45.92 134.33,45.45 134.33,45.3 133.46,44.44 v1(132.42,44.44)
  BOTTOM w0.102: JDIMM1.176 143.86,4.12 144.64,4.9 v1(144.64,4.94)
DDR_A_D40: length 61.4
  IN1 w0.089: v1(130.25,42.24) 130.23,42.24 129.97,41.98 129.97,40.42 121.43,31.88 120.28,31.88 106.76,18.35 106.3,18.35 103.91,15.97 103.91,15.49 101.99,13.57 101.99,9.95 101.36,9.32 101.36,7.13 v1(100.69,6.46)
  BOTTOM w0.076: UC1.AY54 135.92,47.54 135.92,47.27 135.71,47.07 135.71,46.33 135.29,45.91 135.29,45.71 134.82,45.24 134.82,45.1 131.82,42.09 130.4,42.09 v1(130.25,42.24)
  BOTTOM w0.102: v1(100.69,6.46) 101.26,5.89 JDIMM1.42
DDR_A_D41: length 62.3
  IN1 w0.089: v1(131.07,43.15) 130.58,43.15 129.55,42.12 129.55,40.45 121.28,32.18 120.15,32.18 106.63,18.66 106.17,18.66 103.61,16.09 103.61,15.62 101.69,13.7 101.69,11.96 101.6,11.87 101.27,11.87 101.14,11.99 101.14,12.12 101.02,12.25 100.72,12.25 100.6,12.12 100.6,11.5 100.72,11.37 101.6,11.37 101.69,11.28 101.69,10.96 101.6,10.88 100.72,10.88 100.6,10.75 100.6,10.51 100.72,10.38 101.6,10.38 101.69,10.29 101.69,10.08 101.51,9.9 100.8,9.9 100.69,9.79 v1(100.69,9.51)
  BOTTOM w0.076: UC1.AW54 135.69,47.97 135.69,47.28 135.55,47.14 135.55,46.42 135.13,46 135.13,45.78 134.78,45.42 134.66,45.31 134.66,45.16 132.64,43.15 v1(131.07,43.15)
  BOTTOM w0.102: v1(100.69,9.51) 100.96,9.78 JDIMM1.41
DDR_A_D42: length 61.8
  IN1 w0.089: v1(133.7,42.94) 132.89,42.94 131.76,41.81 131.76,41.24 131.96,41.04 131.96,39.84 122.19,30.07 121.41,30.07 121.04,29.71 120.93,29.71 120.85,29.78 120.76,29.78 104.72,13.74 104.72,13.31 104.62,13.2 104.18,13.2 103.85,12.87 103.85,7.69 103.93,7.6 104.03,7.6 104.11,7.51 104.11,7.19 104.03,7.1 103.93,7.1 103.85,7.01 103.85,6.6 103.99,6.46 v1(104.55,6.46)
  BOTTOM w0.076: UC1.AY52 137.2,47.48 137.2,45.53 134.9,43.23 134.9,43.23 134.6,42.94 v1(133.7,42.94)
  BOTTOM w0.102: v1(104.55,6.46) 103.66,5.57 JDIMM1.50
DDR_A_D43: length 62.6
  IN1 w0.089: v1(104.55,7.98) 104.31,7.98 104.15,8.14 104.15,12.74 104.28,12.87 104.86,12.87 105.03,13.03 105.03,13.62 119.85,28.43 119.97,28.43 120,28.4 120.11,28.4 120.36,28.65 120.36,28.75 120.29,28.81 120.29,28.88 120.7,29.29 120.84,29.29 121.26,28.87 121.42,28.87 121.63,29.08 121.63,29.21 121.36,29.48 121.36,29.59 121.53,29.76 121.83,29.76 122.03,29.56 122.11,29.56 132.27,39.72 132.27,41.08 131.95,41.39 131.95,41.71 132.26,42.02 v1(132.78,42.02)
  BOTTOM w0.076: UC1.AW52 137.33,48.08 137.45,47.96 137.45,47.91 137.58,47.75 137.59,47.72 137.61,47.68 137.61,47.68 137.62,47.66 137.62,47.48 137.37,47.23 137.37,45.46 133.92,42.02 v1(132.78,42.02)
  BOTTOM w0.102: JDIMM1.51 103.96,9.69 103.61,9.34 103.61,8.11 103.73,7.98 v1(104.55,7.98)
DDR_A_D44: length 63.4
  IN1 w0.089: v1(131.53,43.57) 130.76,43.57 129.25,42.06 129.25,40.73 121,32.49 120.03,32.49 106.59,19.05 106.13,19.05 103.07,15.98 103.07,15.86 103.18,15.75 103.18,15.62 102.95,15.4 102.83,15.4 102.72,15.51 102.59,15.51 102.37,15.28 102.37,15.16 102.47,15.05 102.47,14.92 102.25,14.7 102.12,14.7 102.02,14.81 101.89,14.81 101.6,14.52 101.6,14.39 101.69,14.3 101.69,14.13 101.38,13.82 101.38,13.37 101.21,13.2 100.48,13.2 100.29,13.01 100.29,8.38 v1(100.69,7.98)
  BOTTOM w0.076: UC1.AV54 136.08,48.78 135.52,48.21 135.52,47.35 135.38,47.21 135.38,46.5 134.96,46.08 134.96,45.85 134.61,45.49 134.49,45.38 134.49,45.23 132.83,43.57 v1(131.53,43.57)
  BOTTOM w0.102: JDIMM1.39 100.36,10.14 100.02,9.8 100.02,8.27 100.31,7.98 v1(100.69,7.98)
DDR_A_D45: length 64.2
  IN1 w0.089: v1(100.69,4.94) 101.67,5.91 101.67,9.19 102.3,9.82 102.3,13.44 104.24,15.39 104.24,15.87 106.43,18.05 106.88,18.05 120.41,31.57 121.55,31.57 130.27,40.3 130.27,41.66 134.65,46.03 v1(136.39,46.03)
  BOTTOM w0.076: v1(136.39,46.03) 136.87,46.51 136.87,47.71 136.9,47.76 136.94,47.86 136.94,48 136.9,48.1 136.87,48.13 136.87,48.36 136.91,48.45 136.94,48.5 136.97,48.57 136.97,49.33 136.74,49.56 UC1.AU54
  BOTTOM w0.102: JDIMM1.40 100.66,4.9 v1(100.69,4.94)
DDR_A_D46: length 63.2
  IN1 w0.086: 131.66,40.92 131.61,40.97
  IN1 w0.089: 131.66,40.92 131.66,39.97 122.06,30.37 120.92,30.37 103.54,12.99 103.54,6.15 103.63,6.06 103.89,6.06 103.97,5.97 103.97,5.65 103.89,5.56 103.63,5.56 103.54,5.47 103.54,5.09 103.7,4.94 v1(104.55,4.94) ; 131.61,40.97 131.58,40.99 131.58,41.88 133.1,43.4 v1(134.16,43.4)
  BOTTOM w0.076: v1(134.16,43.4) 134.83,43.4 137.04,45.6 137.04,47.67 137.11,47.83 137.11,48.03 137.04,48.19 137.04,48.32 137.06,48.37 137.09,48.43 137.22,48.56 137.29,48.78 UC1.AV52
  BOTTOM w0.102: JDIMM1.52 104.26,4.64 v1(104.55,4.94)
DDR_A_D47: length 64.4
  IN1 w0.089: v1(132.32,41.56) 132.56,41.56 132.72,41.4 132.72,39.73 121.34,28.36 121.22,28.36 120.95,28.63 120.77,28.63 120.6,28.46 120.6,28.28 120.87,28.01 120.87,27.89 120.62,27.64 120.31,27.64 120.05,27.89 119.74,27.89 105.33,13.49 105.33,12.58 105.24,12.49 104.55,12.49 104.46,12.4 104.46,12.08 104.55,11.99 105.24,11.99 105.33,11.91 105.33,11.59 105.24,11.5 104.55,11.5 104.46,11.41 104.46,11.09 104.55,11 105.24,11 105.33,10.91 105.33,10.6 105.24,10.51 104.55,10.51 104.46,10.42 104.46,10.1 104.55,10.01 105.24,10.01 105.33,9.92 105.33,9.3 105.22,9.18 104.88,9.18 v1(104.55,9.51)
  BOTTOM w0.076: v1(132.32,41.56) 133.7,41.56 137.53,45.38 137.53,47.16 137.79,47.41 137.79,47.71 137.76,47.76 137.76,47.76 137.76,47.76 137.74,47.8 137.74,47.81 137.72,47.84 137.64,48.03 137.64,49.24 UC1.AU52
  BOTTOM w0.102: v1(104.55,9.51) 104.56,9.52 JDIMM1.53
DDR_A_D48: length 70.7
  IN1 w0.089: v1(144.46,53.64) 144.32,53.64 144.1,53.42 144.1,50.61 143.31,49.82 142.06,49.82 141.29,49.05 141.29,45.13 137.35,41.19 137.35,40.32 137.26,40.23 136.76,40.23 136.67,40.14 136.67,39.83 136.76,39.74 137.26,39.74 137.35,39.65 137.35,39.43 137.17,39.26 136.77,39.26 136.71,39.19 136.71,38.79 119.84,21.93 118.69,21.93 110.3,13.53 110.3,12.62 110.21,12.53 109.45,12.53 109.32,12.4 109.32,12.16 109.45,12.03 110.21,12.03 110.3,11.94 110.3,11.63 110.21,11.54 109.41,11.54 109.32,11.45 109.32,11.13 109.41,11.04 110.21,11.04 110.3,10.95 110.3,10.64 110.21,10.55 109.41,10.55 109.32,10.46 109.32,10.14 109.41,10.05 110.21,10.05 110.3,9.96 110.3,8.98 110.17,8.85 109.87,8.85 109.74,8.98 109.74,9.38 109.61,9.51 v1(109.42,9.51)
  BOTTOM w0.076: UC1.AK40 144.79,53.97 v1(144.46,53.64)
  BOTTOM w0.102: v1(109.42,9.51) 109.36,9.56 JDIMM1.69
DDR_A_D49: length 70.9
  IN1 w0.089: v1(109.42,7.98) 109.14,7.98 109.02,8.11 109.02,12.68 109.18,12.84 109.75,12.84 109.89,12.98 109.89,13.56 110.05,13.71 110.05,13.84 109.99,13.9 109.99,14.02 110.21,14.25 110.34,14.25 110.4,14.19 110.52,14.19 110.75,14.41 110.75,14.54 110.69,14.6 110.69,14.72 110.91,14.95 111.04,14.95 111.1,14.89 111.22,14.89 111.45,15.12 111.45,15.24 111.39,15.3 111.39,15.42 111.61,15.65 111.74,15.65 111.8,15.59 111.92,15.59 112.15,15.82 112.15,15.94 112.09,16 112.09,16.12 112.32,16.35 112.44,16.35 112.5,16.29 112.62,16.29 112.85,16.52 112.85,16.64 112.79,16.7 112.79,16.82 113.02,17.05 113.14,17.05 113.2,16.99 113.32,16.99 113.55,17.22 113.55,17.34 113.49,17.4 113.49,17.53 113.72,17.75 113.84,17.75 113.9,17.69 114.03,17.69 114.25,17.92 114.25,18.04 114.19,18.1 114.19,18.23 114.42,18.45 114.54,18.45 114.6,18.39 114.73,18.39 114.95,18.62 114.95,18.74 114.89,18.8 114.89,18.93 115.12,19.15 115.24,19.15 115.3,19.09 115.43,19.09 115.69,19.36 115.69,19.48 115.63,19.54 115.63,19.66 115.85,19.89 115.98,19.89 116.04,19.83 116.16,19.83 116.39,20.06 116.39,20.18 116.33,20.24 116.33,20.36 116.56,20.59 116.68,20.59 116.74,20.53 116.86,20.53 118.59,22.25 119.74,22.25 136.36,38.88 136.36,40.43 136.47,40.54 136.88,40.54 137.02,40.68 137.02,41.29 138.95,43.22 139.12,43.22 141.1,45.2 141.1,49.11 141.99,50 143.23,50 143.91,50.68 143.91,53.33 v1(143.55,53.69)
  BOTTOM w0.076: UC1.AK42 143.82,53.97 v1(143.55,53.69)
  BOTTOM w0.102: v1(109.42,7.98) 109.01,7.98 108.76,8.23 108.76,8.88 108.63,9.01 108.45,9.01 108.32,9.13 108.32,9.49 108.45,9.62 108.63,9.62 108.76,9.74 JDIMM1.67
DDR_A_D50: length 68
  IN1 w0.089: v1(106.84,9.51) 106.84,9.27 106.96,9.15 107.35,9.15 107.48,9.27 107.48,9.93 107.35,10.06 106.9,10.06 106.77,10.19 106.77,10.61 106.9,10.74 107.35,10.74 107.48,10.87 107.48,11.11 107.35,11.24 106.87,11.24 106.74,11.36 106.74,11.6 106.87,11.73 107.37,11.73 107.49,11.86 107.49,12.1 107.37,12.23 106.91,12.23 106.74,12.4 106.74,12.9 106.95,13.11 107.33,13.11 107.46,13.24 107.46,13.63 118.17,24.34 118.39,24.34 118.83,23.89 119.01,23.89 119.14,24.02 119.14,24.2 118.86,24.48 118.86,24.66 119.04,24.83 119.21,24.83 119.52,24.52 119.64,24.52 134.13,39.01 134.13,41.52 137.91,45.3 137.91,47.46 138.63,48.19 138.63,49.26 139.35,49.98 139.35,51.17 139.6,51.41 140.23,51.41 140.36,51.55 140.98,51.55 141.44,52.01 141.88,52.01 142.34,52.47 v1(142.6,52.47)
  BOTTOM w0.076: UC1.AM43 142.79,52.67 v1(142.6,52.47)
  BOTTOM w0.102: JDIMM1.59 106.36,9.99 v1(106.84,9.51)
DDR_A_D51: length 67.7
  IN1 w0.089: v1(141.64,52.4) 141.58,52.4 140.9,51.73 140.29,51.73 140.15,51.59 139.52,51.59 139.17,51.24 139.17,50.11 137.55,48.49 137.55,45.43 133.82,41.7 133.82,39.13 121.84,27.16 121.18,26.49 121.05,26.49 121.02,26.52 120.84,26.52 120.67,26.35 120.67,26.17 120.7,26.14 120.7,26.01 120.55,25.86 120.37,25.86 119.89,26.34 119.76,26.34 119.55,26.13 119.55,26.01 120.02,25.54 120.02,25.36 119.85,25.19 119.67,25.19 119.2,25.66 119.07,25.66 118.85,25.44 118.85,25.31 118.9,25.26 118.9,25.13 118.68,24.91 118.55,24.91 118.5,24.96 118.37,24.96 106.44,13.03 106.44,8.13 106.59,7.98 v1(106.84,7.98)
  BOTTOM w0.076: UC1.AM45 141.91,52.67 v1(141.64,52.4)
  BOTTOM w0.102: JDIMM1.57 105.76,9.06 v1(106.84,7.98)
DDR_A_D52: length 68.5
  IN1 w0.089: v1(106.84,6.46) 106.13,7.16 106.13,13.16 119.81,26.84 121.09,26.84 133.52,39.26 133.52,41.87 137.37,45.73 137.37,48.73 138.41,49.76 138.41,51.2 138.97,51.77 140.05,51.77 140.2,51.92 140.83,51.92 141.06,52.15 141.06,53.11 v1(141.66,53.7)
  BOTTOM w0.076: UC1.AK45 141.92,53.97 v1(141.66,53.7)
  BOTTOM w0.102: v1(106.84,6.46) 105.91,5.53 105.91,4.65 105.46,4.21 JDIMM1.56
DDR_A_D53: length 69.9
  IN1 w0.089: v1(142.6,53.77) 142.3,54.06 141.26,54.06 141.21,54.02 140.67,54.02 140.27,53.62 140.27,52.36 139.86,51.95 138.91,51.95 138.23,51.28 138.23,49.87 137.09,48.74 137.09,45.7 133.21,41.82 133.21,39.53 120.82,27.14 119.69,27.14 105.83,13.28 105.83,5.95 v1(106.84,4.94)
  BOTTOM w0.076: v1(142.6,53.77) 142.79,53.97 UC1.AK43
  BOTTOM w0.102: v1(106.84,4.94) 106.06,4.16 JDIMM1.58
DDR_A_D54: length 69.4
  IN1 w0.086: 138.27,41.81 137.65,41.19 137.65,40.92
  IN1 w0.089: v1(109.42,4.94) 109.64,4.71 110.9,4.71 111.02,4.84 111.02,5.06 110.9,5.18 110.1,5.18 109.97,5.31 109.97,5.55 110.1,5.68 110.47,5.68 110.6,5.81 110.6,13.41 118.82,21.62 119.97,21.62 137.65,39.31 137.65,40.92 ; v1(144.46,52.34) 144.85,51.96 144.85,50.22 144.27,49.64 142.14,49.64 141.49,48.99 141.49,45.02 138.27,41.81
  BOTTOM w0.076: v1(144.46,52.34) 144.79,52.67 UC1.AM40
  BOTTOM w0.102: v1(109.42,4.94) 109.06,4.58 JDIMM1.68
DDR_A_D55: length 69.4
  IN1 w0.089: v1(109.42,6.46) 108.84,6.46 108.71,6.59 108.71,13.18 108.83,13.3 109.3,13.3 109.49,13.49 109.49,13.95 116.64,21.1 116.76,21.1 116.82,21.05 116.95,21.05 117.17,21.27 117.17,21.4 117.12,21.45 117.12,21.58 117.34,21.81 117.47,21.81 117.52,21.75 117.65,21.75 117.87,21.97 117.87,22.1 117.82,22.16 117.82,22.28 118.13,22.6 118.21,22.6 118.3,22.51 118.4,22.51 118.53,22.63 119.69,22.63 135.34,38.29 135.34,38.52 135.41,38.58 135.64,38.58 135.76,38.71 135.76,38.99 135.64,39.12 135.61,39.12 135.48,39.25 135.48,39.55 135.61,39.68 135.93,39.68 136.06,39.8 136.06,40.08 135.93,40.21 135.6,40.21 135.47,40.34 135.47,40.58 135.6,40.71 136,40.71 139.01,43.71 139.3,43.71 140.25,44.66 140.25,49.33 140.63,49.71 141.4,49.71 142.16,50.47 142.16,51.12 142.59,51.55 142.76,51.55 143.55,52.34 v1(143.55,52.39)
  BOTTOM w0.076: v1(143.55,52.39) 143.82,52.67 UC1.AM42
  BOTTOM w0.102: v1(109.42,6.46) 110.05,5.83 110.05,4.93 109.66,4.54 JDIMM1.70
DDR_A_D56: length 67.1
  IN4 w0.089: v1(140.69,52.94) 140.29,52.54 140.29,52.13 139.37,51.21 139.37,50.57 138.33,49.53 138.33,46.86 138.7,46.48 138.7,45.45 138.16,44.91 138.16,43.67 135.45,40.95 135.45,28.27 137.77,25.95 137.77,25.6 144.96,18.41 144.96,18.29 144.73,18.06 144.73,17.94 144.96,17.71 145.08,17.71 145.31,17.94 145.43,17.94 145.71,17.66 145.71,17.54 145.49,17.31 145.49,17.19 145.71,16.96 145.84,16.96 146.06,17.18 146.19,17.18 146.45,16.92 146.45,16.8 146.23,16.57 146.23,16.45 146.45,16.22 146.58,16.22 146.8,16.45 146.93,16.45 147.14,16.23 147.14,16.11 146.91,15.88 146.91,15.76 147.14,15.53 147.26,15.53 147.49,15.76 147.61,15.76 147.84,15.53 147.84,15.41 147.61,15.18 147.61,15.06 147.84,14.83 147.96,14.83 148.19,15.06 148.31,15.06 148.54,14.83 148.54,14.71 148.31,14.48 148.31,14.36 148.54,14.13 148.66,14.13 148.89,14.36 149.01,14.36 149.2,14.18 149.2,13.93 149.28,13.84 149.53,13.84 149.66,13.72 149.66,13.47 149.53,13.35 149.28,13.35 149.2,13.26 149.2,12.94 149.28,12.85 149.56,12.85 149.69,12.72 149.69,12.48 149.56,12.36 149.28,12.36 149.2,12.27 149.2,12.05 149.4,11.84 149.95,11.84 150.15,11.64 150.15,6.72 149.97,6.54 v1(149.75,6.54)
  BOTTOM w0.076: v1(140.69,52.94) 140.97,52.67 UC1.AM46
  BOTTOM w0.102: JDIMM1.192 148.66,4.87 149.32,5.53 149.32,5.96 148.97,6.32 148.97,6.5 149.29,6.82 149.47,6.82 v1(149.75,6.54)
DDR_A_D57: length 66.9
  IN4 w0.089: v1(140.69,53.53) 141.05,53.16 141.05,52.13 140.17,51.24 140.17,50.31 139.72,49.86 138.98,49.86 138.51,49.38 138.51,46.93 138.88,46.56 138.88,45.34 138.34,44.8 138.34,43.59 135.93,41.18 135.93,28.25 138.08,26.1 138.08,25.72 150.28,13.52 150.28,13.21 150.52,12.97 150.52,6.9 150.61,6.81 151.59,6.81 151.71,6.68 151.71,6.44 151.59,6.31 150.37,6.31 150.24,6.19 150.24,5.94 150.37,5.82 151.57,5.82 151.7,5.69 151.7,5.45 151.57,5.32 151.14,5.32 151.02,5.2 151.02,4.74 150.89,4.61 150.62,4.61 150.5,4.74 150.5,5.2 150.37,5.32 150.06,5.32 v1(149.75,5.01)
  BOTTOM w0.076: UC1.AK46 141.13,53.97 v1(140.69,53.53)
  BOTTOM w0.102: JDIMM1.194 149.26,4.52 v1(149.75,5.01)
DDR_A_D58: length 64.5
  IN4 w0.089: v1(146.98,9.58) 146.98,9.36 146.85,9.24 146.58,9.24 146.45,9.36 146.45,10.09 146.58,10.21 147.22,10.21 147.35,10.34 147.35,10.61 147.22,10.73 146.42,10.73 146.29,10.86 146.29,11.29 146.42,11.42 146.93,11.42 147.06,11.54 147.06,11.78 146.93,11.91 146.42,11.91 146.29,12.04 146.29,12.28 146.42,12.41 146.91,12.41 147,12.49 147,12.81 146.91,12.9 146.44,12.9 146.29,13.05 146.29,13.63 146.08,13.85 135.19,24.73 135.19,24.86 135.55,25.22 135.55,25.4 135.38,25.57 135.2,25.57 134.84,25.21 134.72,25.21 134.49,25.43 134.49,25.56 134.91,25.98 134.91,26.15 134.74,26.33 134.56,26.33 134.14,25.91 134.02,25.91 133.82,26.1 133.82,26.26 134.24,26.67 134.24,26.82 133.53,27.53 133.53,40.92 137.19,44.57 137.19,47.14 136.75,47.58 136.75,51.03 137.58,51.86 137.89,51.86 138.44,52.41 v1(138.74,52.41)
  BOTTOM w0.076: v1(138.74,52.41) 139,52.67 UC1.AM49
  BOTTOM w0.102: JDIMM1.183 145.96,10.39 146.14,10.21 146.14,8.93 146.25,8.82 146.44,8.82 146.57,8.94 146.57,9.98 146.69,10.1 146.86,10.1 146.98,9.98 v1(146.98,9.58)
DDR_A_D59: length 64.1
  IN4 w0.089: v1(138.79,53.73) 138.14,54.38 135.91,54.38 135.46,53.94 135.34,53.82 135.34,53.47 135.41,53.41 135.41,49.44 135.93,48.92 135.93,45.68 131.94,41.69 131.94,41.31 132.5,40.75 132.5,25.78 145.38,12.9 145.38,10.15 145.54,9.99 145.54,6.46 v1(146.98,5.01)
  BOTTOM w0.076: v1(138.79,53.73) 139.02,53.97 UC1.AK49
  BOTTOM w0.102: JDIMM1.182 145.66,4.17 146.5,5.01 v1(146.98,5.01)
DDR_A_D60: length 66.1
  IN4 w0.089: v1(149.75,8.06) 149.75,7.94 149.33,7.52 149.33,4.25 149.2,4.13 148.87,4.13 148.78,4.22 148.78,7.72 149.33,8.27 149.33,11.05 148.59,11.79 148.59,13.22 136.8,25.01 136.8,26.02 134.73,28.09 134.73,40.86 137.76,43.88 137.76,49.49 138.22,49.95 138.22,51.02 138.69,51.49 139.03,51.49 139.74,52.2 v1(139.74,52.34)
  BOTTOM w0.076: v1(139.74,52.34) 140.06,52.67 UC1.AM48
  BOTTOM w0.102: JDIMM1.191 148.36,8.76 149.06,8.06 v1(149.75,8.06)
DDR_A_D61: length 65.8
  IN4 w0.089: v1(139.74,53.64) 140.1,53.28 140.1,52.19 139.71,51.8 139.66,51.8 139.19,51.33 139.19,50.67 137.93,49.41 137.93,43.71 135.09,40.86 135.09,28.17 137.35,25.91 137.35,25.47 137.12,25.24 137.12,25.12 137.35,24.89 137.47,24.89 137.7,25.12 137.82,25.12 138.05,24.89 138.05,24.77 137.82,24.54 137.82,24.42 138.05,24.19 138.17,24.19 138.4,24.42 138.52,24.42 138.74,24.2 138.74,24.08 138.51,23.86 138.51,23.73 138.74,23.5 138.86,23.5 139.09,23.73 139.21,23.73 139.44,23.5 139.44,23.38 139.21,23.15 139.21,23.03 139.44,22.8 139.56,22.8 139.79,23.03 139.91,23.03 140.15,22.79 140.15,22.67 139.95,22.47 139.95,22.29 140.12,22.12 140.3,22.12 140.5,22.31 140.62,22.31 140.85,22.09 140.85,21.96 140.65,21.77 140.65,21.59 140.82,21.42 141,21.42 141.2,21.61 141.33,21.61 141.6,21.34 141.6,21.22 141.37,20.99 141.37,20.87 141.6,20.64 141.72,20.64 141.95,20.87 142.07,20.87 142.37,20.57 142.37,20.44 142.15,20.22 142.15,20.09 142.37,19.87 142.5,19.87 142.72,20.09 142.85,20.09 143.08,19.86 143.08,19.69 142.87,19.48 142.87,19.37 143.06,19.18 143.19,19.18 143.4,19.39 143.53,19.39 143.75,19.17 143.75,19.04 143.54,18.83 143.54,18.7 143.76,18.48 143.89,18.48 144.1,18.69 144.23,18.69 144.45,18.47 144.45,18.34 144.24,18.13 144.24,18 148.89,13.35 148.89,11.92 149.63,11.17 149.63,9.7 v1(149.75,9.58)
  BOTTOM w0.076: UC1.AK48 140.06,53.97 v1(139.74,53.64)
  BOTTOM w0.102: JDIMM1.193 148.96,10.28 148.73,10.05 148.73,9.91 148.86,9.78 149.06,9.78 149.19,9.65 149.19,9.5 149.06,9.38 148.86,9.38 148.73,9.25 148.73,8.87 148.95,8.65 149.2,8.65 149.33,8.78 149.33,9.13 149.45,9.26 149.62,9.26 149.75,9.39 v1(149.75,9.58)
DDR_A_D62: length 63.3
  IN4 w0.089: v1(137.83,52.34) 137.55,52.34 137.43,52.47 137.43,53.23 137.3,53.35 136.73,53.35 136.52,53.14 136.52,47.51 137.01,47.03 137.01,45.02 133.23,41.25 133.23,27.38 133.71,26.9 133.71,26.69 133.41,26.39 133.41,26.09 143.06,16.43 143.06,16.3 143.01,16.26 143.01,16.13 143.24,15.91 143.37,15.91 143.41,15.95 143.54,15.95 143.76,15.73 143.76,15.6 143.72,15.56 143.72,15.43 143.94,15.21 144.07,15.21 144.11,15.25 144.24,15.25 144.46,15.03 144.46,14.9 144.42,14.86 144.42,14.73 144.64,14.51 144.77,14.51 144.81,14.55 144.94,14.55 145.16,14.33 145.16,14.2 145.12,14.15 145.12,14.03 145.34,13.8 145.47,13.8 145.51,13.85 145.64,13.85 145.99,13.5 145.99,10.44 146.15,10.28 146.15,8.93 146.28,8.8 146.43,8.8 146.56,8.68 146.56,8.35 146.43,8.22 146.28,8.22 146.15,8.09 146.15,7.84 146.28,7.71 146.9,7.71 146.98,7.79 v1(146.98,8.06)
  BOTTOM w0.076: UC1.AM51 138.16,52.67 v1(137.83,52.34)
  BOTTOM w0.102: JDIMM1.181 145.36,10.38 145.81,9.93 145.81,7.88 145.94,7.75 146.77,7.75 146.98,7.96 v1(146.98,8.06)
DDR_A_D63: length 62.7
  IN4 w0.089: v1(146.98,6.54) 145.84,7.68 145.84,10.12 145.68,10.28 145.68,13.03 132.92,25.79 132.92,41.44 136.83,45.34 136.83,46.95 136.22,47.56 136.22,49.41 135.6,50.04 135.6,53.47 135.52,53.54 135.52,53.74 135.71,53.93 135.98,54.2 137.27,54.2 v1(137.83,53.64)
  BOTTOM w0.076: UC1.AK51 138.16,53.97 v1(137.83,53.64)
  BOTTOM w0.102: v1(146.98,6.54) 146.17,5.73 146.17,5.42 145.06,4.31 JDIMM1.180
DDR_A_DQS0: length 65.4
  IN4 w0.102: v1(133.1,8.44) 133.1,8.26 132.89,8.05 132.62,8.05 132.47,8.19 132.47,9.8 128.98,13.29 128.98,14.29 123.04,20.23 123.04,20.51 123.24,20.71 123.24,21 122.72,21.52 122.41,21.52 122.15,21.25 122.02,21.25 121.85,21.43 121.85,21.72 122.4,22.28 122.4,22.82 121.89,23.34 121.83,23.39 121.83,42.79 125.43,46.39 125.43,51.51 126.47,52.56 126.47,53.23 126.77,53.53 v1(126.77,53.53)
  BOTTOM w0.076: v1(126.77,53.53) 126.87,53.43 126.87,53.32 126.64,53.09 126.57,53.09 126.28,53.38 126.28,53.62 126.61,53.95 128.38,53.95 128.91,54.49 129.89,54.49 129.9,54.49 130.11,54.49 130.11,54.5 130.45,54.5 130.6,54.57 130.61,54.57 130.75,54.57 130.76,54.56 130.84,54.52 130.87,54.5 131.29,54.5 131.33,54.46 UC1.AJ62
  BOTTOM w0.102: v1(133.1,8.44) 133.1,8.26 132.83,7.99 132.72,7.99 132.57,8.13 132.57,9.75 132.28,10.04 132.16,10.16 JDIMM1.137
DDR_A_DQS1: length 71
  IN1 w0.102: v1(91.09,6.84) 91.61,6.84 91.77,7 91.77,13.03 95.18,16.44 95.18,18.32 104.55,27.69 105.9,27.69 118.2,39.99 119.66,39.99 125.39,45.73 125.39,47.17 128.39,50.17 128.39,50.67 v1(128.13,50.94)
  BOTTOM w0.076: UC1.AN61 131.76,52.07 131.57,52.07 131.4,52.24 130.94,52.24 130.92,52.25 130.85,52.29 130.8,52.32 130.57,52.32 130.55,52.31 130.48,52.27 130.47,52.27 130.41,52.24 130.11,52.24 130.11,52.24 128.86,52.24 128.85,52.23 128.84,52.23 128.26,51.64 128.26,51.06 v1(128.13,50.94)
  BOTTOM w0.102: JDIMM1.12 92.26,4.41 92.13,4.54 92.13,6.28 91.78,6.63 91.3,6.63 v1(91.09,6.84)
DDR_A_DQS2: length 61.4
  IN4 w0.102: v1(138.19,6.92) 138.19,6.72 138.06,6.59 137.7,6.59 137.62,6.68 137.62,8.04 137.75,8.17 137.95,8.17 138.19,8.41 138.19,9.37 137.95,9.62 137.82,9.62 137.74,9.69 137.74,9.97 137.83,10.06 137.83,10.54 137.39,10.98 137.39,11.69 137.19,11.89 136.48,11.89 136.08,12.29 136.08,13.6 135.75,13.93 135.22,13.93 126.76,22.39 126.76,22.69 126.41,23.05 126.41,41.48 126.47,41.54 126.47,43.3 127.67,44.5 127.67,45.52 131.28,49.14 131.28,49.22 131.84,49.77 131.84,51.29 132.61,52.07 132.88,52.07 133.13,51.82 v1(133.13,51.69)
  BOTTOM w0.076: UC1.AN58 133.27,52.02 133.13,51.87 v1(133.13,51.69)
  BOTTOM w0.102: v1(138.19,6.92) 138.23,6.92 138.81,6.34 138.81,5.11 138.49,4.79 137.93,4.79 137.26,4.12 JDIMM1.154
