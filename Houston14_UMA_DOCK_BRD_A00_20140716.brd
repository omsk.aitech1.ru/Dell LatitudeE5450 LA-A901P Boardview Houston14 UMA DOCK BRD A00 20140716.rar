# Allegro board Houston14_UMA_DOCK_BRD_A00_20140716.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
BLUE_DOCK: length 33.4
  TOP w0.102: v1(179.11,97.04) 179.11,96.99 178.92,96.8 178.92,96.69 178.49,96.26 UV16.21
  IN4 w0.089: v1(161.95,107.15) 162.89,106.21 166.14,106.21 168.06,104.29 169.01,104.29 170.48,102.82 170.48,101.13 171.42,100.19 174.53,100.19 175.98,98.74 175.98,96.27 176.33,95.93 178,95.93 v1(179.11,97.04)
  BOTTOM w0.102: JDOCK1.45 156.9,109.01 157.65,108.26 160.85,108.26 v1(161.95,107.15)
BOARD_ID: length 10.6
  TOP w0.102: RE79.2 CE40.1 269.25,60.34 268.73,60.34 v1(268.57,60.51) ; v1(261.79,59.99) 261.8,60 UE2.B10
  IN1 w0.089: v1(268.57,60.51) 267.41,60.51 266.43,59.53 263.97,59.53 263.5,59.99 v1(261.79,59.99)
  BOTTOM w0.102: v1(261.79,59.99) 261.79,60.17 v2(261.44,60.52)
BOOT_1.35V:
  vias: v1(255.73,37.21)
BOOT_1.35V_C: length 1.5
  BOTTOM w0.127: v2(254.27,33.66) 253.97,33.95 PC204.1
BQ24770_REGN: length 32.6
  TOP w0.203: PC710.1 82.63,76.08 81.69,77.01 PU700.24
  TOP w0.254: PR713.1 76.34,83.25 76.09,83 v3(76.09,82.43) ; PC710.1 82.63,75.67 PR799.2 84.67,73.62 v2(84.67,70.37) 83.6,69.31 v3(83.6,69.22) ; PR725.1 78.88,71.11 v3(80.26,69.73)
  IN1 w0.254: v3(76.09,82.43) 76.28,82.43 76.59,82.11 76.59,79.16 77.1,78.65 77.1,75.59 78.47,74.21 78.47,72.7 79.72,71.45 79.72,70.27 v3(80.26,69.73)
  IN3 w0.254: v3(80.26,69.73) 80.4,69.59 83.24,69.59 v3(83.6,69.22)
BREATH_LED#: length 214.7
  TOP w0.102: UE2.B57 256.35,55.65 v1(255.85,56.15)
  IN2 w0.122: v1(172.39,115.65) 173.38,115.65 176.71,112.32 180.78,112.32 184.84,108.27 199.11,108.27 204.8,102.58 224.56,102.58 225.21,103.23 235.51,103.23 235.72,103.01 240.36,103.01 240.73,103.39 248.72,103.39 251.84,100.27 256.99,100.27 v1(257.6,100.88) 258.14,101.42 261.88,101.42 263.41,99.88 274.14,99.88 274.78,100.52 284.1,100.52 287.74,96.88 287.74,94.35 v1(287.08,93.69)
  IN3 w0.122: v1(292.96,86.81) 293.18,87.02 299.38,87.02 300.6,85.8 308.51,85.8 309.14,86.44 309.91,86.44 v1(310.31,86.03)
  BOTTOM w0.102: JDOCK1.98 171.9,116.19 172.39,115.7 v1(172.39,115.65) ; v1(310.31,86.03) QZ7.4 310.31,84.68 310.38,84.62 RZ34.1 ; v1(257.6,100.88) 258.1,100.38 258.1,97.42 258.06,97.38 258.06,88.74 258.25,88.55 258.25,86.36 258.39,86.22 258.39,85.74 259.18,84.95 259.18,82.63 257.4,80.85 257.4,80.48 257.85,80.03 258.35,80.03 258.98,79.4 258.98,74.98 259.18,74.78 259.18,72.7 259.64,72.24 259.64,70.93 260.4,70.16 260.4,67.73 260.59,67.54 260.59,66.35 260.4,66.16 260.4,65.83 258.28,63.71 258.28,61.85 v2(258.04,61.62) 257.02,60.6 257.02,59.25 255.85,58.08 v1(255.85,56.15) ; v1(292.96,86.81) 292.81,86.96 289.67,86.96 288.53,88.1 288.53,92.8 287.64,93.69 v1(287.08,93.69)
BREATH_LED#_Q: length 2.7
  BOTTOM w0.102: v2(311.33,89.17) 310.49,88.33 RZ32.1 310.49,87.47 310.31,87.29 QZ7.3
BREATH_WHITE_LED#: length 60.8
  TOP w0.102: v1(308.29,84.14) 308.29,84.24 307.85,84.68 307.47,84.68 v2(307.12,85.03) ; v1(303.59,47.23) 304.05,46.77 304.05,44.35 299.12,39.42 295.48,39.42 294.08,40.82 JLED1.2
  IN2 w0.122: v1(308.29,84.14) 309.45,82.98 309.45,72.8 304.06,67.42 304.06,64.72 301.94,62.6 301.94,61.28 303.81,59.41 303.81,52.65 303.56,52.4 303.56,47.26 v1(303.59,47.23)
  BOTTOM w0.102: v1(308.29,84.14) 308.39,84.04 RZ34.2
BREATH_WHITE_LED_SNIFF#: length 16.1
  TOP w0.102: v1(316.65,97.48) 318.27,99.1 LED3.1
  BOTTOM w0.102: RZ32.2 309.58,87.89 311.11,89.42 311.11,93.61 312.12,94.62 v2(313.63,94.62) 313.79,94.62 v1(316.65,97.48)
BST_3V: length 1.7
  TOP w0.102: v2(215.94,66.87) 216.26,67.19 PR110.2
BST_3V_C: length 1.4
  TOP w0.102: PR110.1 216.13,68.58 v2(216.07,68.65)
BST_5V: length 1.6
  TOP w0.102: v2(216.42,59.63) 216.8,60.01 217.74,60.01 PR109.1
BST_5V_C: length 1.4
  TOP w0.102: PC110.1 219.06,57.91 v2(219.49,57.47)
BST_+V1.05SP: length 0.7
  TOP w0.102: v2(219.37,46.04) 218.87,46.04 v1(218.73,46.18)
  vias: v1(218.15,46.21)
BST_+V1.05SP_C: length 2.3
  TOP w0.102: v2(215.73,49.16) PR312.1
  TOP w0.635: PC302.2 216.88,47.98 PR312.1
BT_LED#: length 4.8
  TOP w0.102: RZ15.1 273.69,51.17 QZ2.4 273.71,49.75 v1(273.56,49.6) 273.47,49.51 v2(273.47,48.83)
  BOTTOM w0.102: JNGFF1.8 273.6,49.55 v1(273.56,49.6)
BT_RADIO_DIS#: length 81
  TOP w0.102: RE11.2 253.02,86.49 v1(253.34,86.17) 252.64,85.47 252.34,85.47 252.17,85.3 UE1.A13 ; v1(279.06,53.65) 279.48,54.07 280.43,54.07 281.39,53.1 DZ2.1 ; v1(282.18,92.89) v2(282.18,93.46)
  IN2 w0.122: v1(279.06,53.65) 279.06,54.05 278.24,54.87 278.24,56.39 279.6,57.75 279.6,59.45 280.18,60.03 280.18,63.19 281.45,64.46 281.45,71.03 282.61,72.19 282.61,75.84 281.9,76.55 281.9,87.89 282.22,88.21 282.22,90.55 282.6,90.93 282.6,92.47 v1(282.18,92.89)
  IN3 w0.122: v1(253.34,86.17) 254.09,86.92 260.06,86.92 265.18,92.04 268.58,92.04 269,92.46 279.25,92.46 280.02,93.23 281.84,93.23 v1(282.18,92.89)
BT_RADIO_DIS#_R: length 4.8
  TOP w0.102: v2(283.54,51.41) 283.31,51.41 283.2,51.53 v1(283.01,51.53) 282.83,51.7 DZ2.2
  BOTTOM w0.102: JNGFF1.46 283.1,51.43 v1(283.01,51.53)
CAM_MIC_CBL_DET#: length 136.1
  TOP w0.102: v2(185.2,68.77) 185.74,68.24 v1(185.74,68.16)
  IN2 w0.122: v1(94.26,99.44) 94.26,98.43 95.67,97.02 97.45,97.02 98.97,95.49 99.11,95.49 100.16,94.44 v1(100.61,94.44)
  IN3 w0.086: v1(167.31,67.14) 167.68,67.5 167.68,68.33 167.49,68.51 167.49,72.02 168.41,72.94 168.41,73.39
  IN3 w0.122: 168.41,73.39 168.41,77.33 169.09,78 169.18,78 169.19,78.01 170.69,78.01 171.74,79.06 171.74,79.73 171.13,80.35 169.73,80.35 166.37,83.71 163.56,83.71 163.23,84.03 160.44,84.03 159.95,84.52 153.95,84.52 153.14,85.33 153.14,85.98 151.72,87.39 151.72,89.5 150.72,90.5 147.03,90.5 146.19,89.66 144.29,89.66 142.85,91.11 139.63,91.11 136.16,94.59 136.16,98.22 135.9,98.48 134.04,98.48 133.36,99.16 132.53,99.16 131.76,99.93 130.03,99.93 128.26,98.15 116.9,98.15 116.23,97.48 107.89,97.48 105.04,94.63 100.8,94.63 v1(100.61,94.44)
  IN4 w0.086: 170.65,66.4 170.38,66.66 169.3,66.66 169.14,66.5 167.95,66.5 v1(167.31,67.14)
  IN4 w0.089: v1(185.74,68.16) 185.74,68.26 185.41,68.58 182.71,68.58 181.25,67.12 181.17,67.12 180.94,66.88 172.73,66.88 172.25,66.4 170.65,66.4
  BOTTOM w0.076: UC1.F4 167.03,66.86 v1(167.31,67.14)
  BOTTOM w0.102: v1(185.74,68.16) 185.81,68.16 187.38,66.6 RPC15.4 ; v1(94.26,99.44) 94.89,100.08 JEDP1.14
CD3301_DCIN: length 2.1
  BOTTOM w0.127: PR835.2 96.63,62.08 v2(95.97,62.74)
CD3301_SDC_IN: length 1.8
  BOTTOM w0.254: PU800.6 102.9,60.78 102.68,61 PR847.2
CD_PBATT_OFF: length 4.3
  BOTTOM w0.254: PU800.27 100.4,53.82 99.1,52.52 PR843.1 98.76,52.34 v2(97.75,51.34)
CFG0: length 62.1
  TOP w0.102: v1(96.82,33.03) 96.82,33.87 96.16,34.53 JXDP1.9 ; v2(117.64,57.29) 117.64,57.65 117.59,57.7 RC183.1 118.11,58.49 v1(118.21,58.38)
  IN1 w0.086: v1(129.2,57.32) 129.08,57.32 128.64,57.75 126.4,57.75
  IN1 w0.089: v1(96.82,33.03) 98.35,34.55 102.44,34.55 103.45,35.56 103.45,36.32 103.72,36.59 104.68,36.59 106.53,38.44 107.3,38.44 112.84,43.98 112.84,48.87 116.56,52.6 116.56,54.76 117.35,55.55 117.35,57.2 118.21,58.07 v1(118.21,58.38) 118.69,57.9 119.58,57.9 119.67,57.99 119.67,58.28 119.76,58.37 119.94,58.37 120.03,58.28 120.03,57.99 120.11,57.9 120.29,57.9 120.38,57.99 120.38,58.28 120.47,58.37 120.65,58.37 120.74,58.28 120.74,57.99 120.83,57.9 122.02,57.9 122.11,57.99 122.11,58.4 122.2,58.49 122.37,58.49 122.46,58.4 122.46,57.99 122.55,57.9 122.73,57.9 122.82,57.99 122.82,58.4 122.91,58.49 123.09,58.49 123.18,58.4 123.18,57.99 123.26,57.9 126.25,57.9 126.4,57.75
  BOTTOM w0.076: v1(129.2,57.32) 129.47,57.59 129.93,57.59 130.16,57.35 130.55,57.35 130.71,57.52 131.5,57.52 131.53,57.48 132.01,57.48 UC1.AC60
CFG1: length 61.4
  TOP w0.102: v2(125.26,56.71) 125.26,57.24 v1(125.35,57.33) ; v1(97.66,33.05) 97.08,32.48 96.67,32.48 96.18,32.97 96.18,33.77 95.92,34.03 JXDP1.11
  IN1 w0.089: v1(125.35,57.33) 125.03,57.65 124.41,57.65 124.32,57.56 124.32,57.22 124.23,57.13 124.06,57.13 123.97,57.22 123.97,57.56 123.88,57.65 123.7,57.65 123.61,57.56 123.61,57.22 123.52,57.13 123.34,57.13 123.26,57.22 123.26,57.56 123.17,57.65 122.99,57.65 122.9,57.56 122.9,57.22 122.81,57.13 122.63,57.13 122.54,57.22 122.54,57.56 122.46,57.65 121.87,57.65 121.74,57.52 121.74,57.1 121.62,56.97 120.89,56.97 120.8,57.06 120.8,57.43 120.69,57.53 120.55,57.53 120.44,57.43 120.44,57.06 120.35,56.97 120.18,56.97 120.09,57.06 120.09,57.49 119.98,57.6 119.84,57.6 119.73,57.49 119.73,57.06 119.64,56.97 118.75,56.97 v1(118.25,57.47) 117.6,56.82 117.6,55.49 116.79,54.68 116.79,52.52 113.11,48.84 113.11,43.93 107.4,38.22 106.62,38.22 105.1,36.7 105.1,35.75 104.78,35.42 103.62,35.42 102.5,34.31 98.91,34.31 v1(97.66,33.05)
  BOTTOM w0.076: UC1.AC62 130.77,57.81 130.48,57.52 130.23,57.52 130,57.75 128.15,57.75
  BOTTOM w0.102: RC184.1 v1(118.25,57.47) ; 128.15,57.75 128,57.9 125.87,57.9 125.35,57.38 v1(125.35,57.33)
CFG2: length 56.8
  TOP w0.102: v2(123.99,59.76) 124.66,59.76 v1(124.8,59.9) ; JXDP1.15 v1(95.19,33.03)
  IN1 w0.089: v1(95.19,33.03) 95.31,33.15 95.31,33.54 97.42,35.65 99.31,35.65 100.44,36.78 102.22,36.78 111.58,46.14 111.58,46.14 111.72,46.28 111.72,49.42 114.26,51.96 114.26,54.79 115.32,55.84 115.32,57.41 115.86,57.95 116.46,57.95 116.81,58.29 116.81,59.08 117.09,59.36 117.09,60.25 117.91,61.06 122.12,61.06 122.73,60.45 123.37,60.45 123.81,60.01 124.69,60.01 v1(124.8,59.9)
  BOTTOM w0.076: 128.02,58.13 128.23,57.92 130.25,57.92 UC1.AC63
  BOTTOM w0.102: 128.02,58.13 126.34,58.13 125.98,58.48 125.34,58.48 124.65,59.17 124.65,59.74 v1(124.8,59.9)
CFG3: length 85.9
  TOP w0.102: JXDP1.17 95.27,32.53 v1(95.77,33.02) ; RC113.2 RC305.1 103.02,21.22 92.53,21.22 92.23,20.92 v1(90.92,20.92) v2(90.92,20.21)
  IN1 w0.089: v1(90.92,20.92) 90.92,21.94 90.55,22.3 90.55,23.78 91.53,24.75 93.52,24.75 94.55,25.78 94.55,31.8 v1(95.77,33.02) 95.73,33.07 95.73,33.41 97.73,35.41 102.38,35.41 102.78,35.81 102.78,36.73 112.01,45.96 112.15,46.1 112.15,46.14 112.19,46.18 112.19,49.28 114.69,51.78 114.69,54.54 115.95,55.79 116.21,55.79 116.65,56.24 116.65,57.52 117.24,58.11 117.24,58.86 117.63,59.25 117.63,59.67 117.86,59.9 122.77,59.9 124,58.67 126.56,58.67 127.14,59.25 v1(127.14,59.29)
  BOTTOM w0.076: v1(127.14,59.29) 127.14,59.15 127.49,58.8 128.18,58.8 128.57,58.41 130.04,58.41 130.18,58.56 UC1.AA63
CFG3_R: length 3.3
  TOP w0.102: RC113.1 102.06,22.16 101.92,22.03 v2(101.38,22.03) JXDP1.60
CFG4: length 70.6
  TOP w0.102: v1(96.94,29.06) 95.97,30.03 JXDP1.27 ; RC191.1 121.01,56.08 v2(122.59,56.08) v1(125.56,56.08)
  IN1 w0.086: v1(132.01,58.18) 132.01,57.64 131.95,57.58 130.35,57.58 130.2,57.43 130.2,56.91 129.79,56.49 129.53,56.49 129.44,56.58 129.44,56.86 129.36,56.94 129.1,56.94 129.03,56.87 129.03,56.38 128.95,56.29 128.77,56.29 128.64,56.42 128.64,56.77 128.55,56.86 128.31,56.86 128,56.55 128,56.32 128.37,55.95 128.37,55.73 128.23,55.59 127.76,55.59 127.66,55.69 127.66,56.15 127.57,56.24 127.4,56.24 127.31,56.15 127.31,55.69 127.22,55.6 127.05,55.6 126.96,55.69 126.96,56.15 126.88,56.24 126.4,56.24
  IN1 w0.089: v1(96.94,29.06) 97.5,29.62 97.5,29.76 101.12,33.38 103.12,33.38 104.02,34.28 105.4,34.28 108.77,37.65 109.13,37.65 115.52,44.04 118.77,44.04 120.92,46.19 120.92,50.09 117.81,53.2 117.81,53.57 118.08,53.84 120.56,53.84 122.8,56.08 v1(125.56,56.08) 125.56,55.97 125.69,55.84 126,55.84 126.12,55.97 126.12,56.16 126.2,56.24 126.4,56.24
  BOTTOM w0.076: UC1.AA60 132.31,58.48 v1(132.01,58.18)
CFG5: length 60.1
  TOP w0.102: v2(91.61,29.28) 91.86,29.53 JXDP1.29 v1(95.22,29.53)
  IN1 w0.089: v1(95.22,29.53) 95.25,29.55 95.25,31.61 96.41,32.77 96.41,33.23 97.95,34.77 102.35,34.77 103.21,35.63 103.21,36.41 103.61,36.8 104.59,36.8 106.44,38.65 107.21,38.65 112.62,44.07 112.62,49.09 115.16,51.62 115.16,54.14 116.36,55.35 116.43,55.35 117.12,56.03 117.12,57.38 117.67,57.93 117.67,58.41 118.05,58.78 123.27,58.78 123.82,58.24 127.96,58.24 v1(128.96,59.24)
  BOTTOM w0.076: v1(128.96,59.24) 129.46,58.74 129.89,58.74 130.16,59.02 130.48,59.02 130.77,59.31 UC1.Y62
CFG6: length 58.3
  TOP w0.102: v1(96.22,28.36) 95.59,28.98 95.15,28.98 94.69,28.53 JXDP1.33
  IN4 w0.086: v1(131.36,59.68) 130.72,59.05 130.72,56.73 129.99,56 128.61,56 127.52,54.92 124.97,54.92
  IN4 w0.089: v1(96.22,28.36) 97.23,28.36 97.97,27.63 99.96,27.63 101.05,28.72 106.5,28.72 115.61,37.82 115.61,39.96 122.4,46.75 122.4,48.23 122.7,48.53 122.7,52.96 124.66,54.92 124.97,54.92
  BOTTOM w0.076: v1(131.36,59.68) 131.66,59.38 UC1.Y61
CFG7: length 60.6
  TOP w0.102: v1(95.28,28.44) 94.86,28.03 JXDP1.35
  IN1 w0.089: v1(95.28,28.44) 94.77,28.95 94.77,31.44 96.18,32.84 96.18,33.37 97.94,35.13 102.41,35.13 103,35.72 103,36.59 112.41,46 112.41,49.19 114.91,51.69 114.91,54.45 116.04,55.58 116.36,55.58 116.88,56.1 116.88,57.44 117.46,58.02 117.46,58.67 117.82,59.03 123.33,59.03 123.91,58.45 127.52,58.45 v1(128.31,59.24)
  BOTTOM w0.076: v1(128.31,59.24) v2(128.81,58.75) 128.98,58.58 129.96,58.58 130.23,58.85 130.55,58.85 130.71,59.02 131.5,59.02 131.53,58.98 132.01,58.98 UC1.Y60
CFG8: length 55.2
  TOP w0.102: JXDP1.10 101,34.53 101.56,35.09 v2(101.56,35.25) 101.56,35.58 101.38,35.76 v1(101.38,37.8)
  IN1 w0.089: v1(125.46,60.78) 123.38,62.85 119.55,62.85 119.46,62.77 118.45,62.77 116.51,60.84 116.51,60.24 116.19,59.92 115.82,59.92 v1(115.38,59.48) 114.73,58.83 114.73,55.98 113.83,55.08 113.83,52.14 111.15,49.46 111.15,46.33 102.18,37.36 101.82,37.36 v1(101.38,37.8)
  BOTTOM w0.076: 126.4,60.04 126.54,60.04 126.8,59.78 127.97,59.78 128.15,59.6 130.55,59.6 UC1.V62
  BOTTOM w0.102: v1(115.38,59.48) 115.87,58.98 117.09,58.98 RC190.1 ; 126.4,60.04 126.19,60.04 v1(125.46,60.78)
CFG9: length 57
  TOP w0.102: JXDP1.12 100.9,34.03 101.92,35.04 101.92,35.63 101.61,35.93 101.61,37.4 v1(102.02,37.81) ; v2(114.97,60.01) 115.39,60.43 v1(115.39,60.52)
  IN1 w0.086: v1(126.66,60.8) 126.66,60.8 126.4,61.06
  IN1 w0.089: 126.4,61.06 124.33,63.13 119.52,63.13 119.37,62.99 118.05,62.99 116.08,61.01 115.86,61.01 115.39,60.54 v1(115.39,60.52) 114.48,59.6 114.48,56.05 113.45,55.02 113.45,52.1 110.63,49.28 110.63,46.14 103.05,38.56 102.77,38.56 v1(102.02,37.81)
  BOTTOM w0.076: UC1.V61 131.4,60.35 130.88,60.35 130.67,60.14 130.67,59.96 130.48,59.76 128.22,59.76 127.99,60 127.42,60
  BOTTOM w0.102: 127.42,60 126.66,60.8 v1(126.66,60.8) ; v1(115.39,60.52) 115.39,60.43 115.81,60.01 117.08,60.01 RC189.1
CFG10: length 56.6
  TOP w0.102: v1(121.42,52.96) 121.42,54.65 RC188.1 ; JXDP1.16 100.7,33.03 100.81,33.14 v2(101.56,33.14) 101.85,32.85 101.85,32.67 102.96,31.56 v1(102.96,30.47)
  IN1 w0.086: 124.97,55.41 128.48,55.41 129.24,56.16 129.71,56.16 130.67,57.13 132.11,57.13 132.42,57.44 132.42,59.26 v1(132.01,59.68)
  IN1 w0.089: v1(102.96,30.47) 104.95,32.46 104.95,33.22 108.92,37.19 109.28,37.19 115.7,43.61 118.95,43.61 121.35,46.01 121.35,51.39 121.02,51.72 121.02,52.56 v1(121.42,52.96) 122.25,52.96 124.69,55.41 124.97,55.41
  BOTTOM w0.076: UC1.V60 132.31,59.98 v1(132.01,59.68)
CFG11: length 54
  TOP w0.102: JXDP1.18 100.89,32.53 v1(100.95,32.59)
  IN4 w0.086: v1(127.25,60.76) 126.72,60.23 126.72,59.6 126.78,59.55 126.78,59.22 126.42,58.87 126.4,58.87
  IN4 w0.089: 126.4,58.87 125.01,58.87 124.68,58.54 124.68,56.9 119.57,51.79 117.42,51.79 114.48,48.85 114.48,38.17 108.06,31.75 101.84,31.75 101,32.59 v1(100.95,32.59)
  BOTTOM w0.076: 128.24,60.03 129.11,60.03 129.63,60.56 129.95,60.56 130.16,60.35 130.55,60.35 130.71,60.51 131.5,60.51 131.53,60.48 132.01,60.48 UC1.U60
  BOTTOM w0.102: v1(127.25,60.76) 127.65,60.37 v2(127.91,60.37) 128.24,60.03
CFG12: length 60.7
  TOP w0.102: v1(101.64,29.53) 101.14,30.03 JXDP1.28
  IN4 w0.086: v1(127.81,62.64) 126.84,61.66 126.64,61.66 126.4,61.42
  IN4 w0.089: 126.4,61.42 124.93,61.42 124.19,60.68 124.19,57.08 121.79,54.68 121.12,54.68 119.02,52.57 117.59,52.57 114.01,48.99 114.01,38.51 109.14,33.64 107.51,33.64 107.2,33.34 100.28,33.34 99.4,32.46 99.4,29.85 100.16,29.09 101.19,29.09 v1(101.64,29.53)
  BOTTOM w0.076: v2(127.66,63.31) 127.81,63.16 v1(127.81,62.64) 128.71,61.74 129.27,61.74 129.45,61.56 UC1.T63
CFG13: length 56.7
  TOP w0.102: v1(101,29.52) 101,29.52 101,29.53 JXDP1.30
  IN4 w0.089: v1(124.87,60.77) 124.4,60.31 124.4,56.94 121.74,54.27 121.02,54.27 119.11,52.36 117.68,52.36 114.25,48.93 114.25,38.39 109.25,33.39 107.68,33.39 107.2,32.91 105.31,32.91 104.85,32.45 102.08,32.45 101.49,33.05 100.63,33.05 100.05,32.46 100.05,30.47 v1(101,29.52)
  BOTTOM w0.076: UC1.T62 130.55,61.1 129.27,61.1 129.13,61.24 127.45,61.24
  BOTTOM w0.102: v1(124.87,60.77) 125.34,61.24 v2(125.72,61.24) 127.45,61.24
CFG14: length 60.6
  TOP w0.102: JXDP1.34 97.99,28.53 v1(97.9,28.44)
  IN4 w0.086: v1(127.23,62.63) 126.51,61.91 126.4,61.91
  IN4 w0.089: v1(97.9,28.44) 99,29.53 99,32.59 99.96,33.56 105.32,33.56 106.45,34.69 109.82,34.69 113.78,38.65 113.78,49.07 117.5,52.79 118.93,52.79 121.17,55.03 121.82,55.03 123.97,57.18 123.97,60.92 124.96,61.91 126.4,61.91
  BOTTOM w0.076: v1(127.23,62.63) v2(128.17,61.69) 128.36,61.5 129.16,61.5 129.39,61.26 130.48,61.26 130.67,61.46 130.67,61.63 130.88,61.85 131.4,61.85 UC1.T61
CFG15: length 54
  TOP w0.102: JXDP1.36 101.18,28.03 v2(101.79,28.64) 102.27,29.12 v1(102.27,29.66)
  IN4 w0.086: v1(132.01,61.18) 132.01,61.16 130.64,59.79 130.64,59.54 130.49,59.39 130.49,56.76 129.97,56.24 128.49,56.24 127.46,55.21 124.97,55.21
  IN4 w0.089: v1(102.27,29.66) 102.76,29.17 106.63,29.17 115.34,37.89 115.34,40 122.18,46.84 122.18,48.32 122.48,48.62 122.48,53.05 124.64,55.21 124.97,55.21
  BOTTOM w0.076: UC1.T60 132.31,61.48 v1(132.01,61.18)
CFG16: length 55.4
  TOP w0.102: v2(126.02,58.74) 126.02,59.09 v1(125.72,59.38) ; JXDP1.6 97.83,35.53 97.33,36.02 v1(97.33,36.63)
  IN1 w0.089: v1(97.33,36.63) 97.73,37.02 102.16,37.02 111.37,46.23 111.37,49.37 114.05,52.05 114.05,54.92 114.97,55.84 114.97,58.16 115.75,58.93 116.1,58.93 116.76,59.59 116.76,60.63 118.08,61.95 121.84,61.95 123.1,60.7 123.44,60.7 123.84,60.3 125.25,60.3 125.72,59.82 v1(125.72,59.38)
  BOTTOM w0.076: UC1.AA62 131,58.56 130.55,58.1 130.23,58.1 130.22,58.08 128.32,58.08 128.08,58.32 127.62,58.32
  BOTTOM w0.102: 127.62,58.32 126.79,58.32 v1(125.72,59.38)
CFG17: length 48.8
  TOP w0.102: JXDP1.4 100.7,36.03 v1(100.93,36.25)
  IN1 w0.089: v1(126.38,59.38) 125.92,58.93 124.14,58.93 122.96,60.11 117.67,60.11 117.34,59.78 117.34,59.3 117.02,58.99 117.02,58.2 116.43,57.61 116.43,56.33 116.12,56.01 115.86,56.01 114.48,54.63 114.48,51.87 111.94,49.33 111.94,46.19 111.8,46.05 102.29,36.54 101.22,36.54 v1(100.93,36.25)
  BOTTOM w0.076: 127.21,58.55 v2(127.05,58.71) 126.4,59.36 ; 127.62,58.55 128.14,58.55 128.45,58.25 130.15,58.25 130.16,58.27 130.48,58.27 130.71,58.5 130.71,58.68 130.88,58.85 131.4,58.85 UC1.AA61
  BOTTOM w0.102: 127.62,58.55 127.21,58.55 ; 126.4,59.36 v1(126.38,59.38)
CFG18: length 54.5
  TOP w0.102: JXDP1.24 101.06,31.03 v1(101.63,30.46)
  IN4 w0.086: 126.4,56.56 130.04,56.56 130.25,56.77 130.25,60.33 129.96,60.62 129.11,60.62 v1(128.96,60.77)
  IN4 w0.089: v1(101.63,30.46) 101.99,30.1 102.66,30.1 103.37,29.39 106.54,29.39 115.07,37.92 115.07,40.03 121.97,46.93 121.97,48.41 122.22,48.67 122.22,53.76 125.02,56.56 126.4,56.56
  BOTTOM w0.076: v1(128.96,60.77) 128.99,60.73 129.34,60.73 129.5,60.89 130.27,60.89 UC1.U63
CFG19: length 56
  TOP w0.102: v1(102.25,30.5) 102.25,31.44 101.87,31.82 v2(101.66,31.82) 100.96,31.82 100.67,31.53 JXDP1.22
  IN4 w0.086: v1(128.38,60.77) 128.38,59.85 128.49,59.74 129.68,59.74 129.98,59.44 129.98,58.96 129.64,58.61 126.4,58.61
  IN4 w0.089: v1(102.25,30.5) 103.1,31.35 108.15,31.35 114.8,37.99 114.8,40.06 121.75,47.02 121.75,48.5 121.97,48.72 121.97,53.86 124.94,56.84 124.94,58.49 125.07,58.61 126.4,58.61
  BOTTOM w0.076: v1(128.38,60.77) 128.88,60.27 129.11,60.27 129.57,60.72 130.02,60.72 130.23,60.51 130.48,60.51 130.77,60.81 UC1.U62
CFG_RCOMP: length 18.8
  TOP w0.127: v1(118.21,59.45) 118.21,59.74 v2(118.88,60.42)
  TOP w0.381: v1(118.21,59.45) 117.64,59.45 RC185.1
  IN3 w0.381: v1(129.78,60.14) 129.82,60.14 130.48,59.48 130.48,58.89 129.6,58.02 124.97,58.02 123.86,56.91 120.51,56.91 120.22,57.2 120.22,58 119.35,58.87 118.55,58.87 118.21,59.21 v1(118.21,59.45)
  BOTTOM w0.203: UC1.V63 129.86,60.06 v1(129.78,60.14)
CHAGER_SRC:
  vias: v2(76.49,86.81) v3(71.35,91.9) v3(71.73,91.33) v3(72.11,91.9) v3(72.56,91.33) v3(72.87,91.9) v3(73.38,91.39) v3(73.72,91.93) v3(74.1,91.38) v3(74.41,91.96) v3(81.18,84.72) v3(81.7,85.18) v3(82.4,85.18) v3(83.1,85.18) v3(83.78,85.18) v3(84.51,85.17)
CHARGER_CELL_PIN: length 4.6
  TOP w0.203: 77.76,74.42 77.76,74.89 77.72,74.93 PU700.16
  TOP w0.254: 77.76,74.42 78.27,73.92 v2(78.27,73.47) PR725.2 PR729.1
CHARGER_SMBCLK: length 242.5
  TOP w0.102: RPE6.3 249.88,57.97 251.09,56.76 v1(251.09,56.72) ; UE2.B50 253.83,56 v1(253.98,56.15) ; PU700.12 75.61,77.01 v3(75.45,76.85)
  IN1 w0.089: v1(89.69,30.17) 89.59,30.06 88.76,30.06 86.2,32.63 86.2,47.61 85.7,48.11 85.7,55.9 81.74,59.86 81.74,63.08 79.84,64.98 78.55,64.98 75.86,67.67 75.86,68.7 76.09,68.92 76.09,73.51 75.36,74.24 75.36,76.76 v3(75.45,76.85) ; v1(251.09,56.72) 251.11,56.72 251.6,56.24 253.85,56.24 253.94,56.15 v1(253.98,56.15)
  BOTTOM w0.102: v1(251.09,56.72) 250.74,57.08 247.05,57.08 245.82,55.84 PT2.1 245.82,55.45 244.35,53.98 241.24,53.98 240.5,53.24 240.5,51.85 239.08,50.43 239.08,47.95 236.11,44.99 234.81,44.99 234.72,44.9 234.63,44.9 233.24,43.51 233.24,41.64 230.64,39.04 230.64,36.72 225.8,31.87 222.8,31.87 221.73,30.8 207.02,30.8 205.27,32.55 199.46,32.55 196.93,30.03 111.02,30.03 109.3,28.3 103.95,28.3 103.77,28.48 99.4,28.48 98.79,27.87 93.59,27.87 92.37,29.09 92.35,29.09 92.23,29.21 91.03,29.21 90.08,30.17 v1(89.69,30.17)
CHARGER_SMBDAT: length 242
  TOP w0.102: UE2.A47 251.99,56.25 251.97,56.28 251.27,56.28 251.09,56.1 v1(251.09,56.1) 250.63,56.56 250.63,56.68 249.84,57.47 RPE6.2 ; v3(75.4,77.51) 75.48,77.43 76.45,77.43 PU700.11
  IN1 w0.089: v1(89.75,29.49) 89.65,29.59 88.57,29.59 85.73,32.43 85.73,32.82 85.73,32.82 85.73,47.36 85.23,47.86 85.23,55.7 81.27,59.66 81.27,62.89 79.65,64.51 78.36,64.51 75.7,67.16 75.39,67.47 75.39,68.89 75.62,69.12 75.62,73.32 74.89,74.04 74.89,77 v3(75.4,77.51)
  BOTTOM w0.102: v1(251.09,56.1) 250.88,55.88 249.99,55.88 249.22,56.64 247.3,56.64 246.3,55.64 246.3,55.25 244.55,53.49 PT1.1 241.44,53.49 240.98,53.04 240.98,51.65 239.56,50.23 239.56,47.75 236.28,44.48 234.98,44.48 234.92,44.41 234.83,44.41 233.72,43.31 233.72,41.44 231.13,38.84 231.13,36.52 226,31.38 223,31.38 221.93,30.32 206.82,30.32 205.07,32.07 199.66,32.07 197.13,29.54 111.22,29.54 109.5,27.82 103.75,27.82 103.57,27.99 99.6,27.99 98.99,27.38 93.39,27.38 92.17,28.6 92.15,28.6 92.03,28.73 90.84,28.73 90.08,29.49 v1(89.75,29.49)
CHG_BTS_C:
  vias: v2(85.13,77.41)
CHG_LGATE: length 15.7
  IN2 w1.016: 84.29,76.19 84.37,76.27 87.99,76.27 90.83,79.11 90.83,86.39 90.86,86.41
  BOTTOM w0.127: v3(81.8,75.53) v2(82.42,75.53)
  vias: v3(81.78,76.19) v3(90.39,87.63) v3(90.39,86.96)
CHG_SNUB: length 0.8
  BOTTOM w0.102: 92.47,91.28 v2(93.27,91.28)
CHG_SW: length 5.9
  IN1 w1.016: 87.38,84.09 87.39,84.08 87.39,82.65 85.04,80.3 83.86,80.3
  vias: v1(94.32,87.32) v3(83.6,79.31) v3(83.6,78.68) v3(87.07,84.39) v3(87.81,84.42)
CHG_UGATE: length 9
  IN1 w1.016: 82.69,77.46 82.88,77.65 85.09,77.65 88.91,81.47 89.38,81.47 89.4,81.49
  BOTTOM w0.127: v3(82.49,78.07) v2(83.12,78.07)
  vias: v1(89.32,82.12) v1(89.93,82.13) v3(81.8,78.02)
CLK_27M_IN: length 11.7
  TOP w0.102: YV2.1 148.08,89.12 148.95,88.25 150.29,88.25 150.84,88.8 151.82,88.8 RV80.1 152.29,89.27 CV115.1 153.5,89.58 154.94,89.58 v2(155.26,89.9) 155.26,90.67 156.4,91.81 156.4,92.08 UV8.K1
CLK_27M_OUT: length 8
  TOP w0.076: UV8.L1 156.85,91.65 156.1,90.9 156.1,90.49
  TOP w0.102: RV81.2 152.08,88.15 RV80.2 152.59,88.66 153.83,88.66 154.07,88.9 v2(154.34,88.9) 155.13,88.9 155.92,89.69 155.92,90.31 156.1,90.49
CLK_27M_OUT_R: length 5.5
  TOP w0.102: CV113.1 152.72,87.67 152.46,87.67 152.34,87.54 152.3,87.54 151.99,87.24 RV81.1 151.03,87.1 YV2.3 149.68,85.8 v2(149.82,85.66)
CLK_BIASREF: length 10.9
  BOTTOM w0.076: UC1.C26 153.71,68.81 154.04,69.14 154.04,69.24 154.37,69.24 154.57,69.45 154.57,69.97 154.81,70.21 155.33,70.21 156.6,71.48 156.6,72.6 156.99,72.98 156.99,73.32 158,74.33
  BOTTOM w0.102: 158,74.33 158.42,74.75 v2(158.42,75.25) 158.58,75.42 RC69.1
CLK_DDC2_2320: length 30.5
  TOP w0.102: RV251.2 181.14,90.35 v1(179.81,91.68) 179.69,91.8 UV16.10 ; UV8.L4 159.12,91.56 v1(159.12,89.83)
  BOTTOM w0.102: v1(159.12,89.83) 159.92,89.04 159.92,88.8 161.81,86.91 167.42,86.91 168.26,86.07 170.43,86.07 171.31,86.95 176.38,86.95 177.62,88.18 177.62,88.65 178.64,89.66 178.64,90.52 v1(179.81,91.68)
CLK_DDC2_CRT: length 109.7
  TOP w0.102: v1(265.53,96.74) 266.23,96.74 267.02,97.53 267.02,107.67 268.72,109.37 268.72,110.68 269.28,111.24 RV36.2 269.38,111.37 v2(269.38,112.41) 269.38,112.9 JCRT1.15 ; v1(181.95,93.92) 181.9,93.92 181.78,94.05 UV16.14
  IN1 w0.089: v1(181.95,93.92) 182.37,94.34 187.22,94.34 187.39,94.5 197.69,94.5 198.65,95.47 217.37,95.47 218.85,94 224.05,94 225.69,95.63 230,95.63 230.87,96.51 239.81,96.51 240.44,95.88 243.94,95.88 244.64,96.59 250,96.59 250.46,96.13 257.56,96.13 258.5,97.07 264.76,97.07 265.04,96.79 265.48,96.79 v1(265.53,96.74)
CLK_DDC2_DOCK: length 48.9
  TOP w0.102: v1(182.58,93.91) 182.58,94.25 182.38,94.45 v2(182.23,94.45) UV16.15
  IN4 w0.089: v1(182.58,93.91) 183.46,94.8 183.46,96.66 181.74,98.39 181.74,99.67 179.72,101.69 179.72,102.42 175.86,106.28 172.33,106.28 168.81,109.79 168.81,111.79 167.22,113.38 165.2,113.38 164.2,114.37 161.5,114.37 159.93,115.94 159.93,118.73 159.5,119.17 156.4,119.17 v1(155.99,119.57)
  BOTTOM w0.102: JDOCK1.48 157.4,119.31 157.05,119.66 157.05,119.74 156.81,119.98 156.4,119.98 v1(155.99,119.57)
CLK_KBD: length 136.4
  TOP w0.102: RPE2.8 242.94,63.68 243.84,62.78 v1(243.84,62.41) ; v1(235.81,78.08) 235.81,79.38 228.14,87.05 228.14,98.35 225.83,100.66 225.83,104.11 223.31,106.63 220,106.63 v1(219.96,106.59) ; v1(251.02,61.17) 251.43,60.75 UE2.A38
  IN1 w0.089: v1(251.02,61.17) 244.88,61.17 243.84,62.21 v1(243.84,62.41)
  IN2 w0.122: v1(199.5,111.16) 199.51,111.16 199.61,111.06 199.61,110.22 204.79,105.04 218.41,105.04 v1(219.96,106.59)
  IN4 w0.089: v1(192.94,118.67) 192.44,118.18 192.3,118.04 192.3,116.89 197.98,111.22 199.44,111.22 v1(199.5,111.16) ; v1(243.84,62.41) 241.81,64.44 241.81,70.67 241.4,71.08 241.4,76.21 239.64,77.97 235.93,77.97 v1(235.81,78.08)
  BOTTOM w0.102: JDOCK1.78 165.9,119.28 165.98,119.35 165.98,119.82 167.03,120.88 188.19,120.88 190.54,118.53 192.8,118.53 v1(192.94,118.67)
CLK_MSE: length 151.8
  TOP w0.102: v1(251.58,60.04) 251.79,60.25 UE2.A39 ; v1(243.22,60.1) 242.54,60.77 242.54,62.28 242.14,62.68 RPE2.6 ; v1(237.01,76.99) 237.26,76.99 237.69,77.42 237.69,89.93 239.05,91.29 239.05,91.96 v1(239.04,91.98)
  IN2 w0.122: v1(243.22,60.1) 243.9,59.41 243.9,58.45 244.32,58.03 246.19,58.03 246.99,57.23 248.62,57.23 249.62,56.22 250.17,55.68 251.27,55.68 252.39,56.8 252.39,59.19 251.58,60 v1(251.58,60.04)
  IN4 w0.089: v1(237.01,76.99) 237.12,76.88 239.33,76.88 240.45,75.76 240.45,71.32 240.09,70.97 240.09,64.86 240.75,64.2 240.75,60.75 241.41,60.1 v1(243.22,60.1) ; v1(164.99,112.26) 164.94,112.26 164.55,111.87 164.55,110.98 165.15,110.38 167.07,110.38 172.03,105.43 175.53,105.43 178.87,102.09 178.87,99.66 181.14,97.38 181.14,94.73 180.86,94.45 180.86,92.75 181.69,91.92 186.33,91.92 186.63,92.22 191.98,92.22 192.34,91.86 194.07,91.86 195.08,92.88 196.79,92.88 199.04,95.13 217.29,95.13 218.82,93.6 233.79,93.6 234.59,92.8 235.62,92.8 236.34,92.08 238.94,92.08 v1(239.04,91.98)
  BOTTOM w0.102: JDOCK1.71 164.4,111.72 164.87,112.19 164.92,112.19 v1(164.99,112.26)
CLK_PCI_DOCK: length 137.4
  TOP w0.102: v1(193.27,86.2) 196,83.47 196,70.63 198.04,68.58 198.32,68.58 199.31,67.59 199.31,63.44 199.78,62.97 199.78,56.63 198.35,55.2 198.35,51.15 194.95,47.74 v1(194.95,44.47) ; v1(198.74,39.39) 198.44,39.08 197.95,39.08 193.55,34.68 193.55,33.82 189.93,30.19 167.23,30.19 160.24,37.19 CC15.2 RC70.2
  IN4 w0.089: v1(177.76,107.17) 177.76,105.16 180.28,102.65 180.28,101.92 182.34,99.86 184.09,99.86 185.98,97.97 185.98,96.91 188.27,94.62 191.81,94.62 193.61,92.81 v1(193.61,92.79)
  BOTTOM w0.102: R273.1 178.09,106.83 v1(177.76,107.17) 177.9,107.3 JDOCK1.121 ; v1(198.74,39.39) 197.87,39.39 195.4,41.85 195.4,44.01 v1(194.95,44.47) ; v1(193.61,92.79) 193.61,92.46 193.64,92.43 193.64,86.41 193.42,86.2 v1(193.27,86.2)
CLK_PCI_LPDEBUG: length 132.2
  TOP w0.102: CC14.2 RC67.2 v2(161.12,37.71) 161.12,36.98 167.4,30.71 189.65,30.71 193.07,34.12 193.07,34.87 197.78,39.59 198.24,39.59 198.75,40.1 198.91,40.1 199.3,40.48 224.32,40.48 225.53,41.68 235.9,41.68 237.27,43.06 237.99,43.06 242.56,47.62 242.56,49.02 242.91,49.38 243.24,49.38 243.84,48.78 248.15,48.78 248.45,49.09 249.5,49.09 252.83,45.76 262.8,45.76 263.35,45.21 266.41,45.21 v1(266.7,45.51)
  BOTTOM w0.102: v1(266.7,45.51) 266.61,45.42 266.61,44.33 266.9,44.03 266.9,39.75 268.63,38.03 JLPDE1.10
CLK_PCI_MEC: length 180.5
  TOP w0.076: 164.13,38.35 164.17,38.39 164.17,39.83 RC74.2 CC13.2
  TOP w0.102: 164.13,38.35 164.08,38.3 164.08,35.47 167.51,32.04 189.62,32.04 192.1,34.52 192.1,35.28 197.38,40.55 197.84,40.55 198.35,41.06 v1(198.51,41.06) ; UE2.A29 255.6,65.28 255.41,65.47 255.41,66.35 v1(255.88,66.82) 256.07,67.01 RE66.1 ; v1(273.35,45.49) 273.28,45.42 270.47,45.42 268.67,43.61 266.98,43.61 v1(265.47,42.1)
  IN4 w0.089: v1(198.51,41.06) 198.95,41.06 199.36,40.67 201.53,40.67 206.34,35.85 212.52,35.85 213.94,34.43 226.61,34.43 227.47,35.29 227.47,39.81 228.44,40.79 229.48,40.79 232.44,43.74 232.94,43.74 232.95,43.73 236.73,43.73 237.16,43.3 238.01,43.3 238.4,43.69 240.2,43.69 240.69,44.19 242.27,44.19 244.31,46.23 245.74,46.23 246.02,45.94 252.8,45.94 254.79,43.96 257.25,43.96 257.77,43.44 263.75,43.44 265.09,42.1 v1(265.47,42.1) ; v1(255.88,66.82) 257.54,68.48 257.54,70.31 258.76,71.53 262.04,71.53 265.35,68.21 270.34,68.21 270.65,67.91 270.65,65.76 271.89,64.52 271.89,59.94 273.55,58.29 273.55,50.76 273.13,50.34 273.13,45.72 v1(273.35,45.49)
CLK_PCI_SIO: length 130.2
  TOP w0.076: CC12.2 165.07,41.58 165.07,40.82 164.64,40.39 RC72.2
  TOP w0.102: RC72.2 164.64,35.61 167.59,32.67 v2(168.44,32.67) 189.56,32.67 191.62,34.72 191.62,35.48 197.18,41.04 197.64,41.04 198.16,41.56 223.76,41.56 224.93,42.73 235.53,42.73 235.84,43.03 235.84,44.01 236.5,44.67 236.5,46.03 237.37,46.9 237.37,50.05 238.54,51.22 238.54,54.23 238.1,54.68 238.1,58.17 238.29,58.36 238.29,73.15 237.46,73.98 237.46,74.6 240.04,77.18 245.5,77.18 RE27.1 246.28,77.96 247.18,77.96 247.44,77.7 247.74,77.7 247.75,77.69 UE1.A28
CLK_PCIE_LAN: length 173.4
  TOP w0.102: UL1.44 278.08,89.78 v1(277.85,90.01)
  IN1 w0.089: v1(145.29,73.15) 145.29,73.1 145.03,72.84 144.91,72.84 144.79,72.96 144.79,75.19 145.14,75.54 145.34,75.54 146.39,76.58 146.39,79.54 147.23,80.38 147.23,80.96 148.7,82.43 148.7,82.72 151.29,85.3 151.29,85.75 154.3,88.76 155.74,88.76 156.15,88.34 163.91,88.34 165.05,89.48 167.78,89.48 169.02,90.72 169.02,91.72 171.74,94.44 171.74,98.25 172.57,99.08 173.06,99.08 173.81,99.83 184.81,99.83 186.19,101.22 194.01,101.22 194.35,100.88 202.07,100.88 202.33,100.62 224.39,100.62 225.51,101.73 237.56,101.73 238.81,102.99 242.33,102.99 242.59,103.25 249.24,103.25 250.12,103.25 250.7,103.83 256.02,103.83 257.21,102.64 261.04,102.64 261.6,102.08 275.02,102.08 275.35,102.41 275.35,102.74 275.73,103.11 v1(275.74,103.11)
  BOTTOM w0.076: v1(145.29,73.15) 145.02,72.89 144.51,72.89 144.22,72.59 143.65,72.02 143.65,69.29 UC1.B42
  BOTTOM w0.102: v1(275.74,103.11) 275.74,103.11 275.62,102.99 275.62,93.26 277.51,91.37 277.51,90.35 v1(277.85,90.01)
CLK_PCIE_LAN#: length 173.4
  TOP w0.102: v1(277.27,89.98) 277.68,89.57 UL1.45
  IN1 w0.089: v1(275.16,103.11) 275.16,102.49 274.94,102.27 261.68,102.27 261.12,102.83 257.29,102.83 256.1,104.02 250.61,104.02 250.04,103.44 249.32,103.44 242.51,103.44 242.24,103.18 238.73,103.18 237.48,101.93 225.43,101.93 224.31,100.82 202.41,100.82 202.15,101.07 194.43,101.07 194.09,101.41 186.11,101.41 184.72,100.03 173.72,100.03 172.97,99.28 172.49,99.28 171.55,98.33 171.55,94.52 168.83,91.8 168.83,90.8 167.7,89.68 164.97,89.68 163.83,88.53 156.24,88.53 155.82,88.95 154.22,88.95 151.09,85.83 151.09,85.38 148.51,82.8 148.51,82.51 147.04,81.04 147.04,80.46 146.19,79.62 146.19,76.66 145.26,75.73 145.05,75.73 144.6,75.28 144.6,72.88 144.83,72.65 145.21,72.65 v1(145.29,72.57)
  BOTTOM w0.076: v1(145.29,72.57) 145.2,72.66 144.61,72.66 143.87,71.93 143.87,69.52 143.92,69.47 143.99,69.39 143.99,69.18 UC1.C41
  BOTTOM w0.102: v1(275.16,103.11) 275.36,102.91 275.36,93.15 277.27,91.25 v1(277.27,89.98)
CLK_PCIE_MMI: length 222.6
  TOP w0.102: v1(305.16,66.3) 305.4,66.05 305.4,65.91 306.09,65.22 UR1.3
  IN1 w0.089: v1(145.29,74.44) 145.48,74.63 145.76,74.63 146.25,75.13 146.25,75.32 147.96,77.02 147.96,80.72 150.63,83.4 150.63,83.58 151.85,84.8 152.57,84.8 155.3,87.53 166.9,87.53 169.88,90.51 169.88,91.57 170.22,91.91 171.02,91.91 171.51,92.4 171.51,93.24 172.5,94.24 172.5,97.36 174.31,99.16 185.56,99.16 186.94,100.54 193.43,100.54 193.82,100.15 201.82,100.15 202.07,99.9 224.79,99.9 225.96,101.07 238.08,101.07 238.7,101.68 241.99,101.68 242.49,102.19 256.55,102.19 256.8,101.94 256.96,101.94 256.96,101.94 260.79,101.94 261.39,101.35 288.21,101.35 292.19,97.37 292.19,90.07 298.38,83.88 304.41,83.88 305.72,82.57 308.4,82.57 309.45,81.52 309.45,71.84 307.62,70.01 306.54,70.01 305.6,69.07 305.6,68.49 304.43,67.32 304.43,66.83 304.72,66.53 304.92,66.53 v1(305.16,66.3)
  BOTTOM w0.076: UC1.C42 143.68,68.78 143.24,69.23 143.06,69.23 142.9,69.39 142.85,69.45 142.82,69.56 142.82,69.61 142.87,69.75 142.9,69.82 142.9,69.99 142.87,70.07 142.85,70.12 142.82,70.21 142.82,72.8 143.17,73.14
  BOTTOM w0.102: v1(145.29,74.44) 145.16,74.56 144.64,74.56 v3(144.17,74.09) 143.47,73.39 143.29,73.21 143.22,73.14 143.17,73.14
CLK_PCIE_MMI#: length 222.7
  TOP w0.102: v1(305.17,66.91) 305.24,66.91 305.68,66.47 305.68,66.11 306.16,65.62 UR1.2
  IN1 w0.089: v1(145.29,75.02) 145.48,74.83 145.67,74.83 146.06,75.21 146.06,75.4 147.76,77.1 147.76,80.8 150.44,83.48 150.44,83.66 151.77,84.99 152.49,84.99 155.22,87.72 166.81,87.72 169.68,90.59 169.68,91.65 170.14,92.11 170.94,92.11 171.31,92.48 171.31,93.32 172.31,94.32 172.31,97.44 174.23,99.35 185.48,99.35 186.86,100.74 193.51,100.74 193.9,100.35 201.9,100.35 202.15,100.1 224.71,100.1 225.88,101.26 238,101.26 238.62,101.88 241.91,101.88 242.41,102.38 256.63,102.38 256.88,102.14 260.88,102.14 261.47,101.54 288.29,101.54 292.38,97.45 292.38,90.15 298.46,84.08 304.49,84.08 305.8,82.77 308.48,82.77 309.64,81.6 309.64,71.76 307.7,69.82 306.62,69.82 305.79,68.99 305.79,68.41 304.62,67.24 304.62,66.91 304.8,66.73 304.99,66.73 v1(305.17,66.91)
  BOTTOM w0.076: 142.63,72.96 143.06,73.39 143.11,73.39 ; UC1.C43 143.09,68.93 142.76,69.27 142.7,69.36 142.69,69.36 142.67,69.4 142.62,69.58 142.62,69.62 142.7,69.81 142.71,69.85 142.71,69.96 142.7,70.01 142.68,70.06 142.66,70.13 142.63,70.15
  BOTTOM w0.102: 143.11,73.39 144.51,74.79 145.06,74.79 v1(145.29,75.02) ; 142.63,70.15 142.63,72.96
CLK_PCIE_SATA: length 167.5
  IN1 w0.089: v1(289.81,98.08) 289.78,98.08 289.4,97.7 289.4,97.56 289.22,97.37 279.38,97.37 278.67,98.08 269.12,98.08 266,94.96 249.77,94.96 249.05,95.68 245.25,95.68 242.57,92.99 235.21,92.99 233.52,94.69 228.47,94.69 226.62,92.84 196.87,92.84 195.41,91.37 193.67,91.37 192.83,92.22 181.55,92.22 181.43,92.34 175.13,92.34 172.97,90.19 172.97,88.93 172.22,88.17 171.5,88.17 168.34,85.02 167.8,85.02 167.58,84.8 154.93,84.8 150.03,79.89 150.03,77.08 147.73,74.78 147.73,74.17 147.15,73.6 147.15,72.5 147.26,72.4 147.39,72.4 147.65,72.66 v1(147.65,72.71)
  BOTTOM w0.076: UC1.A37 146.98,70.23 147.15,70.41 147.15,72.21 v1(147.65,72.71)
  BOTTOM w0.102: v1(289.81,98.08) 289.79,98.08 289.46,97.75 289.46,97.58 290.18,96.85 291.03,96.85 291.1,96.92 291.1,97.04 291.15,97.1 JNGFF2.47
CLK_PCIE_SATA#: length 167.6
  IN1 w0.089: v1(289.2,98.07) 289.2,97.64 289.14,97.57 279.46,97.57 278.75,98.28 269.04,98.28 265.92,95.16 249.85,95.16 249.14,95.87 245.17,95.87 242.49,93.19 238.3,93.19 238.3,93.19 238.13,93.19 235.3,93.19 233.6,94.88 228.38,94.88 226.53,93.04 196.79,93.04 195.33,91.57 193.75,91.57 192.91,92.41 181.63,92.41 181.51,92.53 175.05,92.53 172.78,90.27 172.78,89.01 172.14,88.37 171.41,88.37 168.26,85.21 167.72,85.21 167.5,84.99 154.85,84.99 149.83,79.97 149.83,77.16 147.53,74.86 147.53,74.25 146.96,73.68 146.96,72.42 147.18,72.2 147.57,72.2 v1(147.65,72.13)
  BOTTOM w0.076: UC1.B37 146.75,69.69 147.38,70.32 147.38,72.02 147.48,72.13 v1(147.65,72.13)
  BOTTOM w0.102: v1(289.2,98.07) 289.2,97.47 290.08,96.6 JNGFF2.45
CLK_PCIE_WIGIG: length 228.2
  IN1 w0.086: v1(145.3,70.77) 145.28,70.79 144.68,70.79 143.93,71.54 143.93,73.34 143.93,73.35 143.93,73.39
  IN1 w0.089: 143.93,73.39 143.93,75.59 145.44,77.1 145.44,80.94 146.41,81.92 146.74,81.92 147.58,82.76 147.58,82.89 149.88,85.19 149.88,85.58 154.08,89.78 155.96,89.78 156.4,89.33 157.51,89.33 158.64,90.46 162.55,90.46 162.84,90.76 164.42,90.76 165.37,91.71 166.76,91.71 167.05,92.01 167.05,92.55 167.65,93.15 167.65,93.45 168.93,94.74 168.93,97.61 171.92,100.6 172.45,100.6 173.25,101.4 181.38,101.4 182.43,102.45 201.92,102.45 202.88,101.49 223.89,101.49 225.36,102.95 229.06,102.95 229.14,102.95 229.14,102.95 236.99,102.95 238.28,104.24 249.63,104.24 250.28,104.89 255.91,104.89 256.08,105.06 257.76,105.06 259.32,103.5 261.39,103.5 261.87,103.03 272.65,103.03 272.81,103.19 v1(272.81,103.63)
  BOTTOM w0.076: v1(145.3,70.77) 145.49,70.77 145.91,70.34 145.91,69.87 UC1.B39
  BOTTOM w0.102: v1(272.81,103.63) 272.95,103.49 272.95,102.93 274.37,101.5 274.37,98.94 273.69,98.25 273.69,88.97 273.96,88.69 273.96,86.07 273.66,85.77 273.66,84.77 273.96,84.47 273.96,83.39 274.97,82.38 v3(274.97,75.53) 274.97,72.63 279.92,67.68 279.92,66.39 287.09,59.22 287.09,56.4 290.79,52.69 290.79,47.73 290.39,47.33 290.39,45.73 287.51,42.84 287.51,41.96 287.35,41.81 JNGFF1.63
CLK_PCIE_WIGIG#: length 228.2
  IN1 w0.086: v1(145.3,71.35) 144.94,70.99 144.76,70.99 144.12,71.62 144.12,73.34 144.12,73.35 144.12,73.39
  IN1 w0.089: 144.12,73.39 144.12,75.51 145.63,77.02 145.63,80.86 146.49,81.72 146.82,81.72 147.78,82.67 147.78,82.81 150.08,85.11 150.08,85.5 154.16,89.58 155.87,89.58 156.32,89.14 157.59,89.14 158.72,90.27 162.63,90.27 162.93,90.57 164.5,90.57 165.45,91.52 166.84,91.52 167.25,91.93 167.25,92.47 167.84,93.07 167.84,93.37 169.13,94.66 169.13,97.53 172,100.4 172.53,100.4 173.34,101.21 181.46,101.21 182.51,102.26 201.84,102.26 202.8,101.29 223.97,101.29 225.44,102.76 229.06,102.76 237.07,102.76 238.36,104.05 249.71,104.05 250.36,104.7 255.99,104.7 256.16,104.87 257.68,104.87 259.24,103.3 261.31,103.3 261.78,102.83 272.73,102.83 273.01,103.11 273.01,103.27 273.37,103.63 v1(273.39,103.63)
  BOTTOM w0.076: UC1.A39 145.45,70.41 145.16,70.41 144.95,70.62 144.95,70.99 v1(145.3,71.35)
  BOTTOM w0.102: JNGFF1.65 287.85,41.81 287.76,41.9 287.76,42.74 290.64,45.62 290.64,47.22 291.04,47.62 291.04,52.8 287.34,56.5 287.34,59.32 280.17,66.49 280.17,67.78 275.23,72.73 275.23,82.48 274.22,83.49 274.22,84.57 273.91,84.88 273.91,85.66 274.22,85.97 274.22,88.79 273.94,89.07 273.94,98.15 274.62,98.83 274.62,101.61 273.2,103.03 273.2,103.44 v1(273.39,103.63)
CLK_PCIE_WLAN: length 227.2
  IN1 w0.089: v1(272.84,100.55) 272.94,100.44 272.94,100.25 272.74,100.04 270.22,100.04 269.42,100.84 258.35,100.84 257.79,100.29 251.23,100.29 249.85,101.67 242.78,101.67 242.27,101.16 238.86,101.16 238.3,100.59 231.06,100.59 230.66,100.19 225.82,100.19 225.05,99.42 201.7,99.42 201.55,99.57 193.65,99.57 193.23,99.99 187.21,99.99 185.53,98.32 180.68,98.32 180.5,98.5 176.04,98.5 175.71,98.17 175.54,98.17 174.4,97.03 174.4,96.6 173.52,95.72 173.52,94.45 172.68,93.61 172.68,92.64 166.99,86.96 155.43,86.96 153.77,85.29 153.77,84.85 149.11,80.18 149.11,77.5 146.81,75.2 146.81,74.76 145.76,73.71 145.76,71.12 146.14,70.74 v1(146.68,70.74)
  BOTTOM w0.076: v1(146.68,70.74) 146.51,70.74 146.43,70.66 146.43,69.46 146.49,69.4 146.49,68.99 146.55,68.93 UC1.C37
  BOTTOM w0.102: v1(272.84,100.55) 273,100.38 273,98.82 272.8,98.62 272.8,84.37 273,84.16 273,83.03 274.06,81.98 274.06,72.33 278.63,67.76 278.63,58.07 280.77,55.92 282.15,55.92 282.51,55.57 282.93,55.57 284.95,53.55 288.72,53.55 289.93,52.34 289.93,48.4 289.06,47.54 288.52,47.54 286.49,45.51 286.49,45.01 285.65,44.17 284.55,44.17 284.17,44.55 282.05,44.55 281.47,43.97 281.47,41.91 281.35,41.79 JNGFF1.39
CLK_PCIE_WLAN#: length 227.2
  IN1 w0.089: v1(146.68,71.33) 146.68,71.25 146.36,70.94 146.22,70.94 145.96,71.2 145.96,73.63 147,74.67 147,75.12 149.3,77.42 149.3,80.1 153.96,84.76 153.96,85.21 155.51,86.76 167.07,86.76 172.87,92.56 172.87,93.53 173.72,94.37 173.72,95.64 174.6,96.52 174.6,96.95 175.63,97.98 175.79,97.98 176.12,98.31 180.42,98.31 180.6,98.12 185.61,98.12 187.29,99.8 193.14,99.8 193.57,99.37 201.47,99.37 201.62,99.22 225.13,99.22 225.9,100 230.74,100 231.14,100.4 238.38,100.4 238.94,100.96 242.35,100.96 242.86,101.47 249.77,101.47 251.14,100.09 257.87,100.09 258.43,100.64 269.33,100.64 270.13,99.84 272.82,99.84 273.14,100.17 273.14,100.29 273.4,100.55 v1(273.42,100.55)
  BOTTOM w0.076: v1(146.68,71.33) 146.19,70.84 146.19,69.26 UC1.B38
  BOTTOM w0.102: v1(273.42,100.55) 273.25,100.38 273.25,98.72 273.05,98.52 273.05,84.47 273.25,84.27 273.25,83.14 274.31,82.08 v3(274.31,76.85) 274.31,72.43 278.88,67.86 278.88,58.17 280.87,56.17 282.26,56.17 282.62,55.82 283.03,55.82 285.05,53.8 288.82,53.8 290.18,52.44 290.18,48.3 289.17,47.28 288.62,47.28 286.74,45.4 286.74,44.91 285.75,43.92 284.44,43.92 284.06,44.3 282.16,44.3 281.72,43.87 281.72,41.95 281.85,41.82 JNGFF1.41
CLK_TP_SIO: length 39.7
  TOP w0.102: v1(251.66,61.17) 251.75,61.25 UE2.A37 ; JKBTP1.3 234.8,35.74 v2(234.86,35.8) CZ31.1 RZ19.2 237.62,36.35 v1(237.85,36.35)
  BOTTOM w0.102: v1(237.85,36.35) 238.81,36.35 240.11,37.64 240.11,39.37 242.9,42.16 242.9,46.74 245.07,48.91 245.07,49.24 246.46,50.62 246.46,51.4 249.42,54.36 251.31,54.36 253.09,56.13 253.09,60.85 252.77,61.17 v1(251.66,61.17)
CLKRUN#: length 134.4
  TOP w0.102: UE1.B20 v1(250.51,82.44) ; v1(253.54,65.7) 253.68,65.7 254.1,65.28 UE2.A32 ; v1(242.27,73.18) v2(242.27,72.42)
  IN1 w0.089: v1(253.54,65.7) 253.35,65.89 v1(251.5,65.89) ; v1(242.27,73.18) 242.62,72.82 249.53,72.82 v1(249.73,72.62)
  IN4 w0.086: 171.77,60.47 171.75,60.45 167.36,60.45 167.06,60.15 166.42,60.15 166.12,60.45 166.11,60.45 v1(165.96,60.59)
  IN4 w0.089: v1(242.28,81.37) 242.06,81.16 239.98,81.16 239.28,80.46 231.41,80.46 229.79,82.08 209.8,82.08 209.13,81.41 204.21,81.41 204,81.19 203.73,81.19 201.63,79.09 201.63,77.97 194.25,70.59 194.25,64.11 190.91,60.77 188.31,60.77 187.83,60.3 186.58,60.3 186.36,60.52 185.12,60.52 183.73,61.9 v1(183.03,61.9) 183.03,61.34 182.4,60.7 175.67,60.7 175.44,60.47 171.77,60.47
  BOTTOM w0.076: UC1.V5 165.96,60.47 v1(165.96,60.59)
  BOTTOM w0.102: RPC3.8 183.31,61.52 183.03,61.8 v1(183.03,61.9) ; v1(251.5,65.89) 250.8,66.59 250.8,67.29 249.57,68.52 249.57,72.46 v1(249.73,72.62) 249.73,73.22 251.49,74.97 251.49,76.22 252.23,76.96 252.23,80.9 251.13,82.01 250.94,82.01 v1(250.51,82.44) ; v1(242.28,81.37) 242.28,81.07 242.79,80.56 242.79,73.89 242.27,73.37 v1(242.27,73.18)
CMPIN: length 59.5
  TOP w0.102: v1(108.45,50.28) v2(108.45,50.94)
  TOP w0.254: v1(89.73,51.41) 89.5,51.18 85.73,51.18 81.88,55.04 81.88,56.55 79.57,58.86 79.57,61.15 74.41,66.3 PC737.1 75.13,75.86 75.23,75.86 75.94,76.56 75.97,76.56 76.01,76.61 PU700.13
  IN1 w0.254: v1(89.73,51.41) 90.42,52.11 106.06,52.11 106.37,51.81 106.84,51.81 108.36,50.28 v1(108.45,50.28)
  BOTTOM w0.254: v1(108.45,50.28) 108.19,50.54 PR745.1 ; PR737.2 PR745.1 ; PR745.1 108.27,52.09 PR738.1
CMPOUT: length 58.4
  TOP w0.102: v1(109.13,50.26) 109.13,50.23 v2(109.77,49.6)
  TOP w0.203: PU700.14 76.11,76.21 75.98,76.09 PC741.2 74.97,72.84 74.97,66.25 79.93,61.28 79.93,58.99 82.23,56.7 82.23,55.18 85.73,51.69 89.22,51.69 89.42,51.89 91.26,51.89 v1(91.67,51.48)
  IN1 w0.254: v1(91.67,51.48) 91.91,51.73 105.91,51.73 106.32,51.31 106.73,51.31 108.25,49.8 108.79,49.8 109.13,50.14 v1(109.13,50.26)
  BOTTOM w0.254: PR743.1 PR740.1 PR738.2 v1(109.13,50.26)
CONTACTLESS_DET#: length 160.4
  TOP w0.102: v1(214.53,82.91) 214.53,82.9 215.01,82.41 220.22,82.41 221.91,80.72 227.06,80.72 228.19,79.59 228.19,76.76 229.95,75.01 v2(232.45,75.01) 234.65,75.01 237.08,72.57 237.08,60.71 236.47,60.1 236.47,57.57 237.02,57.03 237.02,54.88 235.97,53.83 235.97,46.5 235.79,46.32 235.79,46.32 v1(232.74,43.27) ; v1(236.21,14.12) 236.53,13.8 JUSH1.4 ; v1(184.63,72.08) 184.63,69.63 183.21,68.2 183.21,66.45 182.8,66.04 182.8,65.34 182.28,64.82 v1(182.28,64.57)
  IN2 w0.122: v1(184.63,72.08) 185.16,72.6 193.35,72.6 197.56,76.81 197.56,81.3 200.79,84.52 212.91,84.52 v1(214.53,82.91)
  IN4 w0.086: 171.77,63.02 171.69,62.94 171.68,62.94 171.64,62.9 171.55,62.9 171.5,62.85 171.44,62.85 171.34,62.74 169.02,62.74 168.38,62.1 166.29,62.1 v1(165.95,62.44)
  IN4 w0.089: v1(182.28,64.57) 181.9,64.18 180.59,64.18 180.35,64.42 177.68,64.42 177.01,63.75 174.28,63.75 173.82,63.3 172.05,63.3 171.77,63.02 ; v1(236.21,14.12) 235.24,15.09 235.24,15.8 233.22,17.82 233.22,36.06 231.41,37.87 231.41,41.66 232.74,42.99 v1(232.74,43.27)
  BOTTOM w0.076: UC1.U6 165.7,61.57 166.01,61.89 166.01,62.37 v1(165.95,62.44)
  BOTTOM w0.102: RPC4.7 182.78,64.07 v1(182.28,64.57)
CORE_BOOT_C:
  vias: v2(130.85,95.14)
CORE_SNUB: length 0.7
  TOP w0.102: 122.44,86.1 v2(122.44,85.41)
CORE_SW:
  vias: v2(119.04,84.65) v3(126.12,87.23) v3(126.14,86.53)
CPPE#: length 12.4
  TOP w0.102: v1(178.6,63.13) 178.6,62.74 v2(178.33,62.47)
  IN3 w0.086: 171.77,64.25 171.28,64.25 v1(170.58,64.95)
  IN3 w0.122: v1(178.6,63.13) 178.29,63.44 177.79,63.44 176.97,64.25 171.77,64.25
  BOTTOM w0.076: UC1.J1 169.1,65.38 170.15,65.38 v1(170.58,64.95)
  BOTTOM w0.102: v1(178.6,63.13) 178.62,63.14 178.62,63.14 179.04,63.57 RC160.2
CPU_DPB_AUX: length 10.1
  BOTTOM w0.076: 166.48,71.07 166.47,71.07 166.46,71.06 166.4,71.06 165.91,70.57 165.91,69.65 UC1.B5
  BOTTOM w0.102: RPC20.2 168.18,77.11 168.33,76.96 168.33,76.36 168.49,76.2 v3(168.49,75.76) 168.49,75.17 169.08,74.58 169.08,74.34 169.06,74.32 169.06,73.77 169.08,73.75 169.08,72.97 168.06,71.95 167.41,71.95 167.41,71.96 167.4,71.96 166.51,71.07 166.48,71.07
CPU_DPB_AUX#: length 10.7
  BOTTOM w0.076: UC1.C5 166.18,69.07 166.18,69.67 166.1,69.75 166.1,70.5 166.46,70.86 166.48,70.86
  BOTTOM w0.102: 166.48,70.86 166.61,70.86 167.5,71.75 168.15,71.75 169.29,72.89 v3(169.29,74.04) 169.29,74.67 168.7,75.26 168.7,75.46 168.72,75.48 168.72,76.04 168.7,76.06 168.7,76.29 168.54,76.44 168.54,76.89 168.68,77.03 RPC20.1
CPU_DPB_CTRLCLK: length 107.1
  TOP w0.102: v1(101,106.56) 101.12,106.44 QV3.1
  IN2 w0.086: 151.86,74.13 152,74.13 152.02,74.15 152.11,74.15 152.13,74.16 153.62,74.16 154.97,72.81 155.93,72.81 156.84,71.9 157.77,71.9 158.6,72.73 162.78,72.73 163.08,73.03 164.19,73.03 164.28,72.94 164.28,72.37 163.92,72.01 v1(163.92,71.99)
  IN2 w0.122: v1(108.59,96.61) 108.59,96.51 108.97,96.13 116.99,96.13 117.51,96.65 125.52,96.65 127.4,98.52 131,98.52 131.38,98.13 133.81,98.13 134.61,97.33 134.95,97.33 135.63,96.66 135.63,89.06 136.61,88.08 136.61,87.19 137.19,86.62 142.02,86.62 143.29,85.35 143.29,80.56 144.08,79.78 145.14,79.78 145.41,79.51 147.07,79.51 147.98,80.42 147.98,80.84 148.32,81.18 148.68,81.18 149.14,80.72 149.14,79.69 148.79,79.34 148.79,76.81 151.47,74.13 151.86,74.13
  BOTTOM w0.076: UC1.B9 163.3,69.59 163.82,70.11 163.82,71.29 164.05,71.52 164.05,71.85 v1(163.92,71.99) 164.37,72.44 164.37,73.21 164.55,73.39
  BOTTOM w0.102: v1(108.59,96.61) 108.7,96.73 108.7,97.16 107.94,97.91 107.94,104 105.73,106.21 101.84,106.21 101.5,106.56 v1(101,106.56) ; RPC2.2 165.13,76.78 164.96,76.6 v2(164.96,74.39) 164.96,73.8 164.55,73.39
CPU_DPB_CTRLCLK_R: length 15.3
  TOP w0.102: v2(101.26,110.68) 101.26,110.63 v1(100.67,110.05) 100.93,109.79 RV7.1 100.93,108.94 101.12,108.75 QV3.6
  IN4 w0.089: JHDMI1.15 92.2,112.91 92.72,112.38 93.95,112.38 94.32,112.02 94.32,110.25 95.29,109.29 100.39,109.29 100.67,109.57 v1(100.67,110.05)
CPU_DPB_CTRLDAT: length 106.2
  TOP w0.102: v1(102.6,106.7) 102.42,106.88 QV3.4
  IN2 w0.086: v1(164.53,72.02) 164.57,72.07 164.57,73.06 164.31,73.32 162.96,73.32 162.66,73.01 158.48,73.01 157.65,72.19 156.97,72.19 156.05,73.1 155.09,73.1 153.74,74.45 151.86,74.45
  IN2 w0.122: v1(109.19,96.59) 109.33,96.45 116.86,96.45 117.38,96.97 125.39,96.97 127.26,98.85 131.13,98.85 131.52,98.46 133.94,98.46 134.74,97.66 135.09,97.66 135.95,96.79 135.95,89.2 136.94,88.21 136.94,87.32 137.32,86.94 142.16,86.94 143.62,85.48 143.62,80.69 144.21,80.1 145.28,80.1 145.54,79.83 146.94,79.83 147.66,80.55 147.66,80.98 148.18,81.51 148.82,81.51 149.47,80.86 149.47,79.56 149.12,79.21 149.12,76.94 151.61,74.45 151.86,74.45
  BOTTOM w0.076: 165.18,73.39 164.81,73.01 164.81,72.3 v1(164.53,72.02) 164.35,71.85 164.35,71.43 164.12,71.2 164.12,70.93 164,70.8 164,69.89 163.63,69.53 UC1.C9
  BOTTOM w0.102: 165.18,73.39 165.44,73.65 v2(165.44,75.62) 165.44,76.4 165.62,76.58 165.62,77.21 165.63,77.23 RPC2.1 ; v1(109.19,96.59) 109,96.78 109,97.28 108.25,98.04 108.25,104.02 105.83,106.44 102.86,106.44 v1(102.6,106.7)
CPU_DPB_CTRLDAT_R: length 16.8
  TOP w0.102: QV3.3 103.33,105.8 v2(103.76,106.23) 104.15,106.62 v1(104.15,106.87) 103.8,107.23 RV9.1
  IN1 w0.089: JHDMI1.16 92.7,111.45 95.54,108.6 102.43,108.6 v1(104.15,106.87)
CPU_DPC_AUX: length 58.6
  IN4 w0.089: v1(167.21,75.91) 167.18,75.91 166.8,75.53 166.77,75.53 166.75,75.51 166.42,75.51 166.19,75.74 166.06,75.74 164.72,77.08 163.07,77.08 162.38,77.76 152.04,77.76 151.29,77.01 150.49,77.01 147.87,79.62 147.87,82.75 148.27,83.14 148.27,83.91 147.57,84.6 147.57,84.93 147.8,85.16 148.11,85.16 v1(148.32,85.37)
  BOTTOM w0.076: UC1.A6 165.56,70.57 165.56,70.81 167.55,72.8 167.55,73.17
  BOTTOM w0.102: RPC20.3 167.68,77.16 167.55,77.02 167.55,76.61 167.21,76.27 v1(167.21,75.91) 166.87,75.57 166.87,74.46 167.55,73.78 167.55,73.17 ; v1(148.32,85.37) 148.16,85.21 147.97,85.21 147.9,85.28 147.9,85.69 147.43,86.15 137.49,86.15 137.19,86.44 136.15,86.44 135.52,85.82 134.32,85.82 133.3,86.83 133.3,90.58 133.06,90.82 133.06,90.9 CV79.1
CPU_DPC_AUX#: length 58.4
  IN4 w0.089: v1(148.32,84.79) 148.13,84.99 147.87,84.99 147.74,84.86 147.74,84.68 148.44,83.98 148.44,83.07 148.04,82.68 148.04,79.7 150.56,77.18 151.22,77.18 151.97,77.93 162.45,77.93 163.14,77.25 164.79,77.25 166.13,75.91 v1(166.59,75.91)
  BOTTOM w0.076: UC1.B6 164.87,69.94 164.89,69.97 164.89,70.41 165.58,71.1 167.14,72.66 167.34,72.86 167.34,73.13
  BOTTOM w0.102: RPC20.4 167.18,77.12 167.34,76.96 167.34,76.75 166.59,76 v1(166.59,75.91) 166.66,75.83 166.66,74.37 167.34,73.69 167.34,73.13 ; CV80.1 132.73,91.3 132.85,91.18 132.85,90.73 133.09,90.49 133.09,86.75 134.23,85.61 135.61,85.61 136.24,86.24 137.11,86.24 137.4,85.94 147.35,85.94 147.69,85.6 147.69,85.19 147.88,85 148.14,85 148.32,84.81 v1(148.32,84.79)
