# Allegro board Houston14_UMA_DOCK_BRD_A00_20140716.brd (continued)
## Nets (continued)
SPI_DINTPM: RZ30.2 UZ1.26
SPI_DO32: RPC12.6 UC3.5
SPI_DO64: RPC11.7 UC2.5
SPI_DOTPM: RZ29.2 UZ1.23
SPI_PCH_CLK: JSPI1.14 RC227.1 RPC11.3 RPC12.2
SPI_PCH_CS0#: JSPI1.12 RC35.1 RC228.1
SPI_PCH_CS0#_R: RC35.2 UC2.1
SPI_PCH_CS1#: JSPI1.20 RC50.1 RC224.1
SPI_PCH_CS1#_R: RC50.2 UC3.1
SPI_PCH_DIN: JSPI1.16 RC226.1 RPC11.1 RPC12.4
SPI_PCH_DO: JSPI1.18 RC225.1 RPC11.2 RPC12.3
SPI_PCH_DO2: JSPI1.10 RC29.2 RC38.1 RC55.1 RC229.1
SPI_PCH_DO2_32: RC55.2 UC3.3
SPI_PCH_DO2_64: RC38.2 UC2.3
SPI_PCH_DO3: JSPI1.8 RC31.2 RC230.1 RPC11.4 RPC12.1
SPI_PCH_DO3_32: RPC12.8 UC3.7
SPI_PCH_DO3_64: RPC11.5 UC2.7
SPKR: RA12.2 RC180.2 UC1.V2
SRCDET: RV84.1 UV8.C2
SRTCRST#: CC3.2 RC10.2 UC1.AV6
STSTART_DCBLOCK_GC: PR811.2 PU800.16
SUS_ON: PR207.1 RE281.1 RE282.1 RPE10.2 UZ3.5
SUS_ON_EC: RE281.2 UE2.B23
SUS_STAT#/LPCPD#: RC82.2 UC1.AG4
SUSACK#: RC81.2 UC1.AK2 UE2.A23
SUSCLK: RC136.2 RZ56.1
SUSCLK_R: RC136.1 UC1.AE6
SW1: PC110.2 PL102.1 PQ101.1 PQ101.2 PQ101.3 PQ103.5 PR112.1 PU100.18
SW2: PC109.1 PL101.2 PQ100.1 PQ100.2 PQ100.3 PQ102.5 PR111.1 PU100.8
SW_1.35V: PC204.2 PL200.2 PQ200.1 PQ200.2 PQ200.3 PQ201.5 PR203.1 PU200.16
SW_10_GRN#: QL2.1 RL30.2 UL4.41
SW_100_ORG#: QL1.4 RL29.2 UL4.18
SW_+V1.05SP: PL301.1 PR305.1 PR312.2 PU300.10
SW_ACTLED_YEL#: QL1.1 UL4.17
SW_DPB_AUX: CV119.2 RV75.1 UV8.J13
SW_DPB_AUX#: CV120.2 RV82.1 UV8.J14
SW_DPB_AUX#_C: CV120.1 UV11.5
SW_DPB_AUX_C: CV119.1 UV11.2
SW_DPC_AUX: CV122.2 RV74.1 UV8.B11
SW_DPC_AUX#: CV123.2 RV85.1 UV8.A11
SW_DPC_AUX#_C: CV123.1 UV12.5
SW_DPC_AUX_C: CV122.1 UV12.2
SW_LAN_TX0+: TL1.6 UL4.38
SW_LAN_TX0-: TL1.5 UL4.37
SW_LAN_TX1+: TL1.2 UL4.34
SW_LAN_TX1-: TL1.1 UL4.33
SW_LAN_TX2+: TL1.12 UL4.29
SW_LAN_TX2-: TL1.11 UL4.28
SW_LAN_TX3+: TL1.8 UL4.25
SW_LAN_TX3-: TL1.7 UL4.24
SW_USB3RN1: LI1.4 UI4.26
SW_USB3RP1: LI1.1 UI4.27
SW_USB3TN1: CI4.2 UI4.30
SW_USB3TP1: CI5.2 UI4.31
SW_USBP0+: LI3.4 UI4.19
SW_USBP0-: LI3.1 UI4.18
SW_USBP3+: LI4.1 UI5.1
SW_USBP3-: LI4.4 UI5.2
SYS_LED_MASK#: QL1.2 QL1.5 QL2.2 QZ3.2 QZ7.2 RE21.2 UE1.B48 UZ10.1
SYS_PWROK: CC22.1 JXDP1.47 RC120.1 UC1.AG2 UE2.B7
SYS_RESET#: JAPS1.13 RC77.2 UC1.AC3 UC4.4
TDI_IREF: RC186.2 UC1.B12
TDI_XDP_R: RC99.2 RC118.1 UC7.5
TDO_XDP: JXDP1.52 RC98.2 RC115.1 RC117.2 UC7.2
THERMATRIP2#: CE36.1 QE4.1 RE69.2 UE2.B34
THERMATRIP3#: RPE6.1 UE2.A2
THSEL_STRAP: RE78.1 UE2.B29
TMDS_CLK#_C: CV13.1 LV3.1 RV17.1
TMDS_CLK_C: CV14.1 LV3.4 RV16.1
TMDS_CON_CLK: JHDMI1.10 LV3.3
TMDS_CON_CLK#: JHDMI1.12 LV3.2
TMDS_CON_N0: JHDMI1.9 LV6.3
TMDS_CON_N1: JHDMI1.6 LV9.2
TMDS_CON_N2: JHDMI1.3 LV12.3
TMDS_CON_P0: JHDMI1.7 LV6.2
TMDS_CON_P1: JHDMI1.4 LV9.3
TMDS_CON_P2: JHDMI1.1 LV12.2
TMDS_N0_C: CV18.1 LV6.4 RV15.1
TMDS_N1_C: CV21.1 LV9.1 RV13.1
TMDS_N2_C: CV29.1 LV12.4 RV11.1
TMDS_P0_C: CV17.1 LV6.1 RV14.1
TMDS_P1_C: CV22.1 LV9.4 RV12.1
TMDS_P2_C: CV28.1 LV12.1 RV10.1
TOUCH_PANEL_INTR#: JEDP1.5 RPC16.5 UC1.P3
TOUCH_SCREEN_PD#: T96.1(TP-1) UE1.B55
TOUCHPAD_INTR#: RPC3.7 UC1.U7
TP_DC_TEST_B2: RC192.2 UC1.B2
TP_LAN_JTAG_TCK: RL2.2 UL1.35
TP_LAN_JTAG_TDI: T88.1(TP-1) UL1.32
TP_LAN_JTAG_TDO: T89.1(TP-1) UL1.34
TP_LAN_JTAG_TMS: RL1.2 UL1.33
TPM_PIRQ#: RC247.1 UC1.T3 UZ1.20
TRST#_XDP: JXDP1.54 UC7.12
UG_3V: PQ100.4 PU100.10
UG_5V: PQ101.4 PU100.16
UIM_CLK: CZ66.1 JNGFF2.24 JSIM1.4
UIM_DATA: CZ65.1 JNGFF2.26 JSIM1.3
UIM_RESET: CZ67.1 JNGFF2.22 JSIM1.6
USB3RN1: UC1.G20 UI4.5
USB3RN1_D-: DI1.1 DI1.9 JUSB1.5 LI1.3
USB3RN2: LI6.1 UC1.E18
USB3RN2_D-: DI4.1 DI4.9 JUSB3.5 LI6.2
USB3RN4: LI9.1 UC1.F15
USB3RN4_D-: DI6.1 DI6.9 JUSB2.5 LI9.2
USB3RP1: UC1.H20 UI4.4
USB3RP1_D+: DI1.2 DI1.8 JUSB1.6 LI1.2
USB3RP2: LI6.4 UC1.F18
USB3RP2_D+: DI4.2 DI4.8 JUSB3.6 LI6.3
USB3RP4: LI9.4 UC1.G15
USB3RP4_D+: DI6.2 DI6.8 JUSB2.6 LI9.3
USB3TN1: UC1.C33 UI4.2
USB3TN1_C: CI4.1 LI2.4
USB3TN1_D-: DI1.4 DI1.7 JUSB1.8 LI2.3
USB3TN2: CI13.2 UC1.B33
USB3TN2_C: CI13.1 LI5.1
USB3TN2_D-: DI4.4 DI4.7 JUSB3.8 LI5.2
USB3TN4: CI28.2 UC1.B31
USB3TN4_C: CI28.1 LI8.1
USB3TN4_D-: DI6.4 DI6.7 JUSB2.8 LI8.2
USB3TP1: UC1.B34 UI4.1
USB3TP1_C: CI5.1 LI2.1
USB3TP1_D+: DI1.5 DI1.6 JUSB1.9 LI2.2
USB3TP2: CI16.2 UC1.A33
USB3TP2_C: CI16.1 LI5.4
USB3TP2_D+: DI4.5 DI4.6 JUSB3.9 LI5.3
USB3TP4: CI27.2 UC1.A31
USB3TP4_C: CI27.1 LI8.4
USB3TP4_D+: DI6.5 DI6.6 JUSB2.9 LI8.3
USB_DB_DET#: T98.1(TP-1) UE1.A2
USB_OC0#: RPC10.5 UC1.AL3 UI1.5
USB_OC1#: RPC7.8 UC1.AT1 UI3.13
USB_OC2#: RPC5.6 UC1.AH2 UI2.5
USB_OC3#: RPC7.6 UC1.AV3
USB_PWR_EN1#: RPE9.2 UE1.B44 UI1.4
USB_PWR_EN2#: RPE9.3 UE1.A33 UI2.4
USB_PWR_SHR_EN#: RPE9.4 UE2.B38 UI3.6
USB_PWR_SHR_VBUS_EN: RPE9.1 UE1.B50 UI3.5
USBP0+: UC1.AM8 UI4.6
USBP0-: UC1.AN8 UI4.7
USBP0_D+: DI2.2 JUSB1.3 LI3.3
USBP0_D-: DI2.3 JUSB1.2 LI3.2
USBP1+: UC1.AT7 UI3.3
USBP1-: UC1.AR7 UI3.2
USBP1_R_D+: DI5.3 JUSB3.3 LI7.2
USBP1_R_D-: DI5.2 JUSB3.2 LI7.3
USBP2+: JNGFF1.3 UC1.AP8
USBP2-: JNGFF1.5 UC1.AR8
USBP3+: UC1.AT10 UI5.8
USBP3-: UC1.AR10 UI5.7
USBP3_D+: DI3.3 JUSB2.3 LI4.2
USBP3_D-: DI3.2 JUSB2.2 LI4.3
USBP4+: LV27.3 UC1.AL15
USBP4-: LV27.2 UC1.AM15
USBP4_D+: DV4.3 JEDP1.3 LV27.4
USBP4_D-: DV4.2 JEDP1.2 LV27.1
USBP5+: LZ1.1 UC1.AN13
USBP5-: LZ1.4 UC1.AM13
USBP5_D+: JEDP1.13 LZ1.2
USBP5_D-: JEDP1.12 LZ1.3
USBP6+: JUSH1.18 UC1.AN11
USBP6-: JUSH1.19 UC1.AP11
USBP7+: JNGFF2.7 UC1.AP13
USBP7-: JNGFF2.9 UC1.AR13
USBRBIAS: RC152.1 UC1.AJ10 UC1.AJ11
USH_DET#: JUSH1.1 RPC6.6 UC1.E3
USH_PWR_STATE#: JUSH1.5 RZ10.2 UE1.A34
USH_SMBCLK: JUSH1.16 RZ8.2 UE2.A50
USH_SMBDAT: JUSH1.15 RZ9.2 UE2.B53
VCI_IN2#: RPE5.4 UE2.B63
VCT_LAN_R1: RL3.2 UL1.6
VFB: PR531.2 PU500.24
VGA_ID: RE84.1 RE85.1 UE1.B59
VIDALERT_N: PR528.2 PU500.32 RC204.2 RC207.2
VIDSCLK: PR527.2 PU500.31 UC1.N63
VIDSOUT: PR529.2 PU500.1 RC208.2 UC1.L63
VMM2320_AUX: CV110.1 RV70.2 UV7.26
VMM2320_AUX#: CV111.1 RV69.2 UV7.27
VMM2320_AUX#_C: CV111.2 UV8.H2
VMM2320_AUX_C: CV110.2 UV8.H1
VMM2320_HPD: UV7.48 UV8.J1
VMM2320_N0: CV103.1 UV7.49
VMM2320_N0_C: CV103.2 UV8.G2
VMM2320_N1: CV105.1 UV7.46
VMM2320_N1_C: CV105.2 UV8.F2
VMM2320_N2: CV107.1 UV7.44
VMM2320_N2_C: CV107.2 UV8.E2
VMM2320_N3: CV109.1 UV7.41
VMM2320_N3_C: CV109.2 UV8.D2
VMM2320_P0: CV102.1 UV7.50
VMM2320_P0_C: CV102.2 UV8.G1
VMM2320_P1: CV104.1 UV7.47
VMM2320_P1_C: CV104.2 UV8.F1
VMM2320_P2: CV106.1 UV7.45
VMM2320_P2_C: CV106.2 UV8.E1
VMM2320_P3: CV108.1 UV7.42
VMM2320_P3_C: CV108.2 UV8.D1
VMM2320_VGA_DET: RV88.2 UV8.M3
VMM2320_VGA_IREF: RV89.1 UV8.M5
VMM2320_VGA_NC: T108.1(TP-1) UV8.L5
VMM_DPB_CTRLCLK: RPV1.1 UV8.K13 UV11.12
VMM_DPB_CTRLDAT: RPV1.2 UV8.L14 UV11.9
VMM_DPC_CTRLCLK: RPV2.2 UV8.B12 UV12.12
VMM_DPC_CTRLDAT: RPV2.1 UV8.A12 UV12.9
VMM_GPIO4: RV518.2 UV8.B14
VMM_GPIO5: RV519.2 UV8.B13
VMM_GPIO6: RV83.1 UV8.C1
VMM_GPIO7: RPV1.4 UV8.M12
VMM_GPIO8: RPV1.3 UV8.M13
VMM_GPIO9: RV73.1 UV8.L3
VMM_SPI_CLK: UV8.B3 UV9.6
VMM_SPI_CS#: RV86.2 UV8.A4 UV9.1
VMM_SPI_DIN: UV8.B4 UV9.2
VMM_SPI_DO: UV8.A3 UV9.5
VMM_SPI_HOLD: RV87.2 UV9.7
VMM_SPI_WP#: RV517.2 UV8.B1 UV9.3
VR_HOT#: PR534.2 PU500.30
VREF: PC507.2 PH500.1 PR500.2 PR502.2 PR503.2 PR504.2 PR521.2 PU500.27
VSET_5085: CE38.1 RE77.1 UE2.A17
VSYNC_2320: UV8.L9 UV16.7
VSYNC_CONN: CV58.1 JCRT1.14 LV20.2 RV37.2
VSYNC_CRT: LV20.1 UV16.18
VSYNC_DOCK: JDOCK1.67 UV16.17
WIGIG_32KHZ: JNGFF1.42 RZ56.2 RZ57.2
WIGIG_32KHZ_R: RZ57.1 UZ11.4
WIGIG_AUX: CV149.1 RV72.2 UV7.28
WIGIG_AUX#: CV150.1 RV71.2 UV7.29
WIGIG_AUX#_C: CV150.2 JNGFF1.12
WIGIG_AUX_C: CV149.2 JNGFF1.14
WIGIG_HPD: JNGFF1.23 UV7.38
WIGIG_LANE_N0: CV156.1 UV7.39
WIGIG_LANE_N0_C: CV156.2 JNGFF1.24
WIGIG_LANE_N1: CV152.1 UV7.36
WIGIG_LANE_N1_C: CV152.2 JNGFF1.18
WIGIG_LANE_N2: CV147.1 UV7.34
WIGIG_LANE_N2_C: CV147.2 JNGFF1.17
WIGIG_LANE_N3: CV145.1 UV7.31
WIGIG_LANE_N3_C: CV145.2 JNGFF1.11
WIGIG_LANE_P0: CV157.1 UV7.40
WIGIG_LANE_P0_C: CV157.2 JNGFF1.26
WIGIG_LANE_P1: CV153.1 UV7.37
WIGIG_LANE_P1_C: CV153.2 JNGFF1.20
WIGIG_LANE_P2: CV148.1 UV7.35
WIGIG_LANE_P2_C: CV148.2 JNGFF1.19
WIGIG_LANE_P3: CV146.1 UV7.32
WIGIG_LANE_P3_C: CV146.2 JNGFF1.13
WIGIGCLK_REQ#: JNGFF1.60 RPC4.5 UC1.U5
WIRELESS_LED#: QZ2.3 QZ2.6 QZ7.1 QZ11.6 RZ31.2 UE1.A47
WLAN_DISBL#: UE1.B68 UL2.4
WLAN_LED: JLED1.6 QZ9.3
WLAN_LED#: JNGFF1.6 QZ2.1 RZ14.1
WLAN_LED_Q#: QZ7.6 QZ9.2
WLAN_WIGIG60GHZ_DIS#: DZ1.1 RE8.2 UE1.A1
WLAN_WIGIG60GHZ_DIS#_R: DZ1.2 JNGFF1.48
WLANCLK_REQ#: JNGFF1.45 RPC16.6 UC1.N1
WWAN_LED#: JNGFF2.10 QZ11.1 RZ37.1
WWAN_PWR_EN: JNGFF2.6 RZ43.2
WWAN_RADIO_DIS#: DZ5.1 RE10.2 UE1.A53
WWAN_RADIO_DIS#_R: DZ5.2 JNGFF2.8
WWAN_WAKE#: JNGFF2.15 RE276.2 UE1.B43
XDP_DBRESET#: CC21.1 JXDP1.48 RC77.1 RC122.2 UC4.1
XDP_OBS0_R: JXDP1.21 UC1.J60
XDP_OBS1_R: JXDP1.23 UC1.H60
XDP_OBS2_R: T10.1(TP-1) UC1.H61
XDP_OBS3_R: T11.1(TP-1) UC1.H62
XDP_OBS4_R: T12.1(TP-1) UC1.K59
XDP_OBS5_R: T13.1(TP-1) UC1.H63
XDP_OBS6_R: T14.1(TP-1) UC1.K60
XDP_OBS7_R: T15.1(TP-1) UC1.J61
XDP_RST#_R: JXDP1.46 RC106.2
XTAL24_IN: CC8.2 RC63.2 UC1.A25 YC2.3
XTAL24_OUT: RC63.1 RC65.1 UC1.B25
XTAL24_OUT_R: CC11.2 RC65.2 YC2.1
XTALI: CL14.2 RL11.2 UL1.10 YL1.1
XTALO: RL10.2 RL11.1 UL1.9
XTALO_R: CL13.2 RL10.1 YL1.3
Z2805: RL18.1 TL1.22
Z2806: RL16.1 TL1.16
Z2807: RL17.1 TL1.21
Z2808: RL15.1 TL1.15
N15115: T16.1(TP-1) UC1.AD4
N19253: T28.1(TP-1) UC1.AV63
N19255: T29.1(TP-1) UC1.AU63
N19263: T30.1(TP-1) UC1.C63
N19267: T31.1(TP-1) UC1.C62
N19275: T33.1(TP-1) UC1.A51
N19277: T34.1(TP-1) UC1.B51
N19281: T35.1(TP-1) UC1.L60
N21871: T74.1(TP-1) UC1.P60
N21873: T75.1(TP-1) UC1.P61
N21875: T76.1(TP-1) UC1.N59
N21877: T77.1(TP-1) UC1.N61
N29827: JDIMM1.197 RD15.2
N29829: JDIMM1.201 RD16.2
N33048: CD36.2 RD21.1
N33050: CD54.2 RD25.1
N33054: JDIMM2.197 RD28.1
N33058: JDIMM2.201 RD27.1
N40459: QV2.1 RV5.2
N42068: QV4.2 RV19.2
N43975: QN1.5 QN1.6 RN2.2
N46665: CA29.1 UA1.35
N46669: CA29.2 UA1.36
N46677: CA25.1 UA1.31
N46697: CA27.1 RA12.1
N46705: CA28.1 RA13.1
N46713: QA2.5 QA2.6 RA21.2
N46735: CA33.1 RA17.2
N70739: JDEG1.1 RE71.2
N70745: RE64.1 UE2.B61
N70747: CE34.1 RE66.2
N70757: RE57.1 RE58.1 UE2.A59
N73962: CZ45.1 UZ9.12
N73964: CZ46.1 UZ9.10
N75571: DZ3.2 DZ4.2 QZ3.1 RZ24.2
N75591: QZ4.1 RZ27.1
N75595: DZ3.1 QZ3.3
N75599: QZ9.1 RZ33.1
N525777: CZ42.1 UZ8.10
N588510: CZ41.1 UZ8.12
N5261056: QD1.3 RD10.1 RD11.1 RD12.1 RD13.1
N10757881: CD21.2 RD7.1
N15438178: PD702.1 PD704.1 PD705.1 PR708.1
N15438627: PC711.1 PR710.1 PR711.1 PU700.6
N15439163: PR714.2 PU700.5
N15439291: PC718.2 PR716.2 PU700.7
N15439295: PC719.2 PR718.2 PU700.8
N15439512: PR720.2 PR788.2 PU700.9
N15440461: PR717.2 PU700.10
N15441413: PR722.1 PU700.18
N15441884: PC729.1 PR723.1 PU700.17
N15442134: PC726.2 PC727.1 PR721.3 PU700.20
N15442185: PC727.2 PC728.1 PR721.2 PU700.19
N17156946: PC5.1 PQ4.4 PQ6.4 PR14.2 PR17.1 PR18.1
N17156948: PQ6.1 PQ6.2
N17639884: PC505.2 PR519.2 PU500.2
N17640254: PC506.1 PR523.1 PR535.1 PU500.25
N17640267: PC512.1 PR535.2
N17640270: PC506.2 PC512.2 PR521.1 PR523.2 PU500.26
N17645088: PL500.3 PR512.2
N17680637: PR536.2 PU500.8
N17680665: PR516.1 PR539.1 PU500.3
N18325201: CL16.1 TL1.3
N18325205: CL17.1 TL1.4
N18325209: CL20.1 TL1.9
N18325213: CL21.1 TL1.10
N18339814: DA5.1 RA25.2
N18339816: DA4.1 RA24.2
N18364501: RV50.1 UV7.20
N18366912: CV60.1 UV7.17
N18431888: DA2.2 JHP1.5 RA1.2
N18490882: RI14.2 UI3.16
N18609334: QV7.1 QV8.2 RV6.2
N18749305: JEDP1.21 LV1.1
N18754440: QA3.3 RA27.2
N18754442: QA3.6 RA28.2
N18779977: C319.1 R273.2
N18779979: C43.1 R41.2
N18779981: C42.1 R6.2
N19516037: CZ9.1 RZ35.1
N19544058: CC10.2 RC62.1
N19544059: CC9.2 RC61.1
N19638635: PR114.1 PU100.19
N19651849: CE9.1 RE27.2
N19651850: RE24.1 UE1.B19
N19891055: RV121.2 UV16.8
N20360585: CA49.2 UA1.34
N20361305: CA35.2 UA1.25
N20363962: CA51.1 RA44.1 UA1.21
N20363967: CA52.1 UA1.39
N20363972: CA53.1 UA1.7
N20571750: CZ23.1 UZ2.10
N20571754: CZ49.1 UZ2.12
N20572359: CZ37.1 UZ3.12
N20572446: CZ62.1 UZ3.10
N20576488: CZ64.1 UZ7.6
N20670193: RC2.2 SW1.2
N20711035: PC304.2 PR309.1
N20813044: PC809.2 PD813.1 PQ815.4 PQ826.4 PR818.1 PR822.1
N20813052: PC809.1 PQ815.1 PQ815.2 PQ815.3 PQ826.1 PQ826.2 PQ826.3 PR818.2
N20813067: PQ832.2 PR828.2
N20813069: PQ829.2 PQ832.1 PR830.2
N20813073: PD815.2 PQ829.1
N20813075: PQ829.3 PR830.1 PR895.2
N20813085: PC807.2 PQ810.4 PR811.1
N20813089: PQ813.5 PR853.2
N20826302: PC209.2 PR204.1 PU200.12
N20857922: PQ806.3 PR815.2 PR816.1
N20862119: PR518.2 PR524.1 PR525.1
N20935195: PR799.1 PU700.21
N20987678: PD817.1 PQ814.3 PR827.2
N20987955: PQ806.5 PQ806.6 PR813.2
N20988471: PQ817.6 PR819.1 PU806.1
N22492653: CN4.1 UN3.6
N23549436: RA45.1 UA1.22
N24544483: PD5.2 PD5.3 PL3.1 PQ2.1 PR7.1 PR10.2
N24606174: PC309.1 PU300.5
N25271873: QE4.2 RE70.2
N48705653: PQ2.3 PR7.2 PR9.1
N48705663: PQ3.2 PR10.1 PR12.2
N48705665: PQ2.2 PQ3.1 PR11.2 PR13.1
N48708367: PR210.2 PU200.7
N48708425: PR206.2 PU200.9
N48716673: PR838.1 PU800.28
N48716693: PR845.1 PU800.26
N49522072: PC700.2 PQ701.2 PQ702.2 PR702.2
N49522215: PQ703.1 PQ703.3 PR706.2 PR707.2 PR709.2
N49522242: PC702.2 PC703.1 PR705.2 PU700.1
N49522275: PC701.2 PC702.1 PR704.2 PU700.2
N49522729: PQ701.1 PR701.2
N49522731: PQ702.1 PR701.3
N49522780: PQ700.4 PR700.1
N61500733: PR513.1 PU500.4
N61500909: PC510.2 PR526.1 PU500.28
N61500999: PH501.2 PR515.1
N61501245: PC501.1 PH500.2 PR505.2 PU500.14
N61501462: PR511.2 PU500.16
N66971793: PR105.2 PU100.5
N66972075: PR106.2 PU100.1
N78957489: PQ816.1 PR822.2
N78967043: PQ816.2 PU806.4
N78985854: PR810.2 PR812.2 PU804.2
N79002827: PQ806.2 PU804.4
N79023703: PR863.1 PU800.19
N79030038: PQ813.2 PQ813.3 PR829.2
N79030087: PQ813.6 PR826.2
N79030091: PQ814.2 PR826.1 PR827.1
N79030745: PD813.2 PQ814.1
N79114795: PC4.1 PQ1.2 PR6.2
N79114801: PD4.2 PQ1.1
N80905978: PC402.1 PR400.2 PR401.1 PU400.8
N80906026: PC403.2 PR402.2 PR403.1 PU400.2

Pads without a net: DV6 3; FD1 1; FD2 1; FD3 1; FD4 1; JAPS1 16 17 18; JDIMM1 77 122 125 198 205 206; JDIMM2 77 122 125 198 205 206; JEDP1 16 20 32; JHDMI1 14; JKBTP1 6 13; JLED1 9; JNGFF1 9 36 38 40 50 52 54 56; JNGFF2 12 14 16 17 20 32 34 36 38 40 48 50 51 52 53 54 55 56 57 58 59 60; JSATA1 8 20; JSIM1 1 2 5; JSPI1 4; JUSH1 9 10; JXDP1 40 42; PBATT1 11 12; PD2 3; PJPDC1 10; PRP2 4 5; PU200 10; PU400 7; PU500 5; PU700 4; PU800 20 29 30 31 35 36; QL2 3 4 5; QZ11 3 4 5; RPC15 2 7; RPC19 3 6; RPE5 1 8; RPE6 4 5; UC1 A5 A21 A23 A35 A41 A43 A49 AA23 AA59 AB8 AB21 AB23 AC20 AC58 AC59 AD5 AD7 AD8 AD10 AD23 AD59 AD60 AE59 AE60 AF20 AG58 AH13 AL1 AL2 AL11 AL32 AM10 AM11 AN10 AP7 AP32 AT2 AU10 AU12 AU15 AU44 AV2 AV10 AV44 AV50 AV62 AW10 AW14 AW49 AY8 AY14 AY42 AY43 B21 B22 B23 B35 B41 B43 B49 C4 C21 C46 C47 D1 D15 D58 D61 E1 E6 E8 E13 E15 F6 F8 F22 G1 G10 H10 H18 H22 J2 J4 J13 J20 J21 J58 K4 K10 K18 K21 L3 L11 L59 M20 M21 N23 N58 N60 P20 R5 R20 R23 T23 T59 U10 U59 V21 V59 W23 Y20 Y22; UC8 1; UD1 1; UE1 A3 A5 A8 A9 A11 A12 A16 A23 A32 A42 A45 A46 A48 A49 A52 A55 A56 A57 A58 A59 A60 A61 A64 B1 B3 B4 B6 B7 B11 B13 B14 B16 B17 B18 B32 B39 B40 B45 B47 B49 B56 B57 B58 B60 B61 B63 B64 B65 B66; UE2 A15 B15 B16 B62; UI3 9 15; UI4 8 13 17; UL4 5; UN1 2 3; UN2 7; UR1 19 39 40 44 46; UV7 2 4 14 22 23 58; UV8 E10 H3 H11 K2 L2 L10 L11 L12 L13 M1 M2 M10 M11; UZ1 1 2 5 6 7 9 12 13 14 15 17 27 28; YC2 2 4

## Via types
v1: diameter 0.457, hole 0.203, TOP to BOTTOM, 5167 vias
v2: diameter 0.305, hole 0.152, TOP to BOTTOM, 742 vias
v3: diameter 0.508, hole 0.254, TOP to BOTTOM, 842 vias
v4: diameter 0.406, hole 0.203, TOP to BOTTOM, 123 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
0.675V_DDR_VTT_ON: length 167.1
  IN3 w0.254: v1(232.24,9.79) 231.11,9.79 227.94,6.62 227.94,4.23 226.83,3.13 163.55,3.13 161.35,5.32 156.77,5.32 154.98,3.53 141.68,3.53 140.63,4.59 v1(140.63,5.16)
  IN4 w0.254: v3(263.94,40.07) 263.94,40.08 262.57,41.46 260.64,41.46 259.88,42.22 254.72,42.22 254.11,42.83 242.06,42.83 239.75,40.52 237.17,40.52 236.64,39.99 236.64,29.85 238.05,28.44 238.05,23.51 240.71,20.85 240.71,17.71 240.54,17.54 240.54,13.11 239.69,12.26 234.71,12.26 v1(232.24,9.79)
  BOTTOM w0.254: PR210.1 v3(263.94,40.07)
  vias: v1(135.39,6.82) v1(135.39,6.24) v1(140.61,5.77) v2(133.52,4.64)
1.05V_LP_EN: length 10.3
  TOP w0.102: QV21.3 168.8,84.79 168.59,84.99 RV210.2 166.93,84.99 166.55,85.37 166.55,85.97 166.71,86.13 166.71,88.13 166.46,88.38 v2(165.47,88.38) CV374.1 164.23,88.38 QV20.3
1.05V_M_PWRGD: length 26.7
  TOP w0.102: RC27.1 191.97,49.42 v1(192.55,48.83) ; v1(213.51,43.73) 213.12,43.73 v2(212.66,43.27)
  TOP w0.254: PR313.1 v1(213.51,43.73)
  IN2 w0.122: v1(213.51,43.73) 213.38,43.86 196.63,43.86 194.16,46.33 194.16,47.23 v1(192.55,48.83)
1.05V_MODPHY_EN: length 6.3
  TOP w0.102: v2(174.99,83.78) RZ5.2
  TOP w0.254: QZ6.3 175.65,80.26 175.83,80.44 175.83,81.28 175.51,81.6 CZ25.1 RZ5.2 175.11,82.73 QZ10.3
1.05V_MP_PWROK: length 3.6
  TOP w0.102: v2(214.69,46.12) 215.11,45.7 v1(215.11,45.35)
  TOP w0.254: PR313.2 215.16,44.64 PR315.2 215.18,45.29 v1(215.11,45.35)
  BOTTOM w0.254: PU300.2 215.37,45.61 v1(215.11,45.35)
1.5VSP:
  vias: v2(226.73,52.77)
1.35V_B+: length 30
  IN1 w0.254: v3(263.94,35.12) 263.88,35.12 263.25,35.75 263.25,40.71 261.15,42.8 249.17,42.8 247.4,41.02 247.4,36.39 v3(247.08,36.07)
  BOTTOM w0.102: v2(264.71,35.37) 264.45,35.12 v3(263.94,35.12)
  BOTTOM w0.254: PR206.1 v3(263.94,35.12)
1.35V_FB: length 0.5
  BOTTOM w0.102: 261.56,42.29 v2(262.04,42.29)
3.3V_CAM_EN#: length 194.4
  TOP w0.254: RC174.1 183.91,49.65 183.86,49.6 v1(183.86,49.55) ; v1(97.96,99.16) 97.96,100.95 97.73,101.18 QZ1.2
  IN1 w0.254: v1(97.96,99.16) 98.44,99.16 99.73,97.87 100.6,97.87 103.09,95.38 109.13,95.38 110.45,96.7 117.82,96.7 119.6,98.48 125.15,98.48 128.32,101.65 131.79,101.65 v1(132.84,100.6)
  IN2 w0.254: v1(200.28,77.71) 200.55,77.45 200.55,65.26 200.28,65 200.28,64.57 203.52,61.34 203.52,58.38 202.58,57.44 202.58,55.35 201.4,54.17 194.37,54.17 191.45,51.25 v1(191.45,50.35)
  IN3 w0.254: v1(183.86,49.55) 183.58,49.82 183.58,51.04 183.28,51.34 177.44,51.34 176.53,50.42 v1(173.69,50.42) ; v1(200.28,77.71) 198.45,79.54 180.17,79.54 178.96,78.32 175.83,78.32 172.3,81.86 172.3,83.48 170.9,84.88 164.79,84.88 163.36,86.32 154.34,86.32 152.83,87.83 152.83,89.9 149.72,93 146.54,93 145.71,92.17 140.69,92.17 139.59,93.27 139.59,94.51 137.22,96.88 137.22,98.94 135.4,100.75 133,100.75 v1(132.84,100.6)
  BOTTOM w0.076: UC1.AM4 167.37,52.9 168.49,52.9 168.57,52.98 169.09,52.98 169.22,53.11 169.79,53.11 170.09,52.81 170.33,52.81 170.5,52.64
  BOTTOM w0.102: v1(183.86,49.55) 183.54,49.86 v2(183.54,50.24)
  BOTTOM w0.254: v1(183.86,49.55) 184.4,49 189.06,49 189.53,48.53 190.89,48.53 191.45,49.09 v1(191.45,50.35) ; 170.5,52.64 170.94,52.64 171.25,52.34 171.77,52.34 v1(173.69,50.42)
3.3V_HDD_EN: length 170.4
  TOP w0.102: UN3.3 303.94,54.75 RN6.2 RN7.1 302.93,54.82 302.11,53.99 302.11,51.82 v2(301.84,51.55) v1(301.84,49.82)
  IN1 w0.089: v1(301.84,49.82) 301.66,49.65 295.54,49.65 295.41,49.77 292.82,49.77 291.58,51.02 283.06,51.02 282.42,50.38 281.36,50.38 281.27,50.47 278.56,50.47 276.81,52.22 273.23,52.22 272.76,52.69 270.23,52.69 v1(269.98,52.95) ; v1(243.01,54.97) 242.86,54.82 238.58,54.82 236.47,52.7 236.47,49.3 235.26,48.1 233.68,48.1 229.24,43.65 226.91,43.65 225.06,41.8 207.52,41.8 201.13,48.19 201.13,52.53 200,53.66 200,56.43 197.43,59 195.43,59 191.06,63.38 189.05,63.38 186.91,65.52 v1(186.75,65.52)
  IN2 w0.122: v1(269.98,52.95) 268.26,51.23 260.82,51.23 258.2,53.86 255.48,53.86 255.03,54.31 252.1,54.31 251.8,54.02 244.04,54.02 243.09,54.97 v1(243.01,54.97)
  IN4 w0.086: v1(167.99,64.14) 169.21,65.36 171.77,65.36
  IN4 w0.089: 171.77,65.36 172.22,65.36 173.1,66.23 181.21,66.23 181.44,66.47 181.51,66.47 182.11,67.06 183.34,67.06 185.25,65.16 186.39,65.16 v1(186.75,65.52)
  BOTTOM w0.076: UC1.K2 168.33,64.48 v1(167.99,64.14)
3.3V_TP_EN: length 25.9
  IN4 w0.086: 171.77,65.64 169,65.64 168,64.63 167.21,64.63 166.92,64.35 v1(166.56,64.35)
  IN4 w0.089: 171.77,65.64 172.17,65.64 172.99,66.45 181.12,66.45 181.35,66.68 181.42,66.68 182.02,67.28 183.47,67.28 185.19,65.56 v1(186,65.56)
  BOTTOM w0.076: UC1.L5 166.35,64.13 v1(166.56,64.35)
  BOTTOM w0.102: RPC15.1 186.57,65.1 186.52,65.15 186.41,65.15 v1(186,65.56) 185.07,65.56 v2(184.21,66.41)
3.3V_TS_EN: length 132.1
  IN1 w0.254: v1(131.2,99.44) 130.64,100.01 127.27,100.01 125.36,98.1 119.82,98.1 117.96,96.23 111.93,96.23 v1(111.32,95.62)
  IN2 w0.254: v1(131.2,99.44) 131.69,98.96 135.89,98.96 136.27,98.58 136.27,92.56 137.05,91.78 137.05,89.62 138.4,88.26 142.03,88.26 144.16,86.13 144.16,82.57 145.66,81.07 145.66,80.47 145.97,80.15 146.78,80.15 147.07,80.43 147.07,81.1 147.87,81.9 149,81.9 149.84,81.05 149.84,79.22 149.75,79.13 149.75,77.3 152.31,74.74 154.08,74.74 154.56,74.26 156.93,74.26 157.11,74.08 164.07,74.08 166.4,76.41 167.56,76.41 168.13,76.97 170.84,76.97 171.32,76.49 171.32,74.5 171.08,74.26 171.08,69.71 169.34,67.97 169.34,66.35 166.86,63.87 165.77,63.87 165.32,63.42 v1(165.32,63.4)
  IN4 w0.086: v1(165.32,63.4) 165.85,63.93 167.46,63.93 167.62,63.78 168.48,63.78 169.1,64.39 171.77,64.39
  IN4 w0.089: 171.77,64.39 173.63,64.39 175.22,65.98 177.81,65.98 178.5,65.29 178.83,65.29 179.52,65.98 181.26,65.98 181.53,66.25 183.51,66.25 186.83,62.93 v1(186.83,62.56)
  BOTTOM w0.076: v1(165.32,63.4) 165.05,63.13 UC1.N7
  BOTTOM w0.102: v1(186.83,62.56) 186.85,62.54 RPC18.8
  BOTTOM w0.254: QV7.2 v2(110.57,96.37) v1(111.32,95.62)
3.3V_WWAN_EN: length 22.5
  TOP w0.102: v1(253.79,75.52) 253.92,75.39 UE1.B42 ; v2(268.52,71.06) 268.59,71.06 v1(268.99,71.47) ; v1(268.99,71.47) 269.48,70.98 RZ40.2 ; v1(268.99,71.47) 269,71.47 268.5,71.96 268.5,72.31 268.37,72.44 UZ2.3
  IN2 w0.122: v1(253.79,75.52) 255.35,73.96 255.35,73.45 256.1,72.7 261.39,72.7 262.2,73.51 267.49,73.51 268.58,72.42 268.58,71.88 269,71.47 v1(268.99,71.47)
+0.9V_LAN: length 11.8
  TOP w0.102: v4(266.99,84.9) 267.37,85.28 267.37,85.66
  TOP w0.203: UL1.22 280.08,81.86 280.12,81.82 280.12,81.81 v1(280.1,81.81) ; UL1.40 v1(279.68,89.95) ; UL1.16 277.68,82 277.53,81.85 v1(277.53,81.73) ; v1(278.51,89.83) 278.48,89.79 UL1.43 ; UL1.37 v1(280.88,89.94) ; v1(274.82,83.81) 274.88,83.81 275.19,84.12 UL1.11 ; UL1.8 274.8,85.32 v1(274.73,85.24)
  BOTTOM w0.508: v1(278.51,89.83) 278.51,89.46 278.42,89.37 CL8.1 ; CL11.1 277.66,81.98 277.53,81.85 v1(277.53,81.73) ; CL9.1 280.71,89.78 v1(280.88,89.94) ; v1(274.73,85.24) 275.26,85.24 CL10.1
  vias: v1(270.59,85.55) v1(270.6,84.97) v1(276.2,90.46) v1(276.56,89.93)
+0.675V_DDR_VTT: length 56.1
  TOP w0.102: v3(253.02,41.6) v4(252.26,41.6)
  IN4 w2.032: 251.27,41.48 242.61,41.48 240.39,39.26 240.39,35.37 240,34.99 240,24.89 243.12,21.78 243.12,18.18 242.43,17.49 242.43,11.74 241.48,10.78 235.8,10.78 234.3,9.29 234.3,8.68 232.11,6.48 232.11,5.3 231.9,5.1
  vias: v1(152.34,9.77) v1(152.97,9.76) v1(153.56,9.72) v1(154.01,5.08) v1(154,4.49) v1(154.15,9.71) v1(154.6,5.08) v1(154.61,4.49) v1(229.45,5.39) v1(229.45,4.78) v1(230.06,5.39) v1(230.06,4.78) v3(253.02,40.96) v3(253.66,41.6) v3(253.66,40.96)
+0.675V_P: length 0.7
  TOP w0.102: v1(256.58,39.82) v4(256.07,40.33)
+1.2V_LDO: length 19.2
  TOP w0.203: UR1.31 313.63,64.02 313.89,63.76 314.84,63.76 315.03,63.95 CR19.2 ; UR1.36 313.08,66.02 313.21,66.15 313.21,66.84 313.56,67.19 CR22.2 ; UR1.28 313.24,62.82 314.17,61.89 314.29,61.89 v1(314.32,61.93) ; 304.85,62.04 305.64,62.04 305.8,62.2 ; UR1.41 310.26,67.34 310.88,67.96 310.88,68.9 CR10.2
  TOP w0.254: 305.8,62.2 306.02,62.42 UR1.10
  TOP w0.508: v1(314.79,67.19) CR22.2 ; CR19.2 CR21.2 v1(315.05,65.46) ; CR13.2 304.85,62.04 v1(305.31,62.5)
  IN2 w0.508: v1(305.31,62.5) 306.57,63.76 v1(306.57,66.7)
  vias: v1(306.59,67.33) v1(313.08,69.04) v1(313.69,69.04) v4(305.6,68.14)
+1.05V_M: length 73.8
  TOP w0.076: v1(164.61,55.8) 164.89,56.08 164.89,56.96 166.17,58.24 166.9,58.24 167.83,59.17 168.81,59.17 169.71,60.07 171.37,60.07 RC300.1
  TOP w0.102: v3(197.08,46.36) 197.08,45.72 v4(197.02,45.66)
  TOP w0.508: v1(162.99,56.49) 162.99,56.43 163.06,56.37 163.06,55.98 162.76,55.69 CC61.1 ; RC15.2 119.18,54.42 v1(119.1,54.5) ; v1(160.46,57.64) 160.19,57.64 159.64,57.09 CC62.1
  IN2 w0.508: v1(116,54.42) 116,56.44 v1(115.99,56.45)
  IN3 w0.508: v1(160.46,57.64) 159.39,58.71 158.14,58.71 157.02,57.6 156.54,57.6 155.71,56.76 136.75,56.76 135.04,55.05 132.82,55.05 132.64,54.87 119.47,54.87 v1(119.1,54.5) 119.1,53.01 118.67,52.58 117.11,52.58 116.79,52.9 116.79,53.63 v1(116,54.42)
  BOTTOM w0.203: UC1.AG13 161.71,56.91 161.48,57.14 160.96,57.14 v1(160.46,57.64) ; v1(160.71,56.53) 160.71,56.32 160.89,56.14 UC1.AG14
  BOTTOM w0.254: UC1.AF9 v1(164.61,55.8) 164.61,55.54 UC1.AG8 ; v1(162.99,56.49) 163.11,56.49 163.37,56.75 UC1.AE9
  BOTTOM w0.508: RC16.2 RC18.2 v1(115.99,56.45) ; RC14.2 v1(116,54.42)
  vias: v1(174.66,75.75) v1(174.85,76.3) v1(174.97,75.23) v1(175.28,75.72) v1(175.49,76.58) v1(175.78,76.03) v1(176.01,77.05) v1(176.22,76.49) v1(176.32,77.65) v1(176.78,76.74) v1(176.82,77.35) v1(177.17,77.82) v3(196.15,48.29) v3(196.15,47.65) v3(196.16,46.93) v3(196.79,48.29) v3(196.79,47.65) v3(196.8,46.93) v3(197.42,48.29) v3(197.42,47.65) v3(197.43,46.93) v3(197.71,46.36) v3(198.06,48.29) v3(198.06,47.65) v3(198.07,46.93)
+1.05V_MODPHY:
  vias: v4(167.14,81.57)
+1.05V_MODPHY_PCH: length 1.9
  BOTTOM w0.254: UC1.K9 163.95,64.34 UC1.L10 ; v1(163.25,63.4) 163.25,63.63 UC1.L10 ; UC1.M9 163.95,63.45 UC1.L10
  vias: v1(160.81,62.32) v1(161.06,61.79) v1(161.99,63.02) v1(169.13,76.06) v1(169.14,75.43) v1(169.74,76.37) v1(169.75,75.78) v2(168.57,75.5)
+1.05V_MP: length 21.6
  TOP w0.102: v3(205.08,50.1) 205.14,50.04 v2(205.14,49.47)
  IN1 w0.254: v3(217.27,42.8) 216.83,42.36 207.61,42.36 203.94,46.03 v3(203.94,50.23)
  BOTTOM w0.254: v3(217.27,42.8) 217.26,42.81 PR307.1 PC304.1
  vias: v3(203.3,50.23) v3(205.71,50.1)
+1.5V_RUN: length 409.8
  TOP w0.102: v1(219.14,36.69) v4(217.92,36.69)
  TOP w0.508: RA3.1 23.15,86.96 23.08,86.88 23.05,86.88 v1(22.95,86.78) ; v1(228,25.24) 228.23,25.47 228.23,30.7 226.29,32.64 221.89,32.64 219.14,35.4 v1(219.14,36.69)
  IN1 w0.508: v1(83.54,31.19) 83.3,31.19 82.83,31.66 82.83,32.39 83.74,33.3 83.74,49.49 82.49,50.75 82.49,55.36 79.34,58.51 79.34,60.82 73.53,66.63 73.53,72.88 71.96,74.44 63.9,74.44 63.2,75.15 61.43,75.15 59.65,76.93 56.93,76.93 54.91,78.95 40.01,78.95 39.71,79.25 39.71,79.26 37.76,81.22 37.27,81.22 v1(31.6,86.9)
  IN2 w0.508: v1(228,25.24) 226.86,26.38 224.24,26.38 220.15,22.29 200.39,22.29 196.84,25.85 165.98,25.85 151.5,40.33 151.5,49.33 150.66,50.17 150.66,54.22 149.94,54.94 149.94,60.56 153.27,63.89 159.09,63.89 160.19,64.99 v1(160.19,65.37)
  IN3 w0.508: v1(22.95,86.78) 22.95,86.58 23.63,85.89 30.59,85.89 v1(31.6,86.9)
  IN4 w0.508: v1(83.54,31.19) 83.59,31.24 89.66,31.24 90.97,29.94 v1(91.95,29.94)
  BOTTOM w0.254: v1(160.19,65.37) 160.54,65.01 UC1.J15
  BOTTOM w0.508: v1(91.95,29.94) 93.93,29.94 94.44,30.44 99.48,30.44 100.22,31.18 103.86,31.18 105.23,29.81 108.74,29.81 111.1,32.17 176.14,32.17 179.57,35.6 183.73,35.6 184.67,36.54 186.04,36.54 187.19,37.68 190.23,37.68 192.61,35.31 192.61,32.83 193.42,32.02 195.21,32.02 198.16,34.97 208.31,34.97 208.99,34.28 212.64,34.28 213.13,34.78 213.13,36.16 214.08,37.11 218.72,37.11 v1(219.14,36.69) 219.23,36.6 222.35,36.6 223.56,37.81 223.56,40.69 226.15,43.28 226.15,46.42 226.59,46.87 226.59,49.37 226.58,49.38
+1.05V_RUN: length 519.9
  TOP w0.254: v1(157.82,92.86) 158.15,93.18 UV8.J3 ; 172.11,62.66 169.49,62.66 169.04,63.12 167.18,63.12 167,62.95 166.48,62.95 166.47,62.95 165.04,62.95 164.72,63.27 v1(164.72,63.4) 164.87,63.55 164.87,63.76 164.97,63.86 167.44,63.86 167.64,63.65 171.97,63.65 CC85.1 ; UV8.E5 159.45,95.78 v1(159.13,96.11)
  TOP w0.305: JXDP1.44 102.5,26.03 CC18.1 ; v1(96.2,26.84) 96.15,26.84 95.34,26.03 JXDP1.43 90.61,26.03 CC19.1
  TOP w0.508: RC124.1 RC125.1 115.61,64.58 v1(115.35,64.33) ; v1(156.92,61.58) 157.07,61.74 CC71.1 ; v1(247.19,67.49) 247.19,69.34 v1(247.47,69.62) 247.9,69.62 248.37,69.15 RE70.1 ; CC72.1 159.33,55.9 159.68,55.55 v1(159.68,55.12) ; v1(104.53,23.33) 104.38,23.18 RC117.1 ; v1(162.98,57.09) 162.53,57.09 162.29,56.85 CC58.1 ; v1(157.92,38.33) 158.4,38.33 163.07,33.67 163.07,32.73 161.9,31.56 CC94.1 ; CC85.1 172.31,62.87 172.11,62.66 ; v1(247.61,54.89) 247.61,54.68 248.63,53.66 RE59.2 ; v1(101.55,27.43) 101.84,27.43 102.7,26.57 CC18.1 ; CC53.1 162.83,62.22 162.98,62.22 164.16,63.4 v1(164.72,63.4)
  IN1 w0.508: v1(115.35,64.33) 116.71,64.33 117.08,63.96 117.08,62.83 116.8,62.55 v1(116.04,62.55) ; v1(115.35,64.33) 115.01,64.33 113.63,62.94 v1(113.63,60.47) ; v1(115.35,64.33) 115.35,66.06 116.18,66.88 120.43,66.88 124.1,70.55 124.1,72.42 125.27,73.59 128.92,73.59 v3(129.04,73.46) ; v1(159.68,55.12) 159.68,55.18 159.22,55.64 157.81,55.64 157.16,54.99 156.57,54.99 155.9,55.66 155.9,55.69 154.72,56.87 154.72,66.36 153.84,67.25 153.84,69.41 155.11,70.68 155.11,73.09 154.72,73.47 154.72,74.23 156.12,75.63 157.01,75.63 v1(157.39,76.01)
  IN2 w0.508: 186.98,79.47 193.6,79.47 199.33,85.19 213.4,85.19 214.66,83.93 223.98,83.93 233.34,74.58 233.34,72.09 234.8,70.63 237.67,70.63 239.32,68.98 245.35,68.98 246,69.62 v1(247.47,69.62) ; v1(149.26,74.02) 149.07,74.02 147.23,75.86 145.2,75.86 143.6,74.26 143.6,71.72 141.85,69.97 134,69.97 130.51,73.46 v3(129.04,73.46)
  IN3 w0.254: v1(156.92,61.58) 157.28,61.94 157.28,64.61 156.54,65.34 ; 163.54,68.33 163.54,67.51 163.52,67.49 163.52,67.12 163.54,67.1 163.54,65.12 163.84,64.82 163.87,64.82 164.26,64.43 164.26,64.16 164.72,63.7 v1(164.72,63.4) ; 158.24,49.93 158.24,53.91 158.09,54.07 158.09,54.32 156.88,55.53 v1(156.88,55.77) ; v1(159.27,65.27) 158.8,65.73 158.8,68.1 158.86,68.16
  IN3 w0.381: v1(157.82,92.86) 157.68,92.86 157.21,93.32 157.21,94.33 157.68,94.8 158.62,94.8 159.13,95.3 v1(159.13,96.11)
  IN3 w0.508: 163.54,68.33 163.54,69.2 164.53,70.2 164.53,70.73 165.15,71.35 165.15,72.05 165.1,72.1 165.1,72.26 164.77,72.6 164.76,72.6 164.76,73.31 164.53,73.55 164.53,75.92 166.28,77.68 167.08,77.68 168.59,79.19 168.59,79.92 166.54,81.98 165.7,81.98 165.43,82.25 v1(165.27,82.25) ; 158.86,68.16 158.86,68.92 158.22,69.56 157.9,69.56 157.07,70.39 157.07,75.25 155.38,76.94 155.37,76.94 v1(155.01,77.3) ; v1(157.92,38.33) 157.11,39.15 157.11,46.46 156.69,46.88 156.69,47.22 156.48,47.43 156.48,48.96 157.15,49.63 157.95,49.63 158.24,49.93 ; v1(247.19,67.49) 244.68,67.49 240.75,63.57 240.75,61.61 240.07,60.92 240.07,56.04 238.56,54.53 238.56,51.23 237.89,50.57 237.89,48.22 237.62,47.95 237.62,47.06 236,45.44 230.22,45.44 229.92,45.74 229.03,45.74 223.18,39.88 211.43,39.88 210.45,38.9 207.17,38.9 197.57,29.3 119.55,29.3 119,28.76 103.26,28.76 101.94,27.43 v1(101.55,27.43) ; 156.54,65.34 155.55,66.34 155.55,67.92 155.74,68.11 155.74,71.31 154.78,72.27 154.78,76.53 153.99,77.31 153.99,77.63 152.29,79.34 v1(151.5,79.34)
  IN4 w0.508: v1(247.19,67.49) 247.51,67.17 247.51,64.62 246.46,63.56 246.46,56.26 247.61,55.11 v1(247.61,54.89) ; v1(104.53,23.33) 104.38,23.18 101.32,23.18 101,23.5 101,26.89 v1(101.55,27.43)
  BOTTOM w0.254: UC1.T21 157.3,61.21 v1(156.92,61.58) 157.3,61.96 UC1.R21 ; UC1.P9 163.95,62.5 UC1.N8 164.4,63.07 v1(164.72,63.4) ; UC1.AF22 156.75,55.9 v1(156.88,55.77) ; v1(160.19,65.95) 160.39,65.95 160.67,65.67 UC1.H15 ; UC1.J17 159.52,65.01 v1(159.27,65.27) ; UC1.AG17 159.3,55.44 159.63,55.12 v1(159.68,55.12) 160,55.44 UC1.AG16 ; v1(162.08,65.45) 162.17,65.45 162.57,65.04 UC1.J11 ; v1(162.09,66.07) 162.13,66.03 162.27,66.03 162.57,65.73 UC1.H11 ; UC1.AE8 164.4,56.35 164.49,56.44 v1(164.49,56.75)
  BOTTOM w0.381: 157.16,90.81 157.16,92.55 157.47,92.86 v1(157.82,92.86)
  BOTTOM w0.508: v1(96.2,26.84) 97.03,26.84 97.09,26.9 101.02,26.9 v1(101.55,27.43) ; v1(116.04,62.55) 116.1,62.55 116.67,61.98 RC197.1 ; 157.84,87.49 157.39,87.94 157.39,90.58 157.16,90.81 ; 151.32,76.88 151.32,74.96 150.25,73.89 149.39,73.89 v1(149.26,74.02) ; RC196.2 129.13,73.55 v3(129.04,73.46) ; RC127.1 RC126.1 v1(113.63,60.47)
  vias: v1(150.8,78.59) v1(150.85,79.19) v1(150.85,77.66) v1(151.3,78.04) v1(151.36,78.74) v1(156.77,62.75) v1(165.43,85.47) v1(166.01,85.49) v1(185.31,78.41) v1(185.31,77.78) v1(185.94,78.41) v1(185.94,77.78) v1(186.58,78.41) v1(186.58,77.78) v1(187.21,78.41) v1(187.21,77.78) v4(153.07,79.95)
+1.5V_RUN_AUDIO:
  vias: v2(24.8,90.11)
+1.05V_RUN_UZ7: length 1
  TOP w0.102: v2(180,81.6) 179.95,81.56 UZ7.8
+1.05V_RUN_VMM: length 14.7
  TOP w0.508: QV20.4 164.23,84.7 163.81,85.12 157.78,85.12 157.4,85.5 v1(157.4,85.79)
  IN4 w0.508: v1(157.4,85.79) 157.4,84.96 156.63,84.19 155.19,84.19 153.95,82.95 v1(153.95,81.35)
  vias: v4(152.95,81.73)
+1.05V_VCCST: length 100.1
  TOP w0.508: RC114.1 v1(119.09,61.53) ; 154.11,38.93 154.1,38.92 154.1,35.11 155.93,33.28 v4(156.96,33.28) 162.28,33.28 v1(162.41,33.4) ; RC25.1 119.24,63.57 v1(119.1,63.71) ; v1(112.85,64.1) 113.39,63.57 RC116.1 ; RC204.1 v1(119.1,57.47) ; RC202.2 165.65,40.05 166.54,39.16 166.54,37.49 v1(166.38,37.34) ; RC208.1 119.67,59.45 v1(119.09,59.45)
  IN1 w0.508: v1(123.28,50.9) 122.96,51.22 122.96,52.52 125.17,54.73 130.43,54.73 130.75,55.05 134.87,55.05 135.64,55.81 154.03,55.81 154.47,55.37 v1(154.47,55.32)
  IN2 w0.508: v1(123.28,50.9) 122.47,51.72 122.47,53.28 121.04,54.7 121.04,55.57 119.14,57.47 v1(119.1,57.47) ; v1(162.41,33.4) 166.34,37.34 v1(166.38,37.34) ; v3(102.91,64.46) v3(100.88,64.46)
  IN3 w0.508: 117.54,64.73 117.54,65.36 117.06,65.84 115.18,65.84 113.94,64.61 113.36,64.61 v1(112.85,64.1) 111.32,62.56 106.23,62.56 105.9,62.23 104.66,62.23 102.91,63.99 v3(102.91,64.46)
  IN4 w0.508: v1(119.09,59.45) 119.49,59.45 119.63,59.59 119.63,61.32 119.42,61.53 v1(119.09,61.53)
  BOTTOM w0.254: UC1.AC22 156.38,57.43 v1(156.78,57.03) 156.47,56.71 UC1.AE22 155.97,56.31 UC1.AE23 155.06,56.31 154.47,55.72 v1(154.47,55.32)
  BOTTOM w0.508: v1(112.85,64.1) 113.33,64.58 RC199.1 ; v3(102.91,64.46) PR527.1 PR528.1 ; v3(100.88,64.46) PR529.1 PC511.1
+1.5V_VIN:
  vias: v2(227.5,56.07)
+1.05V_VMM_VDD: length 12.8
  TOP w0.203: UV8.E3 158.15,95.78 v1(157.83,96.11) 158.15,96.43 UV8.D3 ; UV8.E6 160.1,95.78 v1(159.78,96.11) ; v1(161.72,96.11) 161.4,95.78 UV8.E8 ; v1(164.32,95.46) 164,95.13 UV8.F12 ; UV8.H9 v1(162.37,93.51) ; UV8.H7 v1(160.43,93.51) ; UV8.G3 v1(157.83,94.16) ; v1(162.37,96.11) 162.05,95.78 UV8.E9 ; UV8.H8 v1(161.72,93.51) ; UV8.H6 v1(159.78,93.51) ; v1(160.43,96.11) 160.75,95.78 UV8.E7 ; v1(161.72,97.41) UV8.C8 ; UV8.G12 v1(164.32,94.16) ; v1(162.37,97.41) UV8.C9
  TOP w0.508: v1(151.59,98.68) 151.43,98.68 151.12,98.36 CV83.1
  BOTTOM w0.381: v1(160.43,94.81) 159.63,94.81 159.4,95.04 CV84.1 ; CV88.1 161,93.08 160.57,93.51 v1(160.43,93.51) ; CV86.1 160.93,95.75 160.58,96.11 v1(160.43,96.11)
  BOTTOM w0.508: v1(164.32,94.16) 164.33,94.16 CV89.1 ; CV85.1 161.71,98.3 162.37,97.64 v1(162.37,97.41)
  vias: v1(155.08,85.77) v1(155.7,85.79) v2(153.58,85.66)
+1.05V_VMM_VDDTX: length 5.9
  TOP w0.203: v1(157.83,95.46) 158.15,95.13 UV8.F3 ; UV8.J2 157.5,93.18 v1(157.83,93.51) ; UV8.D12 v1(163.68,96.11) 164,95.79 UV8.E12 ; UV8.C7 v1(160.43,97.41) 160.1,97.08 UV8.C6
  TOP w0.254: UV8.K10 v1(163.02,92.21) ; UV8.J10 v1(163.02,92.86) ; UV8.K9 v1(162.37,92.21) ; UV8.K8 v1(161.72,92.21)
  BOTTOM w0.508: CV92.1 163,92.19 v1(163.02,92.21) ; v1(161.72,92.21) 161.08,92.21 CV93.1
  vias: v1(151.99,85.88) v1(152.6,85.88) v1(157.83,96.76) v2(157.14,93.54)
+1.8V_RUN_CARD: length 24
  TOP w0.102: CR34.1 312.97,58.33 312.31,57.67 v2(312.31,55.95)
  IN4 w1.016: 314.4,59.02 316.34,57.08 316.34,47.54 318.67,45.21 323.6,45.21 323.91,45.53
  vias: v1(312.7,59.38) v1(313.28,59.39) v1(324.04,45.96) v1(324.69,45.98)
+1.35V_MEM: length 143.5
  TOP w0.102: RD4.1 89.95,10.56 88.72,9.32 v1(87.97,9.32)
  TOP w0.508: 159.55,12.63 159.55,9.45 160.19,8.82 162.43,8.82 163.02,9.4 163.02,10.62 RD22.1 ; v1(197.08,1.73) 197.14,1.79 CD41.1 ; CD43.1 193.59,1.83 v1(193.49,1.73) ; CD51.1 204.13,2.29 v1(204.13,1.69) ; CD44.1 191.55,1.86 v1(191.68,1.73) ; CD48.1 189.78,1.84 v1(189.89,1.73) ; CD47.1 195.11,1.9 v1(195.29,1.73) ; v1(198.89,1.71) 198.67,1.92 CD45.1 ; v1(200.69,1.73) 200.69,2.4 CD52.1 ; RD2.1 99.86,4.51 v1(99.5,4.87) ; 130.66,7.93 130.64,7.91 130.64,5.16 130.37,4.88 129.14,4.88 128.07,3.81 CD17.1 ; 208.2,11.41 209.59,10.02 RD18.1
  IN2 w0.508: v1(202.48,1.73) 202.48,1.89 201.93,2.44 201.4,2.44 v1(200.69,1.73)
  IN4 w0.508: v1(110.96,3.95) 100.55,3.95 99.63,4.87 v1(99.5,4.87) 99.33,4.87 98.53,4.07 89.29,4.07 88.58,4.78 88.58,8.71 v1(87.97,9.32)
  BOTTOM w0.203: UC1.AP43 142.92,51.37 v1(142.6,51.04) ; UC1.AR48 140.06,50.72 v1(139.74,50.39) ; v1(148.56,46.61) 148.13,47.03 UC1.AY35 ; v1(145.4,46.61) 144.99,47.03 UC1.AY40
  BOTTOM w0.254: v1(146.61,55.18) 146.61,55.18 UC1.AJ37 ; v1(139.1,47.24) 138.73,47.61 UC1.AY50 ; UC1.AJ31 v1(150.51,55.18) ; v1(142.26,46.6) 141.84,47.03 UC1.AY44 ; v1(148.82,51.72) 149.12,52.02 UC1.AN33 ; UC1.AJ33 v1(149.21,55.18) ; v1(153.11,55.18) 153.25,55.04 153.66,55.04 UC1.AH26
  BOTTOM w0.356: JDIMM1.100 121.06,1.67 v1(121.08,1.64) ; v1(115.68,1.64) 115.66,1.67 JDIMM1.82 ; JDIMM2.124 204.26,1.82 v1(204.13,1.69) ; JDIMM1.88 117.46,1.67 v1(117.49,1.64) ; v1(114.5,13.36) 115.36,12.51 JDIMM1.81 ; v1(203.9,13.67) 203.82,13.59 202.98,13.59 202.16,12.77 JDIMM2.117 ; v1(116.17,15.18) 118.96,12.39 JDIMM1.93 ; JDIMM2.106 198.86,1.73 v1(198.89,1.71) ; JDIMM1.117 126.16,12.58 v1(126.02,12.72) ; v1(195.29,1.73) 195.26,1.75 JDIMM2.94 ; JDIMM1.99 120.76,12.61 120.5,12.87 v1(120.05,12.87) ; JDIMM2.100 197.06,1.75 v1(197.08,1.73) ; JDIMM1.124 128.26,2.21 127.74,1.69 ; v1(193.49,1.73) 193.46,1.75 JDIMM2.88 ; JDIMM2.111 200.36,12.58 200.58,12.81 v1(201.01,12.81) ; JDIMM1.75 113.56,12.55 v1(113.95,12.94) ; v1(114.38,1.6) 114.34,1.64 114.02,1.64 113.86,1.8 JDIMM1.76 ; v1(197.85,12.91) 198.13,12.91 198.56,12.48 JDIMM2.105 ; v1(193.41,13.03) 193.16,12.78 JDIMM2.87 ; v1(200.69,1.73) 200.66,1.75 JDIMM2.112 ; v1(122.59,12.87) 122.56,12.84 JDIMM1.105 ; JDIMM2.81 191.36,13.19 191.95,13.78 192.63,13.78 v1(192.91,14.06) ; v1(191.68,1.73) 191.66,1.75 JDIMM2.82 ; v1(202.48,1.73) 202.46,1.75 JDIMM2.118 ; JDIMM2.76 189.86,1.75 v1(189.89,1.73) ; JDIMM2.99 196.76,12.74 v1(196.95,12.93) ; JDIMM1.112 124.66,1.67 v1(124.68,1.64) ; JDIMM1.118 126.46,1.67 126.48,1.64 ; JDIMM2.123 203.96,12.26 v1(203.28,12.94) ; JDIMM1.87 117.16,12.88 v1(116.81,13.22) ; v1(119.28,1.64) 119.26,1.67 JDIMM1.94 ; JDIMM1.106 122.86,1.67 v1(122.89,1.64) ; JDIMM1.111 124.36,12.33 123.25,13.44 v1(123.05,13.44) ; JDIMM1.123 127.96,12.79 128.18,13.01 128.18,13.91 v1(128.31,14.04) ; JDIMM2.75 189.56,12.63 189.27,12.92 188.15,12.92 v1(187.74,12.51) ; JDIMM2.93 194.96,12.26 v1(195.67,12.97)
  vias: v1(115.7,14.66) v1(116.67,15.65) v1(117.16,16.16) v1(199.9,17.36) v1(200.37,16.94) v1(200.83,16.53) v1(201.35,16.11) v1(224.76,24.83) v1(224.7,24.01) v1(224.7,23.24) v1(224.7,22.35) v1(224.7,21.47) v1(225.53,25.28) v1(225.53,24.45) v1(225.53,23.69) v1(225.53,22.86) v1(225.53,21.97) v1(226.29,24.77) v1(226.29,24.01) v1(226.29,23.18) v1(226.29,22.42) v1(226.29,21.66) v4(143.42,40.33)
+1.35V_MEN_P: length 55.5
  IN2 w0.254: v3(260.2,38.61) 261.35,39.77 261.35,41.52 260.34,42.53 246.43,42.53 245.41,41.52 245.41,39.58 243.37,37.53 v3(243.37,37.45) ; v1(244.13,37.4) 244.13,37.54 245.87,39.28 245.87,41.35 246.66,42.14 260.07,42.14 260.91,41.3 260.91,40.07 260.59,39.75 260.2,39.75 v3(260.15,39.7)
  IN2 w1.016: 253.21,39.5 248.41,39.5 247.13,38.22 247.13,38.19 246.24,37.3
  vias: v2(239.56,33.98) v3(245.88,36.46) v3(245.91,35.78) v3(254.48,39.63) v3(255.12,39.63)
+3.3V_ALW: length 506.5
  TOP w0.102: v4(221.4,78.04) 221.46,78.11 v3(222.1,78.11)
  TOP w0.254: RPE6.8 247.47,56.97 247.09,57.36 v1(247.09,57.76) ; 253.98,49.35 254.03,49.39 RPE3.8 ; 253.98,49.35 253.94,49.35 253.53,49.76 RPE3.7 ; 253.98,49.35 v1(253.98,49.32) ; 249.69,89.36 249.34,89.01 RPE4.7 ; 249.69,89.36 249.17,89.36 248.84,89.03 RPE4.8 ; 249.69,89.36 v1(249.96,89.36) ; v1(298.28,40.13) 297.69,40.13 297.08,40.74 JLED1.8 ; RPE9.6 252.9,69.55 v1(252.68,69.33) 252.4,69.61 RPE9.5 ; RPE6.7 247.87,57.47 247.69,57.66 v1(247.69,57.77) 247.69,57.79 247.87,57.97 RPE6.6 ; RPE9.7 253.4,69.5 253.64,69.26 v1(253.64,69.32) 253.64,69.37 253.9,69.62 RPE9.8 ; RE79.1 269.63,58.64 268.26,58.64 268.16,58.74 RPE5.7
  TOP w0.305: CZ28.1 236.05,30.2 234.52,31.74 JKBTP1.11
  TOP w0.381: UZ11.5 284.05,48.18 284.28,47.96 v1(284.28,47.34) ; 168.08,37.86 168.08,38.45 166.45,40.08 166.45,40.31 166.7,40.56 UC8.5 ; UZ6.5 246.32,51.68 CZ34.1
  TOP w0.406: UZ10.5 297.56,45.15 297.91,45.15 298.32,45.56 CZ48.1
  TOP w0.508: RE25.1 v1(263.88,73.98) ; RC217.1 v1(178.85,39.3) 178.9,39.25 178.9,34.76 ; v1(84.77,53.81) 86.25,52.34 v1(87.27,52.34) 87.43,52.49 94.59,52.49 95.71,51.37 106.48,51.37 108.86,53.76 v3(108.86,53.8) ; RE81.1 264.71,50.29 v1(265.4,49.6) ; PR2.1 78.47,4.03 79.34,3.16 v1(82.93,3.16) ; v1(244.27,74.92) 244.58,74.62 RE5.1 ; RZ22.1 243.17,56.56 243.23,56.62 v1(243.23,56.64) 243.23,57.5 243.66,57.93 244.69,57.93 244.74,57.98 RE63.1 ; RE69.1 v1(251.45,68.34) ; v1(213.27,32.5) 212.37,33.4 v1(212.37,34.98) 214.9,37.51 219.57,37.51 219.92,37.16 219.92,35.52 222.03,33.4 226.61,33.4 229.01,31 229.01,25.92 v1(229.08,25.85) ; RE84.2 v1(263.64,81.96) ; v1(255.89,47.08) 255.89,47.11 255.56,47.44 RE37.1 RE43.1 ; CZ48.1 298.84,46.01 v1(298.65,46.21) ; PR315.1 v3(215.18,42.87) ; CZ34.1 248.01,51.68 v1(248.37,52.05) ; PR107.2 v3(221.81,68.34) ; v1(264.29,77.61) 264.29,77.78 264.02,78.04 RE10.1 RE9.1 ; CZ28.1 235.7,30.04 235.2,29.54 v1(235.2,29.12) ; RE68.1 v1(263.69,66.55) ; 178.9,34.76 180.3,33.37 184.21,33.37 184.38,33.53 ; 178.9,34.76 168.11,34.76 167.53,35.35 167.53,37.3 168.08,37.86 CC35.1 ; RE11.1 v1(252.21,87.9) ; RE12.1 v1(249.97,69.87) ; v1(253.78,90.67) 253.77,90.67 253.5,90.95 RZ24.1 ; v1(270.9,58.87) 270.52,59.25 RE79.1 ; RE83.1 v1(264.25,76.01) ; RE276.1 v1(259.25,88.03) RE8.1 ; RE35.1 v1(248.34,62.8) ; PR895.1 v3(50.41,89.74)
  IN1 w0.508: v3(44.01,84.39) 45.35,85.74 45.35,88.62 47.18,90.45 49.7,90.45 v3(50.41,89.74) 50.63,89.51 50.63,86.06 53.38,83.31 59.45,83.31 61.4,81.36 v1(67.35,81.36) ; v1(70.15,77.74) 70.15,77.9 70.5,78.25 71.84,78.25 73.5,76.59 73.5,74.83 74.89,73.44 74.89,67.21 78.17,63.93 79.54,63.93 80.81,62.66 80.81,59.3 84.77,55.34 v1(84.77,53.81) ; v1(235.2,29.12) 234.51,28.43 231.66,28.43 v1(229.08,25.85)
  IN2 w0.508: v1(306.67,86.44) 305.85,86.44 300.37,80.95 300.37,72.96 301.17,72.16 301.17,69.85 297.73,66.4 297.73,65.76 296.99,65.03 296.99,60.7 296.8,60.51 296.8,53.46 297.38,52.87 297.38,47.48 v1(298.65,46.21) ; v1(253.78,90.67) 253.78,89.07 252.62,87.9 v1(252.21,87.9) ; v3(215.18,42.87) 215.18,44.52 218.78,48.12 v3(219.32,48.12) ; v1(67.35,81.36) 68.17,80.53 68.17,79.17 69.58,77.76 70.13,77.76 v1(70.15,77.74) ; v1(178.85,39.3) 179.02,39.3 179.77,38.55 179.77,37.39 185.25,31.9 192.16,31.9 193.8,33.54 193.99,33.54 194.04,33.59 v1(194.04,33.57) 194.04,32.87 194.41,32.5 v1(213.27,32.5) ; v1(82.93,3.16) 83.17,3.16 84.53,4.52 84.53,7.83 85.95,9.25 85.95,18.02 86.46,18.53 86.46,43.7 87.43,44.67 87.43,52.19 v1(87.27,52.34)
  IN3 w0.508: v1(244.27,74.92) 242.93,74.92 242.76,75.08 242.76,77.36 241.85,78.27 240.55,78.27 237.34,81.49 223.24,81.49 223.05,81.68 v1(222.96,81.68) ; v1(102.58,42.41) 102.58,46.31 106.12,49.85 106.12,50.82 108.86,53.56 v3(108.86,53.8) ; v3(221.81,68.34) 221.81,67.73 222.54,67 224.13,67 226,65.13 226,53.56 221.25,48.81 220.15,48.81 219.47,48.12 v3(219.32,48.12)
  IN4 w0.508: v1(81.62,92.22) 80.18,92.22 78.84,90.89 78.84,89.13 77.32,87.61 68.4,87.61 67.35,86.55 v1(67.35,81.36)
  BOTTOM w0.406: PR810.1 68.94,78.72 67.11,78.72 66.54,78.15 PU804.5
  BOTTOM w0.508: PR810.1 69.79,78.13 70.15,77.76 v1(70.15,77.74) ; v1(212.37,34.98) 212.37,36.72 215.18,39.52 v3(215.18,42.87) PR306.1 ; 290.77,35.58 290.77,32.77 290.47,32.48 RE75.1 RE74.1 RE73.1 ; v1(290.66,40.11) 290.21,39.65 290.21,38.83 ; PR815.1 102.58,40.99 v1(102.58,42.41) 102.58,42.84 PR813.1 ; PC805.2 68.07,81.78 67.65,81.36 v1(67.35,81.36) ; RZ31.1 v1(306.67,86.44) ; PR740.2 110.15,52.52 v3(108.86,53.8) 108.85,53.79 PR859.2 ; PR8.2 43.52,84.39 v3(44.01,84.39) ; v1(194.04,33.57) 194.04,33.59 194.02,33.62 194.02,35.92 192.24,37.7 192.24,45.99 191.19,47.04 RC213.1
  vias: v1(82.23,92.23) v1(82.85,92.22) v1(101.71,93.7) v1(102.07,94.17) v1(102.48,93.72) v1(168.4,119.94) v1(168.71,119.43) v1(169.01,119.95) v1(169.61,119.98) v1(190.53,39.17) v1(191.2,39.17) v1(197.57,113.74) v1(197.56,113.13) v1(198.18,113.77) v1(198.16,113.12) v1(236.63,46.95) v1(236.96,47.44) v1(244.54,87) v1(244.77,62.46) v1(244.77,61.86) v1(245.21,86.96) v1(250.93,89.27) v1(266.99,72.66) v1(267,71.9) v1(267.37,71.44) v1(267.52,72.17) v1(268,71.44) v1(268.1,72.02) v1(271.04,72.63) v1(271.09,72.05) v1(271.09,71.47) v1(271.13,70.87) v1(272.73,61.69) v1(272.77,61.09) v1(273,62.25) v1(276.66,62.73) v1(276.66,62.14) v1(276.66,61.52) v1(277.25,62.73) v1(277.25,62.12) v1(277.27,61.5) v3(217.72,86.68) v3(217.72,86.05) v3(218.41,86.68) v3(218.41,86.05) v3(219.11,86.68) v3(219.11,86.05) v3(219.81,86.68) v3(219.81,86.05) v3(222.1,78.74) v3(222.1,77.47) v3(222.8,78.74) v3(222.8,78.11) v3(222.8,77.47) v3(223.49,78.74) v3(223.49,78.11) v3(223.49,77.47) v3(224.19,78.74) v3(224.19,78.11) v3(224.19,77.47) v4(81.18,92.89) v4(139.23,106.37)
+3.3V_ALW2: length 450.4
  TOP w0.203: PU100.3 221.11,63.85 v3(221.15,63.88)
  TOP w0.254: v3(221.15,63.88) 221.77,63.88 PR103.2
  TOP w0.406: v1(185.56,47.31) 185.56,47.46 186.03,47.93 UC6.5
  TOP w0.508: RZ16.1 180.98,82.87 181.71,82.13 v1(181.71,82.15) ; v1(176.2,87.75) 172.9,87.75 172.33,87.18 RV212.1 ; v1(259.6,49.97) 260.13,50.51 RE57.2 ; v1(183.63,87.89) 183.63,87.73 184.23,87.14 187.15,87.14 188.13,86.16 190.97,86.16 191.82,87.01 193.98,87.01 v1(196.75,84.24) 196.75,72.68 198.92,70.51 198.92,68.68 199.75,67.86 199.75,63.83 201.36,62.22 201.36,61.08 200.57,60.29 200.57,56.75 198.88,55.06 198.88,46.1 194.63,41.85 192.65,41.85 191.2,40.4 v1(191.2,40.24) ; PR846.1 103.54,65.17 103.54,63.39 104.06,62.87 v3(105.64,62.87)
  IN1 w0.508: v3(105.64,62.87) 101.16,62.87 99.53,64.49 97.92,64.49 93.41,69 93.41,72.62 v3(92.76,73.27) ; v1(92.43,51.22) 91.05,49.84 91.05,39.92 93.56,37.4 93.56,26.05 92.86,25.35 91.31,25.35 89.98,24.02 89.98,21.03 v1(90.07,20.94)
  IN2 w0.508: v1(85.03,66.87) 85.19,67.03 87.66,67.03 92.43,62.26 v1(92.43,51.22) ; v3(221.15,63.88) 222.3,62.73 222.3,60.71 222.75,60.26 224.7,60.26 225.46,59.5 225.46,52.77 223.88,51.18 223.88,44.14 v1(223.18,43.44) ; v1(185.56,47.31) 185.18,46.93 185.18,43.14 187.36,40.97 187.36,40.58 187.72,40.22 190.22,40.22 190.23,40.24 v1(191.2,40.24) 191.97,40.24 192.81,41.07 196.63,41.07 197.25,40.45 198.77,40.45 198.91,40.6 206.81,40.6 206.82,40.6 209.48,40.6 v1(210.35,39.73) 210.68,40.06 216.2,40.06 v1(217.14,39.12) 219.33,39.12 219.9,38.55 221.43,38.55 222.44,39.56 226.26,39.56 236.07,49.37 237.86,49.37 240.56,52.07 247.2,52.07 248.44,53.31 252.1,53.31 252.38,53.6 254.69,53.6 255.34,52.94 255.34,52.93 255.91,52.37 256.44,52.37 257.35,51.45 258.12,51.45 v1(259.6,49.97) ; v1(181.71,82.15) 193.7,82.15 195.8,84.24 v1(196.75,84.24)
  IN3 w0.508: v1(209.38,34.95) 209.38,33.43 204.94,28.98 203.3,28.98 198.63,24.31 100.01,24.31 96.55,20.84 92.38,20.84 91.67,21.55 90.68,21.55 v1(90.07,20.94) ; v1(87.81,71.67) 89.41,73.27 v3(92.76,73.27)
  IN4 w0.508: v1(183.63,87.89) 183.63,87.72 183.05,87.14 178.61,87.14 178.49,87.01 176.94,87.01 v1(176.2,87.75)
  BOTTOM w0.254: v3(221.15,63.88) 220.76,64.26 PC100.2
  BOTTOM w0.406: PR829.1 85.69,69.55 v2(86.7,70.56) v1(87.81,71.67) 88.2,72.06 PU806.5
  BOTTOM w0.508: v1(87.81,71.67) 87.36,72.11 R272.2 ; PR855.1 105.63,62.88 v3(105.64,62.87) ; v1(209.38,34.95) 209.38,36.98 210.35,37.95 v1(210.35,39.73) ; v1(217.14,39.12) 219.43,41.4 222.03,41.4 223.18,42.55 v1(223.18,43.44) ; PR829.1 v1(85.03,66.87)
+3.3V_ALW_PCH: length 301
  TOP w0.127: v1(179.87,39.35) v4(179.87,38.57)
  TOP w0.254: 174.02,39.33 173.99,39.3 173.69,39.3 173.52,39.46 RPC1.2 ; 174.02,39.33 174.69,38.66 v1(174.79,38.66) ; 174.02,39.33 RPC1.3 ; 181.7,60.05 v1(181.7,60.05) ; 181.7,60.05 181.7,59.95 181.52,59.77 RPC14.5 ; 181.7,60.05 181.7,60.05 181.48,60.27 RPC14.6 ; 181.5,61.27 RPC14.8 ; 181.5,61.27 181.5,61.48 181.17,61.81 v1(180.38,61.81) ; 181.5,61.27 181.5,60.95 181.31,60.77 RPC14.7 ; RPC1.4 174.52,39.51 v1(174.78,39.26)
  TOP w0.381: v1(163.21,58.64) 163.21,58.56 CC63.1
  TOP w0.508: v1(171.44,39.22) 171.44,39.74 171.49,39.79 RC245.2 ; RC120.2 89.36,24.2 v1(88.75,23.59) ; RC216.1 v1(179.87,39.35) ; CC57.1 160.31,54.28 v1(160.31,54.28) 160.15,54.28 159.61,53.73 159.61,47.92 159.25,47.56 159.25,46.8 160.44,45.6 160.44,43.12 v1(160.58,42.98) ; v1(181.24,53.01) 180.58,53.67 RC81.1 RC82.1 RC33.1 RC34.1 ; v1(172.12,36.16) 172.5,36.54 RC79.1
  IN2 w0.508: v1(160.58,42.98) 162.73,42.98 168.05,37.66 168.87,37.66 169.46,37.07 170.42,37.07 171.33,36.16 v1(172.12,36.16) ; v1(88.75,23.59) 91.01,25.85 91.01,30.17 v1(91.39,30.55) ; v1(227.01,75.53) 225.86,76.69 221.77,76.69 220.56,77.9 220.56,78.07 218.49,80.14 203.91,80.14 202.63,78.86 v1(202.6,78.86)
  IN3 w0.254: 169.16,60.26 167.16,60.26 166.95,60.06 165.32,60.06 165.02,59.76 165.02,59.43 164.76,59.16 163.73,59.16 v1(163.21,58.64) ; 159.96,48.01 159.96,49.02 160.79,49.86 160.79,53.79 v1(160.31,54.28) ; 157.53,48.12 159.19,49.78 159.19,56.42 v1(158.78,56.84)
  IN3 w0.508: 157.53,48.12 157.53,46.92 158.46,45.99 158.46,40.87 159.19,40.13 160.79,40.13 161.68,39.25 161.68,38.18 164.44,35.42 172.34,35.42 v1(172.8,35.88) ; 159.96,48.01 159.96,47.91 161.66,46.21 161.66,45.85 161.7,45.81 161.7,44.02 167.84,37.87 170.7,37.87 171.44,38.61 v1(171.44,39.22) ; v1(181.7,60.05) 181.7,60.05 181.7,60.05 173.98,60.05 173.74,60.29 169.19,60.29 169.16,60.26
  IN4 w0.508: v1(202.6,78.86) 202.6,77.54 197.14,72.08 197.14,69.01 197.79,68.37 197.79,66.58 198.03,66.33 198.03,61.7 197.36,61.03 195.11,61.03 194.75,61.03 194.5,60.78 194.5,60.78 194.06,60.33 194.06,59.83 192.27,58.04 188.04,58.04 187.4,57.41 186.71,57.41 186.45,57.15 186.19,57.15 v1(186.14,57.1)
  BOTTOM w0.203: RPC9.3 185.28,57.47 185.34,57.54 185.76,57.54 185.99,57.32 185.99,57.25 v1(186.14,57.1)
  BOTTOM w0.254: RPC10.1 185.36,55.43 185.4,55.39 185.78,55.39 186.06,55.11 186.06,54.68 185.52,54.14 v1(185.52,53.97) ; v1(185.52,53.97) 185.48,53.93 RPC10.4 ; v1(185.52,53.97) 185.51,53.98 185.51,54.03 185.11,54.43 RPC10.3 ; RPC19.5 189.62,51.36 v1(189.64,51.35) ; v1(182.21,52.95) 182.21,53.11 180.89,54.43 RPC5.3 ; RPC9.1 185.46,58.47 185.47,58.46 v1(185.55,58.46) ; UC1.AH14 160.79,54.76 v1(160.31,54.28) ; RPC19.7 190.3,50.36 190.33,50.4 190.64,50.4 v1(190.69,50.35) ; RC2.1 228.03,75.57 228.03,76.25 227.52,76.76 226.49,76.76 225.98,77.27 225.98,78.12 226.19,78.32 JAPS1.1 ; v1(158.78,56.84) 158.69,56.75 157.84,56.75 UC1.AE20 157.4,56.31 UC1.AE21 ; RPC5.4 180.82,53.93 181.24,53.51 v1(181.24,53.01) ; v1(163.21,58.64) 163.23,58.66 UC1.AA9 UC1.AC9
  BOTTOM w0.508: RC2.1 227.84,75.38 227.16,75.38 v1(227.01,75.53) ; RC179.1 184.65,53.08 v1(184.42,53.3) ; 171.87,34.99 170.9,34.03 111.74,34.03 108.98,31.27 104.82,31.27 104.27,31.82 98.42,31.82 97.8,32.43 97.29,32.43 97.27,32.41 95.28,32.41 93.56,30.7 91.54,30.7 v1(91.39,30.55)
  vias: v1(188.19,40.83) v1(188.79,40.85) v1(188.82,47.37) v1(188.82,46.79) v1(189.38,40.85) v1(189.97,40.83)
