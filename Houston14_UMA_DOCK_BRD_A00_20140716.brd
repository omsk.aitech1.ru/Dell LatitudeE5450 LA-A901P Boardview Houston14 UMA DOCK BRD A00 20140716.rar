# Allegro board Houston14_UMA_DOCK_BRD_A00_20140716.brd (continued)
## Nets (continued)
GND: C33.2 C42.2 C43.2 C263.2 C310.2 C311.2 C316.2 C317.2 C318.2 C319.2 CA5.2 CA6.2 CA7.2 CA10.2 CA11.2 CA12.2 CA13.1 CA19.2 CA22.2 CA23.2 CA24.2 CA30.2 CA31.2 CA33.2 CA41.2 CA45.2 CA46.2 CA47.2 CA48.2 CA49.1 CA50.2 CA53.2 CA54.2 CC1.1 CC2.1 CC3.1 CC4.1 CC5.2 CC6.2 CC7.2 CC8.1 CC9.1 CC10.1 CC11.1 CC12.1 CC13.1 CC14.1 CC15.1 CC17.2 CC18.2 CC19.2 CC20.2 CC21.2 CC22.2 CC24.2 CC25.2 CC26.2 CC27.2 CC28.2 CC29.2 CC30.2 CC31.2 CC32.2 CC33.2 CC34.2 CC35.2 CC36.2 CC37.2 CC39.2 CC40.2 CC41.2 CC42.2 CC43.2 CC44.2 CC47.2 CC48.2 CC49.2 CC50.2 CC51.2 CC52.2 CC53.2 CC54.2 CC55.2 CC56.2 CC57.2 CC58.2 CC59.2 CC60.2 CC61.2 CC62.2 CC63.2 CC64.2 CC65.2 CC66.2 CC67.2 CC68.2 CC69.2 CC70.2 CC71.2 CC72.2 CC73.2 CC77.2 CC78.2 CC80.2 CC81.2 CC82.2 CC83.2 CC100.1 CC101.2 CD1.2 CD2.2 CD3.2 CD4.2 CD5.2 CD6.2 CD7.2 CD8.2 CD9.2 CD10.2 CD11.2 CD12.2 CD13.2 CD14.2 CD15.2 CD16.2 CD17.2 CD18.2 CD19.2 CD20.2 CD22.2 CD23.2 CD24.2 CD25.2 CD26.2 CD27.2 CD28.2 CD29.2 CD30.2 CD31.2 CD32.2 CD33.2 CD34.2 CD35.2 CD37.2 CD38.2 CD39.2 CD40.2 CD41.2 CD42.2 CD43.2 CD44.2 CD45.2 CD46.2 CD47.2 CD48.2 CD49.2 CD50.2 CD51.2 CD52.2 CD53.2 CD55.2 CD56.2 CD57.2 CD58.2 CD59.2 CD60.2 CD61.2 CD62.2 CD63.2 CD64.2 CE1.2 CE2.2 CE3.2 CE4.2 CE5.2 CE6.2 CE7.2 CE8.2 CE9.2 CE10.2 CE11.2 CE12.2 CE13.2 CE14.2 CE15.2 CE16.2 CE17.2 CE18.2 CE19.2 CE20.2 CE21.2 CE22.2 CE23.2 CE25.2 CE28.2 CE29.2 CE30.2 CE31.2 CE32.2 CE34.2 CE36.2 CE38.2 CE40.2 CE44.2 CE45.2 CI1.2 CI3.2 CI6.2 CI7.2 CI8.2 CI10.2 CI11.2 CI12.2 CI14.2 CI17.2 CI19.2 CI38.2 CI414.2 CI415.2 CI416.2 CI417.2 CI418.2 CI419.2 CI420.2 CI421.2 CI422.2 CL3.2 CL4.2 CL7.2 CL8.2 CL9.2 CL10.2 CL11.2 CL12.2 CL13.1 CL14.1 CL15.2 CL16.2 CL17.2 CL18.2 CL19.2 CL20.2 CL21.2 CL22.1 CL25.2 CL26.2 CL27.2 CMOS1.1 CN1.2 CN2.2 CN3.1 CN4.2 CN13.2 CN14.2 CN15.2 CN16.2 CN24.2 CN29.2 CR1.2 CR2.2 CR3.2 CR4.2 CR6.2 CR7.1 CR8.1 CR9.1 CR10.1 CR13.1 CR14.1 CR15.1 CR17.1 CR18.1 CR19.1 CR21.1 CR22.1 CR23.2 CR31.2 CR34.2 CR35.2 CV7.2 CV8.2 CV9.2 CV10.2 CV12.2 CV23.2 CV26.2 CV27.2 CV50.2 CV51.2 CV52.2 CV53.2 CV54.2 CV55.2 CV56.2 CV57.2 CV58.2 CV59.2 CV60.2 CV61.2 CV62.2 CV66.2 CV69.2 CV70.2 CV82.2 CV83.2 CV84.2 CV85.2 CV86.2 CV87.2 CV88.2 CV89.2 CV90.2 CV91.2 CV92.2 CV93.2 CV94.2 CV95.2 CV96.2 CV97.2 CV98.2 CV99.2 CV100.2 CV101.2 CV113.2 CV114.2 CV115.2 CV118.2 CV121.2 CV124.2 CV125.2 CV126.2 CV127.2 CV128.2 CV144.2 CV374.2 CV377.2 CV378.2 CV379.2 CV380.2 CZ1.2 CZ2.2 CZ4.2 CZ5.2 CZ6.2 CZ7.2 CZ9.2 CZ10.2 CZ11.2 CZ12.2 CZ15.2 CZ16.2 CZ17.1 CZ18.1 CZ19.2 CZ20.2 CZ23.2 CZ24.2 CZ25.2 CZ27.2 CZ28.2 CZ29.2 CZ30.2 CZ31.2 CZ34.2 CZ35.2 CZ36.2 CZ37.2 CZ38.2 CZ39.1 CZ40.2 CZ41.2 CZ42.2 CZ43.2 CZ44.2 CZ45.2 CZ46.2 CZ47.2 CZ48.2 CZ49.2 CZ50.2 CZ51.2 CZ52.2 CZ53.2 CZ54.2 CZ55.2 CZ56.2 CZ57.2 CZ62.2 CZ63.2 CZ64.2 CZ65.2 CZ66.2 CZ67.2 CZ68.2 D20.1 DA1.1 DA2.1 DA3.1 DA6.1 DA7.1 DE1.2 DI1.3 DI2.1 DI3.1 DI4.3 DI5.1 DI6.3 DV4.1 DV5.1 DV6.1 H1.1(TP-1) H2.1(TP-1) H3.1(TP-1) H4.1(TP-1) H6.1(TP-1) H7.1(TP-1) H8.1(TP-1) H9.1(TP-1) H10.1(TP-1) H11.1(TP-1) H12.1(TP-1) H13.1(TP-1) H15.1(TP-1) H17.1(TP-1) H18.1(TP-1) H19.1(TP-1) H22.1(TP-1) H24.1(TP-1) JAPS1.8 JAPS1.10 JAPS1.12 JAPS1.14 JAPS1.19 JAPS1.20 JCRT1.5 JCRT1.6 JCRT1.7 JCRT1.8 JCRT1.10 JCRT1.16 JCRT1.17 JDEG1.10 JDEG1.11 JDEG1.12 JDIMM1.2 JDIMM1.3 JDIMM1.8 JDIMM1.9 JDIMM1.11 JDIMM1.13 JDIMM1.14 JDIMM1.19 JDIMM1.20 JDIMM1.25 JDIMM1.26 JDIMM1.28 JDIMM1.31 JDIMM1.32 JDIMM1.37 JDIMM1.38 JDIMM1.43 JDIMM1.44 JDIMM1.46 JDIMM1.48 JDIMM1.49 JDIMM1.54 JDIMM1.55 JDIMM1.60 JDIMM1.61 JDIMM1.63 JDIMM1.65 JDIMM1.66 JDIMM1.71 JDIMM1.72 JDIMM1.127 JDIMM1.128 JDIMM1.133 JDIMM1.134 JDIMM1.136 JDIMM1.138 JDIMM1.139 JDIMM1.144 JDIMM1.145 JDIMM1.150 JDIMM1.151 JDIMM1.153 JDIMM1.155 JDIMM1.156 JDIMM1.161 JDIMM1.162 JDIMM1.167 JDIMM1.168 JDIMM1.170 JDIMM1.172 JDIMM1.173 JDIMM1.178 JDIMM1.179 JDIMM1.184 JDIMM1.185 JDIMM1.187 JDIMM1.189 JDIMM1.190 JDIMM1.195 JDIMM1.196 JDIMM2.2 JDIMM2.3 JDIMM2.8 JDIMM2.9 JDIMM2.11 JDIMM2.13 JDIMM2.14 JDIMM2.19 JDIMM2.20 JDIMM2.25 JDIMM2.26 JDIMM2.28 JDIMM2.31 JDIMM2.32 JDIMM2.37 JDIMM2.38 JDIMM2.43 JDIMM2.44 JDIMM2.46 JDIMM2.48 JDIMM2.49 JDIMM2.54 JDIMM2.55 JDIMM2.60 JDIMM2.61 JDIMM2.63 JDIMM2.65 JDIMM2.66 JDIMM2.71 JDIMM2.72 JDIMM2.127 JDIMM2.128 JDIMM2.133 JDIMM2.134 JDIMM2.136 JDIMM2.138 JDIMM2.139 JDIMM2.144 JDIMM2.145 JDIMM2.150 JDIMM2.151 JDIMM2.153 JDIMM2.155 JDIMM2.156 JDIMM2.161 JDIMM2.162 JDIMM2.167 JDIMM2.168 JDIMM2.170 JDIMM2.172 JDIMM2.173 JDIMM2.178 JDIMM2.179 JDIMM2.184 JDIMM2.185 JDIMM2.187 JDIMM2.189 JDIMM2.190 JDIMM2.195 JDIMM2.196 JDOCK1.1 JDOCK1.7 JDOCK1.8 JDOCK1.13 JDOCK1.14 JDOCK1.19 JDOCK1.20 JDOCK1.25 JDOCK1.26 JDOCK1.31 JDOCK1.32 JDOCK1.37 JDOCK1.38 JDOCK1.43 JDOCK1.44 JDOCK1.47 JDOCK1.49 JDOCK1.50 JDOCK1.51 JDOCK1.52 JDOCK1.55 JDOCK1.57 JDOCK1.58 JDOCK1.61 JDOCK1.63 JDOCK1.64 JDOCK1.69 JDOCK1.70 JDOCK1.75 JDOCK1.76 JDOCK1.81 JDOCK1.82 JDOCK1.87 JDOCK1.88 JDOCK1.91 JDOCK1.93 JDOCK1.94 JDOCK1.95 JDOCK1.96 JDOCK1.101 JDOCK1.102 JDOCK1.107 JDOCK1.108 JDOCK1.113 JDOCK1.114 JDOCK1.119 JDOCK1.120 JDOCK1.123 JDOCK1.125 JDOCK1.126 JDOCK1.131 JDOCK1.132 JDOCK1.137 JDOCK1.138 JDOCK1.145 JDOCK1.152 JDOCK1.153 JDOCK1.154 JDOCK1.155 JDOCK1.156 JDOCK1.157 JDOCK1.158 JDOCK1.159 JDOCK1.160 JDOCK1.161 JDOCK1.162 JDOCK1.163 JDOCK1.164 JEDP1.4 JEDP1.6 JEDP1.8 JEDP1.15 JEDP1.23 JEDP1.24 JEDP1.25 JEDP1.27 JEDP1.28 JEDP1.39 JEDP1.41 JEDP1.42 JEDP1.43 JEDP1.44 JEDP1.45 JFAN1.1 JFAN1.5 JFAN1.6 JHDMI1.2 JHDMI1.5 JHDMI1.8 JHDMI1.11 JHDMI1.17 JHDMI1.20 JHDMI1.21 JHDMI1.22 JHDMI1.23 JKBTP1.1 JKBTP1.2 JKBTP1.8 JKBTP1.14 JKBTP1.15 JKBTP1.17 JKBTP1.18 JLED1.10 JLED1.11 JLED1.12 JLOM1.14 JLOM1.15 JLOM1.16 JLOM1.17 JLPDE1.9 JLPDE1.11 JLPDE1.12 JNGFF1.1 JNGFF1.7 JNGFF1.10 JNGFF1.15 JNGFF1.16 JNGFF1.21 JNGFF1.22 JNGFF1.25 JNGFF1.28 JNGFF1.31 JNGFF1.37 JNGFF1.43 JNGFF1.49 JNGFF1.55 JNGFF1.61 JNGFF1.67 JNGFF1.68 JNGFF1.69 JNGFF2.3 JNGFF2.5 JNGFF2.11 JNGFF2.19 JNGFF2.25 JNGFF2.31 JNGFF2.37 JNGFF2.43 JNGFF2.49 JNGFF2.63 JNGFF2.65 JNGFF2.68 JNGFF2.69 JRTC1.2 JRTC1.3 JRTC1.4 JSATA1.1 JSATA1.4 JSATA1.7 JSATA1.12 JSATA1.14 JSATA1.18 JSATA1.21 JSATA1.22 JSATA1.23 JSATA1.24 JSD1.3 JSD1.6 JSD1.10 JSD1.13 JSD1.17 JSD1.20 JSD1.21 JSD1.22 JSD1.23 JSD1.24 JSD1.25 JSD1.26 JSIM1.7 JSIM1.9 JSIM1.10 JSIM1.11 JSIM1.12 JSPI1.1 JSPI1.2 JSPI1.3 JSPI1.21 JSPI1.22 JSPK1.5 JSPK1.6 JTAG1.2 JUSB1.4 JUSB1.7 JUSB1.10 JUSB1.11 JUSB1.12 JUSB1.13 JUSB2.4 JUSB2.7 JUSB2.10 JUSB2.11 JUSB2.12 JUSB2.13 JUSB3.4 JUSB3.7 JUSB3.10 JUSB3.11 JUSB3.12 JUSB3.13 JUSH1.2 JUSH1.3 JUSH1.17 JUSH1.20 JUSH1.21 JUSH1.22 JXDP1.1 JXDP1.2 JXDP1.7 JXDP1.8 JXDP1.13 JXDP1.14 JXDP1.19 JXDP1.20 JXDP1.25 JXDP1.26 JXDP1.31 JXDP1.32 JXDP1.37 JXDP1.38 JXDP1.49 JXDP1.50 JXDP1.59 MIC1.1 MIC1.2 MIC1.3 PBATT1.7 PBATT1.8 PBATT1.9 PBATT1.10 PC1.2 PC3.2 PC4.2 PC9.2 PC10.2 PC20.2 PC21.2 PC22.2 PC100.1 PC101.2 PC102.2 PC105.2 PC106.2 PC111.2 PC113.2 PC114.2 PC115.2 PC117.2 PC118.2 PC119.2 PC200.2 PC201.2 PC203.2 PC205.2 PC206.2 PC207.2 PC208.2 PC209.1 PC211.2 PC212.2 PC214.2 PC215.2 PC300.2 PC301.2 PC303.2 PC305.2 PC306.2 PC307.2 PC308.2 PC309.2 PC310.2 PC311.2 PC400.2 PC401.2 PC402.2 PC404.2 PC500.1 PC501.2 PC503.1 PC505.1 PC507.1 PC508.2 PC509.1 PC510.1 PC511.2 PC514.1 PC515.2 PC516.2 PC517.2 PC518.2 PC519.2 PC520.2 PC521.2 PC704.2 PC705.2 PC706.2 PC707.2 PC708.2 PC709.2 PC710.2 PC713.2 PC714.2 PC715.2 PC716.2 PC717.2 PC721.2 PC722.2 PC723.2 PC724.2 PC725.2 PC732.2 PC737.2 PC741.1 PC805.1 PC810.1 PC813.2 PC815.2 PC816.2 PC817.2 PC900.2 PC901.2 PC902.2 PC903.2 PC904.2 PC913.2 PC914.2 PC915.2 PC916.2 PC917.2 PC966.2 PD1.1 PD2.1 PD5.1 PJP1.2 PJP6.2 PJP701.2 PJPDC1.6 PJPDC1.7 PQ3.3 PQ6.6 PQ102.1 PQ102.2 PQ102.3 PQ103.1 PQ103.2 PQ103.3 PQ201.1 PQ201.2 PQ201.3 PQ705.3 PQ705.4 PQ705.5 PQ806.1 PQ806.4 PQ813.1 PQ813.4 PQ816.3 PQ817.1 PQ817.4 PQ832.3 PR12.1 PR15.2 PR16.2 PR18.2 PR102.1 PR104.2 PR105.1 PR106.1 PR114.2 PR209.2 PR303.2 PR308.2 PR310.2 PR401.2 PR403.2 PR505.1 PR506.1 PR507.1 PR508.1 PR509.1 PR510.1 PR513.2 PR525.2 PR745.2 PR814.1 PR844.2 PR858.2 PR874.2 PU1.2 PU100.21 PU200.1 PU200.3 PU200.14 PU200.21 PU300.9 PU400.1 PU500.19 PU500.22 PU500.29 PU500.33 PU501.3 PU501.9 PU700.22 PU800.5 PU800.14 PU800.23 PU800.32 PU800.37 PU804.3 PU806.3 QA1.3 QA3.1 QA3.4 QE2.1 QE2.4 QN1.1 QN1.4 QV2.3 QV4.3 QV7.3 QV9.3 QV10.3 QV11.3 QV21.1 QV21.4 QZ10.1 QZ10.4 R268.2 R271.2 RA2.2 RA35.2 RA36.2 RA37.2 RC21.2 RC80.2 RC91.1 RC123.2 RC128.1 RC129.1 RC130.2 RC131.2 RC132.2 RC139.1 RC140.2 RC141.1 RC142.1 RC152.2 RC171.2 RC174.2 RC175.2 RC178.2 RC181.2 RC183.2 RC184.2 RC185.2 RC186.1 RC187.2 RC188.2 RC189.2 RC190.2 RC191.2 RC198.2 RC218.2 RC240.2 RC241.2 RC242.2 RC243.2 RC303.2 RC304.2 RC305.2 RC306.1 RD6.2 RD7.2 RD14.1 RD15.1 RD16.1 RD20.2 RD21.2 RD24.2 RD25.2 RD28.2 RE17.1 RE20.1 RE21.1 RE24.2 RE55.1 RE56.1 RE58.2 RE65.2 RE77.2 RE78.2 RE82.1 RE85.2 RE86.1 RE88.2 RE277.1 RI14.1 RL3.1 RL9.2 RL12.2 RL13.2 RN7.2 RN9.1 RN11.1 RN13.1 RN16.1 RN19.1 RN21.1 RN23.2 RN25.2 RPC20.6 RPC20.7 RPE10.5 RPE10.6 RPE10.7 RPE10.8 RR2.1 RR5.2 RR8.2 RR11.2 RV1.2 RV2.2 RV3.1 RV20.2 RV32.2 RV33.2 RV34.2 RV50.2 RV61.2 RV62.2 RV63.2 RV64.2 RV65.2 RV67.1 RV68.1 RV70.1 RV72.1 RV73.2 RV74.2 RV75.2 RV76.2 RV77.2 RV78.2 RV79.2 RV89.2 RV100.2 RV508.1 RV509.1 RZ10.1 RZ27.2 RZ33.2 RZ38.1 RZ40.1 SW1.4 SW1.5 SW3.1 SW3.3 UA1.49 UC1.A11 UC1.A14 UC1.A18 UC1.A24 UC1.A28 UC1.A32 UC1.A36 UC1.A40 UC1.A44 UC1.A48 UC1.A52 UC1.A56 UC1.AA1 UC1.AA58 UC1.AB7 UC1.AB10 UC1.AB20 UC1.AB22 UC1.AC61 UC1.AD3 UC1.AD21 UC1.AD63 UC1.AE5 UC1.AE10 UC1.AE58 UC1.AF11 UC1.AF12 UC1.AF14 UC1.AF15 UC1.AF17 UC1.AF18 UC1.AG1 UC1.AG11 UC1.AG21 UC1.AG23 UC1.AG60 UC1.AG61 UC1.AG62 UC1.AG63 UC1.AH16 UC1.AH17 UC1.AH19 UC1.AH20 UC1.AH22 UC1.AH24 UC1.AH28 UC1.AH30 UC1.AH32 UC1.AH34 UC1.AH36 UC1.AH38 UC1.AH40 UC1.AH42 UC1.AH44 UC1.AH46 UC1.AH49 UC1.AH51 UC1.AH53 UC1.AH55 UC1.AH57 UC1.AJ13 UC1.AJ14 UC1.AJ23 UC1.AJ25 UC1.AJ27 UC1.AJ29 UC1.AJ35 UC1.AJ39 UC1.AJ41 UC1.AJ43 UC1.AJ45 UC1.AJ47 UC1.AJ50 UC1.AJ52 UC1.AJ54 UC1.AJ56 UC1.AJ58 UC1.AJ60 UC1.AJ63 UC1.AK3 UC1.AK23 UC1.AK52 UC1.AL10 UC1.AL13 UC1.AL17 UC1.AL20 UC1.AL22 UC1.AL23 UC1.AL26 UC1.AL29 UC1.AL31 UC1.AL33 UC1.AL36 UC1.AL39 UC1.AL40 UC1.AL45 UC1.AL46 UC1.AL51 UC1.AL52 UC1.AL54 UC1.AL57 UC1.AL60 UC1.AL61 UC1.AM1 UC1.AM17 UC1.AM23 UC1.AM31 UC1.AM52 UC1.AN7 UC1.AN17 UC1.AN23 UC1.AN31 UC1.AN32 UC1.AN35 UC1.AN36 UC1.AN39 UC1.AN40 UC1.AN42 UC1.AN43 UC1.AN45 UC1.AN46 UC1.AN48 UC1.AN49 UC1.AN51 UC1.AN52 UC1.AN60 UC1.AN63 UC1.AP3 UC1.AP10 UC1.AP17 UC1.AP20 UC1.AP22 UC1.AP23 UC1.AP26 UC1.AP29 UC1.AP31 UC1.AP38 UC1.AP39 UC1.AP48 UC1.AP52 UC1.AP54 UC1.AP57 UC1.AR5 UC1.AR11 UC1.AR15 UC1.AR17 UC1.AR23 UC1.AR31 UC1.AR33 UC1.AR39 UC1.AR43 UC1.AR49 UC1.AR52 UC1.AT13 UC1.AT35 UC1.AT37 UC1.AT40 UC1.AT42 UC1.AT43 UC1.AT46 UC1.AT49 UC1.AT61 UC1.AT62 UC1.AT63 UC1.AU1 UC1.AU16 UC1.AU18 UC1.AU20 UC1.AU22 UC1.AU24 UC1.AU26 UC1.AU28 UC1.AU30 UC1.AU33 UC1.AU51 UC1.AU53 UC1.AU55 UC1.AU57 UC1.AU59 UC1.AV8 UC1.AV14 UC1.AV16 UC1.AV20 UC1.AV24 UC1.AV28 UC1.AV33 UC1.AV34 UC1.AV36 UC1.AV39 UC1.AV41 UC1.AV43 UC1.AV46 UC1.AV49 UC1.AV51 UC1.AV55 UC1.AV59 UC1.AW4 UC1.AW16 UC1.AW24 UC1.AW33 UC1.AW35 UC1.AW37 UC1.AW40 UC1.AW42 UC1.AW44 UC1.AW47 UC1.AW50 UC1.AW51 UC1.AW59 UC1.AW60 UC1.AY4 UC1.AY6 UC1.AY11 UC1.AY16 UC1.AY18 UC1.AY22 UC1.AY24 UC1.AY26 UC1.AY30 UC1.AY33 UC1.AY51 UC1.AY53 UC1.AY57 UC1.AY59 UC1.B4 UC1.B20 UC1.B24 UC1.B26 UC1.B28 UC1.B32 UC1.B36 UC1.B40 UC1.B44 UC1.B48 UC1.B52 UC1.B56 UC1.B60 UC1.C11 UC1.C14 UC1.C18 UC1.C20 UC1.C25 UC1.C27 UC1.C38 UC1.C39 UC1.C57 UC1.D2 UC1.D5 UC1.D8 UC1.D12 UC1.D14 UC1.D18 UC1.D21 UC1.D23 UC1.D25 UC1.D26 UC1.D27 UC1.D29 UC1.D30 UC1.D31 UC1.D33 UC1.D34 UC1.D35 UC1.D37 UC1.D38 UC1.D39 UC1.D41 UC1.D42 UC1.D43 UC1.D45 UC1.D46 UC1.D47 UC1.D49 UC1.D50 UC1.D51 UC1.D53 UC1.D54 UC1.D55 UC1.D57 UC1.D59 UC1.D62 UC1.D63 UC1.E11 UC1.E17 UC1.F20 UC1.F26 UC1.F30 UC1.F34 UC1.F38 UC1.F42 UC1.F46 UC1.F50 UC1.F54 UC1.F58 UC1.F61 UC1.G3 UC1.G5 UC1.G6 UC1.G8 UC1.G18 UC1.G22 UC1.H13 UC1.H17 UC1.H57 UC1.J10 UC1.J22 UC1.J59 UC1.J63 UC1.K1 UC1.K12 UC1.L7 UC1.L13 UC1.L15 UC1.L17 UC1.L18 UC1.L20 UC1.L58 UC1.L61 UC1.M22 UC1.N3 UC1.N10 UC1.N21 UC1.P22 UC1.P59 UC1.P62 UC1.P63 UC1.R8 UC1.R10 UC1.R22 UC1.T1 UC1.T58 UC1.U9 UC1.U20 UC1.U22 UC1.U61 UC1.V3 UC1.V7 UC1.V10 UC1.V23 UC1.V58 UC1.W20 UC1.W22 UC1.Y10 UC1.Y59 UC1.Y63 UC2.4 UC3.4 UC4.3 UC5.3 UC6.3 UC7.7 UC7.15 UC8.3 UD1.3 UE1.B27 UE1.C1 UE2.B11 UE2.B18 UE2.B54 UE2.B60 UE2.B66 UE2.C1 UI1.1 UI2.1 UI3.14 UI3.17 UI4.11 UI4.21 UI4.28 UI4.33 UI5.5 UI5.6 UL1.49 UL2.3 UL4.43 UN1.5 UN1.10 UN1.12 UN1.13 UN1.15 UN1.16 UN2.3 UN2.21 UN3.5 UN3.9 UR1.49 UV2.2 UV4.2 UV7.11 UV7.19 UV7.52 UV7.61 UV8.C5 UV8.C13 UV8.C14 UV8.D4 UV8.D5 UV8.D6 UV8.D7 UV8.D8 UV8.D9 UV8.D10 UV8.D11 UV8.D13 UV8.D14 UV8.E4 UV8.E11 UV8.F4 UV8.F5 UV8.F6 UV8.F7 UV8.F8 UV8.F9 UV8.F10 UV8.F11 UV8.G4 UV8.G5 UV8.G6 UV8.G7 UV8.G8 UV8.G9 UV8.G10 UV8.G11 UV8.H4 UV8.H10 UV8.J5 UV8.J6 UV8.J7 UV8.J8 UV8.J9 UV8.J11 UV8.J12 UV8.K5 UV8.L6 UV8.L7 UV8.L8 UV9.4 UV11.7 UV12.7 UV16.3 UV16.11 UV16.28 UV16.31 UV16.33 UV24.2 UZ1.4 UZ1.8 UZ1.11 UZ1.18 UZ1.25 UZ2.11 UZ2.15 UZ3.11 UZ3.15 UZ5.2 UZ6.3 UZ7.5 UZ7.9 UZ8.11 UZ8.15 UZ9.11 UZ9.15 UZ10.3 UZ11.3 YL1.2 YL1.4 YV2.2 YV2.4
GNDA: CA1.2 CA2.2 CA3.2 CA4.2 CA8.2 CA9.2 CA16.2 CA17.2 CA18.2 CA25.2 CA26.2 CA35.1 CA51.2 CA52.2 JHP1.7 PJP6.1 QA2.1 QA2.4 RA35.1 RA36.1 RA37.1 RA44.2 UA1.26 UA1.37
GNDA_CHG: PC701.1 PC703.2 PC711.2 PC718.1 PC719.1 PC726.1 PC728.2 PC729.2 PJP701.1 PR711.2 PR715.2 PR729.2 PR788.1 PU700.29
VCCSENSE: PR531.1 RC209.2 UC1.E63
VDD_1.35V: PC211.1 PR201.1 PR202.2 PU200.11
VSSSENSE: PR532.1 RC218.1 UC1.E62
3301_ACAV_IN_NB: PR848.1 PU800.24
3301_PWRSRC: PR860.1 PU800.15
+AUX_LDO: CR17.2 UR1.12
+BL_PWR_SRC: CV7.1 CV12.1 JEDP1.17 JEDP1.18 JEDP1.19 QV1.1 QV1.2 QV1.5 QV1.6
+CAP_LDO: CE7.1 UE1.B46
+COINCELL: JRTC1.1 PR1.1
+CRT_VCC: CV50.1 JCRT1.9 RV35.1 RV36.1 RV37.1 RV38.1 UV4.3
+DC_IN: PC5.2 PC22.1 PL4.2 PQ4.1 PQ4.2 PQ4.3 PQ6.3 PR14.1 PR16.1 PR737.1 PR835.1
+DC_IN_SS: PC10.1 PD704.2 PD817.3 PQ4.5 PQ700.5 PQ700.6 PQ700.7 PQ700.8 PR15.1 PR831.1
+DCIN: PC709.1 PR708.2 PU700.28
+DCIN_JACK: PC9.1 PC21.1 PJPDC1.2 PJPDC1.3 PL4.1
+DCPRRTC: CC52.1 UC1.AE7
+DIMM1_VREF_DQ: CD1.1 CD5.1 JDIMM1.1 RD4.2 RD5.1 RD6.1
+DIMM2_VREF_DQ: CD33.1 CD34.1 JDIMM2.1 RD22.2 RD23.1 RD24.1
+DOCK_PWR_BAR: C33.1 C317.1 C318.1 D20.2 D20.3 JDOCK1.146 JDOCK1.147 JDOCK1.148 JDOCK1.149 JDOCK1.150 JDOCK1.151 PD705.2 PD808.2 PD808.3 PQ810.5 PQ810.6 PQ810.7 PQ810.8 PQ826.5 PR814.2 PR832.2
+EDP_VDD: PJP29.2 UV24.1
+LCDVDD: CV8.1 CV9.1 JEDP1.30 JEDP1.31 PJP29.1
+LOM_VCT: C316.1 JDOCK1.116 JDOCK1.118
+MIC1_VREF_OUT: DA4.2 DA5.2 UA1.30
+NBDOCK_DC_IN_SS: JDOCK1.41 PD817.2 PR863.2
+PBATT: PD702.2 PD800.2 PD800.3 PL1.2 PL2.2 PQ800.5 PQ800.6 PQ800.7 PQ800.8 PQ815.5 PQ815.6 PQ815.7 PQ815.8 PR723.2 PR838.2
+PCH_ASATA3PLL: CC55.1 CC56.1 LC2.2 RC17.2 UC1.A12 UC1.B11
+PCH_AUSB3PLL: CC47.1 CC51.1 LC1.2 RC149.1 UC1.B18 UC1.B27
+PCH_RTC_VCCSUS3_3: CC73.1 RC212.2 RC213.2 UC1.AH11
+PCH_VCC1P05: CC77.1 CC78.1 LC4.2 UC1.J18 UC1.K19
+PCH_VCCACLKPLL: CC81.1 CC82.1 LC5.2 RC69.2 UC1.A20
+PCH_VCCDSW: CC97.2 RC211.2 UC1.AG19 UC1.AG20
+PCH_VCCDSW3_3: CC80.1 CC97.1 JAPS1.3 JAPS1.7 RC92.2 RC153.2 RC216.2 RC217.2 RPC1.1 RPC10.2 RPC19.8 UC1.AH10
+PCH_VCCDSW_R: CC65.1 RC211.1
+PECI_VREF: CE25.1 RE59.1 UE2.B51
+PWR_SRC: CV11.1 PC704.1 PC705.1 PC706.1 PC707.1 PC708.1 PJP100.1 PJP200.1 PJP302.1 PJP500.1 PL100.1 PL501.1 PL701.1 PR721.4 QV1.4 RV4.1
+PWR_SRC_AC: PC807.1 PD808.1 PJP700.1 PL700.2 PQ810.1 PQ810.2 PQ810.3 PR701.1 PR860.2
+RSVD_VCC3P3_1: RL6.2 UL1.1
+RTC_CELL: CC48.1 CC49.1 CC50.1 PC1.1 PD3.1 RA21.1 RC1.1 RC8.1 RC9.1 RC10.1 RC78.2 RE31.1 RE32.1 RE62.1 RPE5.5 RPE5.6 UC1.AG10
+RTC_CELL_VBAT: CE11.1 RE32.2 UE2.B64
+SD_IO_LDO: CR14.2 CR15.2 UR1.25
+SDC_IN: PC700.1 PQ700.1 PQ700.2 PQ700.3 PR701.4 PR710.2 PR847.1 PU700.3
+SIM_PWR: C263.1 JNGFF2.28 JSIM1.8
+SM_VREF_CA: CD36.1 RD19.2 UC1.AP49
+SM_VREF_CA_DIMM: CD22.1 CD23.1 CD55.1 CD56.1 JDIMM1.126 JDIMM2.126 RD18.2 RD19.1 RD20.1
+SM_VREF_DQ0: CD21.1 RD5.2 UC1.AR51
+SM_VREF_DQ1: CD54.1 RD23.2 UC1.AP51
+USB_LEFT_PWR: CI1.1 CI3.1 JUSB1.1 UI1.6 UI1.7 UI1.8
+USB_RIGHT_PWR: CI8.1 CI10.1 JUSB2.1 UI2.6 UI2.7 UI2.8
+V_DDR_REF: PC212.1 PU200.4
+VCHGR: PC722.1 PC723.1 PC724.1 PC725.1 PD800.1 PQ800.1 PQ800.2 PQ800.3 PR721.1
+VHDMI_VCC: CV26.1 CV27.1 JHDMI1.18 RV7.2 RV9.2 UV2.3
+VLDOIN_1.35V: PJP201.1 PU200.19
+VR_CAP: CE31.1 UE2.B12
+VREFOUT: CA26.1 RA5.2 RA6.2 UA1.23
+Z4012: PD3.2 PR1.2
-DCIN_JACK: PJP1.1 PJPDC1.4 PJPDC1.5
/BATPRES: PR728.2 PR816.2 PU700.15
A_ON: RPE10.3 RZ42.1 UE2.A4 UZ8.3
AC_DIS: PQ6.5 PR828.1 UE2.A10
AC_PRESENT: RPC10.7 UC1.AJ8 UE2.A54
ACAV_DOCK_SRC#: JDOCK1.42 PR842.1 PR846.2
ACAV_IN: PQ817.5 PR713.2 PR714.1 PR715.1 PR851.1 UE2.A64
ACAV_IN#: PQ817.3 PR864.2 PU806.2
ACAV_IN_NB: PR743.2 PR848.2 UE2.B20
ACAVDK_SRC: PR842.2 PU800.4
ACAVIN: PR851.2 PU800.8
ALW_PWRGD_3V_5V: PR108.1 RE283.2 RZ51.1
ALW_PWRGD_3V_5V_EC: RE283.1 UE2.A1
ALWON: PR113.1 UE2.A60
AUD_HP_NB_SENSE: CA41.1 DA2.3 JHP1.6 QA1.2 RA2.1 UE1.A41
AUD_HP_OUT_L: CA43.2 LA2.1 RA7.2 RA24.1
AUD_HP_OUT_L1: CA3.1 DA3.3 JHP1.1 LA2.2
AUD_HP_OUT_R: CA44.2 LA3.1 RA8.2 RA25.1
AUD_HP_OUT_R1: CA2.1 DA1.2 JHP1.2 LA3.2
AUD_NB_MUTE#: CA31.1 QA2.2 RA18.2 UA1.48 UE1.A39
AUD_OUT_L: RA7.1 UA1.33
AUD_OUT_R: RA8.1 UA1.32
AUD_PC_BEEP: CA27.2 CA28.2 UA1.12
AUD_SENSE_A: QA1.1 UA1.13
AUD_SENSE_B: RA27.1 RA28.1 RA38.1 UA1.14
AUX_EN_WOWL: RZ38.2 UE1.B67 UZ3.3 UZ11.1
B-RAMP: PR502.1 PR507.2 PU500.11
BAT1_LED#: RZ28.1 UE2.B1
BAT2_LED#: RZ25.1 UE2.A55
BATDRV#: PQ800.4 PR722.2
BATT_WHITE#: JLED1.5 RZ25.2
BATT_YELLOW#: JLED1.4 RZ28.2
BBS_BIT: T109.1(TP-1) UC1.L8
BC_CLK_ECE1117: JKBTP1.7 UE2.A20
BC_CLK_ECE5048: UE1.A30 UE2.A43
BC_DAT_ECE1117: JKBTP1.9 RPE5.2 UE2.B21
BC_DAT_ECE5048: RE36.2 UE1.B31 UE2.B45
BC_INT#_ECE1117: JKBTP1.10 UE2.A19
BC_INT#_ECE5048: UE1.A29 UE2.A42
BCM5882_ALERT#: JUSH1.14 UE1.B62
BEEP: RA13.2 UE2.B19
BIA_PWM: DV1.1 LV1.2 RV1.1
BIA_PWM_EC: DV1.2 UE2.B25
BLUE: CV56.1 DV6.2 JCRT1.3 LV18.2
BLUE_2320: RV78.1 UV8.M8 UV16.5
BLUE_CRT: CV53.1 LV18.1 RV34.1 UV16.22
BLUE_DOCK: JDOCK1.45 UV16.21
BOARD_ID: CE40.1 RE79.2 UE2.B10
BOOT_1.35V: PR200.2 PU200.18
BOOT_1.35V_C: PC204.1 PR200.1
BQ24770_REGN: PC710.1 PR713.1 PR725.1 PR799.2 PU700.24
BREATH_LED#: JDOCK1.98 QZ7.4 RZ34.1 UE2.B57
BREATH_LED#_Q: QZ7.3 RZ32.1
BREATH_WHITE_LED#: JLED1.2 RZ34.2
BREATH_WHITE_LED_SNIFF#: LED3.1 RZ32.2
BST_3V: PR110.2 PU100.9
BST_3V_C: PC109.2 PR110.1
BST_5V: PR109.1 PU100.17
BST_5V_C: PC110.1 PR109.2
BST_+V1.05SP: PC302.1 PU300.6
BST_+V1.05SP_C: PC302.2 PR312.1
BT_LED#: JNGFF1.8 QZ2.4 RZ15.1
BT_RADIO_DIS#: DZ2.1 RE11.2 UE1.A13
BT_RADIO_DIS#_R: DZ2.2 JNGFF1.46
CAM_MIC_CBL_DET#: JEDP1.14 RPC15.4 UC1.F4
CD3301_DCIN: PC813.1 PR835.2 PU800.1
CD3301_SDC_IN: PR847.2 PU800.6
CD_PBATT_OFF: PR843.1 PU800.27
CFG0: JXDP1.9 RC183.1 UC1.AC60
CFG1: JXDP1.11 RC184.1 UC1.AC62
CFG2: JXDP1.15 UC1.AC63
CFG3: JXDP1.17 RC113.2 RC305.1 UC1.AA63
CFG3_R: JXDP1.60 RC113.1
CFG4: JXDP1.27 RC191.1 UC1.AA60
CFG5: JXDP1.29 UC1.Y62
CFG6: JXDP1.33 UC1.Y61
CFG7: JXDP1.35 UC1.Y60
CFG8: JXDP1.10 RC190.1 UC1.V62
CFG9: JXDP1.12 RC189.1 UC1.V61
CFG10: JXDP1.16 RC188.1 UC1.V60
CFG11: JXDP1.18 UC1.U60
CFG12: JXDP1.28 UC1.T63
CFG13: JXDP1.30 UC1.T62
CFG14: JXDP1.34 UC1.T61
CFG15: JXDP1.36 UC1.T60
CFG16: JXDP1.6 UC1.AA62
CFG17: JXDP1.4 UC1.AA61
CFG18: JXDP1.24 UC1.U63
CFG19: JXDP1.22 UC1.U62
CFG_RCOMP: RC185.1 UC1.V63
CHAGER_SRC: PC713.1 PC714.1 PC715.1 PC716.1 PC717.1 PC732.1 PJP700.2 PL700.1 PQ705.2
CHARGER_CELL_PIN: PR725.2 PR729.1 PU700.16
CHARGER_SMBCLK: PT2.1(TP-1) PU700.12 RPE6.3 UE2.B50
CHARGER_SMBDAT: PT1.1(TP-1) PU700.11 RPE6.2 UE2.A47
CHG_BTS: PR712.1 PU700.25
CHG_BTS_C: PC712.1 PR712.2
CHG_LGATE: PQ705.6 PU700.23
CHG_SNUB: PC721.1 PR726.1
CHG_SW: PC712.2 PL701.2 PQ705.7 PR726.2 PU700.27
CHG_UGATE: PQ705.1 PU700.26
CLK_27M_IN: CV115.1 RV80.1 UV8.K1 YV2.1
CLK_27M_OUT: RV80.2 RV81.2 UV8.L1
CLK_27M_OUT_R: CV113.1 RV81.1 YV2.3
CLK_BIASREF: RC69.1 UC1.C26
CLK_DDC2_2320: RV251.2 UV8.L4 UV16.10
CLK_DDC2_CRT: JCRT1.15 RV36.2 UV16.14
CLK_DDC2_DOCK: JDOCK1.48 UV16.15
CLK_KBD: JDOCK1.78 RPE2.8 UE2.A38
CLK_MSE: JDOCK1.71 RPE2.6 UE2.A39
CLK_PCI_DOCK: CC15.2 JDOCK1.121 R273.1 RC70.2
CLK_PCI_LPDEBUG: CC14.2 JLPDE1.10 RC67.2
CLK_PCI_MEC: CC13.2 RC74.2 RE66.1 UE2.A29
CLK_PCI_SIO: CC12.2 RC72.2 RE27.1 UE1.A28
CLK_PCIE_LAN: UC1.B42 UL1.44
CLK_PCIE_LAN#: UC1.C41 UL1.45
CLK_PCIE_MMI: UC1.C42 UR1.3
CLK_PCIE_MMI#: UC1.C43 UR1.2
CLK_PCIE_SATA: JNGFF2.47 UC1.A37
CLK_PCIE_SATA#: JNGFF2.45 UC1.B37
CLK_PCIE_WIGIG: JNGFF1.63 UC1.B39
CLK_PCIE_WIGIG#: JNGFF1.65 UC1.A39
CLK_PCIE_WLAN: JNGFF1.39 UC1.C37
CLK_PCIE_WLAN#: JNGFF1.41 UC1.B38
CLK_TP_SIO: CZ31.1 JKBTP1.3 RZ19.2 UE2.A37
CLKRUN#: RPC3.8 UC1.V5 UE1.B20 UE2.A32
CMPIN: PC737.1 PR737.2 PR738.1 PR745.1 PU700.13
CMPOUT: PC741.2 PR738.2 PR740.1 PR743.1 PU700.14
CONTACTLESS_DET#: JUSH1.4 RPC4.7 UC1.U6
CORE_BOOT: PC504.2 PU501.7
CORE_BOOT_C: PC504.1 PR517.2
CORE_BOOT_R: PR517.1 PU501.6
CORE_SNUB: PC508.1 PR522.2
CORE_SW: PL500.4 PR522.1 PU501.4
CPPE#: RC160.2 UC1.J1
CPU_DPB_AUX: RPC20.2 UC1.B5
CPU_DPB_AUX#: RPC20.1 UC1.C5
CPU_DPB_CTRLCLK: QV3.1 RPC2.2 UC1.B9
CPU_DPB_CTRLCLK_R: JHDMI1.15 QV3.6 RV7.1
CPU_DPB_CTRLDAT: QV3.4 RPC2.1 UC1.C9
CPU_DPB_CTRLDAT_R: JHDMI1.16 QV3.3 RV9.1
CPU_DPC_AUX: CV79.1 RPC20.3 UC1.A6
CPU_DPC_AUX#: CV80.1 RPC20.4 UC1.B6
CPU_DPC_AUX#_C: CV80.2 UV7.25
CPU_DPC_AUX_C: CV79.2 UV7.24
CPU_DPC_CTRLCLK: RPC2.3 UC1.D9
CPU_DPC_CTRLDAT: RPC2.4 UC1.D11
CPU_PWR_DEBUG#: JXDP1.45 RC197.2 RC198.1 UC1.H59
CPU_SEL: RC163.2 RC306.2 UC1.E4
CPU_XDP_PRDY#: JXDP1.5 UC1.J62
CPU_XDP_PREQ#: JXDP1.3 RC126.2 UC1.K62
CPU_XDP_TCLK: JXDP1.57 RC112.1 RC119.1 RC128.2 UC1.E60
CPU_XDP_TDI: RC125.2 UC1.F63 UC7.6
CPU_XDP_TDO: RC127.2 UC1.F62 UC7.3
CPU_XDP_TMS: RC124.2 UC1.E61 UC7.8
CPU_XDP_TRST#: RC109.1 RC129.2 UC1.E59 UC7.11
CPUSB#: RPC6.7 UC1.K3
CS_1.35V: PR201.2 PU200.13
CSN1: PC502.1 PC513.1 PL500.2 PR514.2 PR515.2 PU500.18
CSP1: PC502.2 PC513.2 PH501.1 PR512.1 PR514.1 PU500.17
CSS_GC: PR702.1 PU800.10
CSSN_1: PQ701.3 PQ703.2 PR703.1 PR705.1 PR707.1
CSSP_1: PQ702.3 PQ703.5 PR703.2 PR704.1 PR706.1
D_CLKRUN#: JDOCK1.111 RPE8.4 UE1.A19
D_DLDRQ1#: JDOCK1.117 RPE8.1 UE1.B24
D_LAD0: JDOCK1.97 UE1.B29
D_LAD1: JDOCK1.99 UE1.B28
D_LAD2: JDOCK1.103 UE1.A25
D_LAD3: JDOCK1.105 UE1.A24
D_LFRAME#: JDOCK1.109 UE1.B23
D_SERIRQ: JDOCK1.115 RPE8.3 UE1.A20
DAI_12MHZ#: JDOCK1.89 R41.1 RA30.1
DAI_BCLK#: JDOCK1.77 R6.1 RA31.1
DAI_DI: JDOCK1.83 UA1.24
DAI_DO#: JDOCK1.85 RA32.1
DAI_LRCK#: JDOCK1.79 UA1.18
DAT_DDC2_2320: RV250.2 UV8.M4 UV16.9
DAT_DDC2_CRT: JCRT1.12 RV35.2 UV16.12
DAT_DDC2_DOCK: JDOCK1.46 UV16.13
DAT_KBD: JDOCK1.80 RPE2.7 UE2.B41
DAT_MSE: JDOCK1.73 RPE2.5 UE2.B42
DAT_TP_SIO: CZ30.1 JKBTP1.4 RZ18.2 UE2.B40
DC_BLOCK_GC: PR700.2 PU800.7
DC_IN_SS: PR831.2 PU800.34
DC_TEST_A3_B3: UC1.A3 UC1.B3
DC_TEST_A4: RC192.1 UC1.A4
DC_TEST_A60: RC193.1 UC1.A60
DC_TEST_A61_B61: UC1.A61 UC1.B61
DC_TEST_A62: RC193.2 UC1.A62
DC_TEST_AV1: RC194.1 UC1.AV1
DC_TEST_AW1: RC194.2 UC1.AW1
DC_TEST_AW63: RC195.1 UC1.AW63
DC_TEST_AY2_AW2: UC1.AW2 UC1.AY2
DC_TEST_AY3_AW3: UC1.AW3 UC1.AY3
DC_TEST_AY60: RC195.2 UC1.AY60
DC_TEST_AY61_AW61: UC1.AW61 UC1.AY61
DC_TEST_AY62_AW62: UC1.AW62 UC1.AY62
DC_TEST_B62_B63: UC1.B62 UC1.B63
DC_TEST_C1_C2: UC1.C1 UC1.C2
DDI1_LANE_N0: CV29.2 UC1.C54
DDI1_LANE_N1: CV21.2 UC1.B58
DDI1_LANE_N2: CV18.2 UC1.B55
DDI1_LANE_N3: CV13.2 UC1.A57
DDI1_LANE_P0: CV28.2 UC1.C55
DDI1_LANE_P1: CV22.2 UC1.C58
DDI1_LANE_P2: CV17.2 UC1.A55
DDI1_LANE_P3: CV14.2 UC1.B57
DDI2_LANE_N0: CV72.1 UC1.C51
DDI2_LANE_N0_C: CV72.2 UV7.7
DDI2_LANE_N1: CV74.1 UC1.C53
DDI2_LANE_N1_C: CV74.2 UV7.10
DDI2_LANE_N2: CV76.1 UC1.C49
DDI2_LANE_N2_C: CV76.2 UV7.13
DDI2_LANE_N3: CV78.1 UC1.A53
DDI2_LANE_N3_C: CV78.2 UV7.16
DDI2_LANE_P0: CV71.1 UC1.C50
DDI2_LANE_P0_C: CV71.2 UV7.6
DDI2_LANE_P1: CV73.1 UC1.B54
DDI2_LANE_P1_C: CV73.2 UV7.9
DDI2_LANE_P2: CV75.1 UC1.B50
DDI2_LANE_P2_C: CV75.2 UV7.12
DDI2_LANE_P3: CV77.1 UC1.B53
DDI2_LANE_P3_C: CV77.2 UV7.15
DDR3_DRAMRST#: CC101.1 CD6.1 CD35.1 JDIMM1.30 JDIMM2.30 RD2.2 UC1.AV15
DDR_A_BS0: JDIMM1.109 UC1.AU35
DDR_A_BS1: JDIMM1.108 UC1.AV35
DDR_A_BS2: JDIMM1.79 UC1.AY41
DDR_A_CAS#: JDIMM1.115 UC1.AU34
DDR_A_D0: JDIMM1.129 UC1.AH63
DDR_A_D1: JDIMM1.131 UC1.AH62
DDR_A_D2: JDIMM1.141 UC1.AK63
DDR_A_D3: JDIMM1.140 UC1.AK62
DDR_A_D4: JDIMM1.132 UC1.AH61
DDR_A_D5: JDIMM1.130 UC1.AH60
DDR_A_D6: JDIMM1.143 UC1.AK61
DDR_A_D7: JDIMM1.142 UC1.AK60
DDR_A_D8: JDIMM1.7 UC1.AM63
DDR_A_D9: JDIMM1.4 UC1.AM62
DDR_A_D10: JDIMM1.17 UC1.AP63
DDR_A_D11: JDIMM1.18 UC1.AP62
DDR_A_D12: JDIMM1.6 UC1.AM61
DDR_A_D13: JDIMM1.5 UC1.AM60
DDR_A_D14: JDIMM1.15 UC1.AP61
DDR_A_D15: JDIMM1.16 UC1.AP60
DDR_A_D16: JDIMM1.159 UC1.AP58
DDR_A_D17: JDIMM1.157 UC1.AR58
DDR_A_D18: JDIMM1.146 UC1.AM57
DDR_A_D19: JDIMM1.148 UC1.AK57
DDR_A_D20: JDIMM1.149 UC1.AL58
DDR_A_D21: JDIMM1.147 UC1.AK58
DDR_A_D22: JDIMM1.158 UC1.AR57
DDR_A_D23: JDIMM1.160 UC1.AN57
DDR_A_D24: JDIMM1.24 UC1.AP55
DDR_A_D25: JDIMM1.22 UC1.AR55
DDR_A_D26: JDIMM1.36 UC1.AM54
DDR_A_D27: JDIMM1.34 UC1.AK54
DDR_A_D28: JDIMM1.23 UC1.AL55
DDR_A_D29: JDIMM1.21 UC1.AK55
DDR_A_D30: JDIMM1.33 UC1.AR54
DDR_A_D31: JDIMM1.35 UC1.AN54
DDR_A_D32: JDIMM1.166 UC1.AY58
DDR_A_D33: JDIMM1.165 UC1.AW58
DDR_A_D34: JDIMM1.175 UC1.AY56
DDR_A_D35: JDIMM1.174 UC1.AW56
DDR_A_D36: JDIMM1.163 UC1.AV58
DDR_A_D37: JDIMM1.164 UC1.AU58
DDR_A_D38: JDIMM1.177 UC1.AV56
DDR_A_D39: JDIMM1.176 UC1.AU56
DDR_A_D40: JDIMM1.42 UC1.AY54
DDR_A_D41: JDIMM1.41 UC1.AW54
DDR_A_D42: JDIMM1.50 UC1.AY52
DDR_A_D43: JDIMM1.51 UC1.AW52
DDR_A_D44: JDIMM1.39 UC1.AV54
DDR_A_D45: JDIMM1.40 UC1.AU54
DDR_A_D46: JDIMM1.52 UC1.AV52
DDR_A_D47: JDIMM1.53 UC1.AU52
DDR_A_D48: JDIMM1.69 UC1.AK40
DDR_A_D49: JDIMM1.67 UC1.AK42
DDR_A_D50: JDIMM1.59 UC1.AM43
DDR_A_D51: JDIMM1.57 UC1.AM45
DDR_A_D52: JDIMM1.56 UC1.AK45
DDR_A_D53: JDIMM1.58 UC1.AK43
DDR_A_D54: JDIMM1.68 UC1.AM40
DDR_A_D55: JDIMM1.70 UC1.AM42
DDR_A_D56: JDIMM1.192 UC1.AM46
DDR_A_D57: JDIMM1.194 UC1.AK46
DDR_A_D58: JDIMM1.183 UC1.AM49
DDR_A_D59: JDIMM1.182 UC1.AK49
DDR_A_D60: JDIMM1.191 UC1.AM48
DDR_A_D61: JDIMM1.193 UC1.AK48
DDR_A_D62: JDIMM1.181 UC1.AM51
DDR_A_D63: JDIMM1.180 UC1.AK51
DDR_A_DQS0: JDIMM1.137 UC1.AJ62
DDR_A_DQS1: JDIMM1.12 UC1.AN61
DDR_A_DQS2: JDIMM1.154 UC1.AN58
DDR_A_DQS3: JDIMM1.29 UC1.AN55
DDR_A_DQS4: JDIMM1.171 UC1.AW57
DDR_A_DQS5: JDIMM1.47 UC1.AW53
DDR_A_DQS6: JDIMM1.64 UC1.AL42
DDR_A_DQS7: JDIMM1.188 UC1.AL49
DDR_A_DQS#0: JDIMM1.135 UC1.AJ61
DDR_A_DQS#1: JDIMM1.10 UC1.AN62
DDR_A_DQS#2: JDIMM1.152 UC1.AM58
DDR_A_DQS#3: JDIMM1.27 UC1.AM55
DDR_A_DQS#4: JDIMM1.169 UC1.AV57
DDR_A_DQS#5: JDIMM1.45 UC1.AV53
DDR_A_DQS#6: JDIMM1.62 UC1.AL43
DDR_A_DQS#7: JDIMM1.186 UC1.AL48
DDR_A_MA0: JDIMM1.98 UC1.AU36
DDR_A_MA1: JDIMM1.97 UC1.AY37
DDR_A_MA2: JDIMM1.96 UC1.AR38
DDR_A_MA3: JDIMM1.95 UC1.AP36
DDR_A_MA4: JDIMM1.92 UC1.AU39
DDR_A_MA5: JDIMM1.91 UC1.AR36
DDR_A_MA6: JDIMM1.90 UC1.AV40
DDR_A_MA7: JDIMM1.86 UC1.AW39
DDR_A_MA8: JDIMM1.89 UC1.AY39
DDR_A_MA9: JDIMM1.85 UC1.AU40
DDR_A_MA10: JDIMM1.107 UC1.AP35
DDR_A_MA11: JDIMM1.84 UC1.AW41
DDR_A_MA12: JDIMM1.83 UC1.AU41
DDR_A_MA13: JDIMM1.119 UC1.AR35
DDR_A_MA14: JDIMM1.80 UC1.AV42
DDR_A_MA15: JDIMM1.78 UC1.AU42
DDR_A_RAS#: JDIMM1.110 UC1.AY34
DDR_A_WE#: JDIMM1.113 UC1.AW34
DDR_B_BS0: JDIMM2.109 UC1.AL35
DDR_B_BS1: JDIMM2.108 UC1.AM36
DDR_B_BS2: JDIMM2.79 UC1.AU49
DDR_B_CAS#: JDIMM2.115 UC1.AM33
DDR_B_D0: JDIMM2.132 UC1.AY31
DDR_B_D1: JDIMM2.131 UC1.AW31
DDR_B_D2: JDIMM2.140 UC1.AY29
DDR_B_D3: JDIMM2.141 UC1.AW29
DDR_B_D4: JDIMM2.129 UC1.AV31
DDR_B_D5: JDIMM2.130 UC1.AU31
DDR_B_D6: JDIMM2.142 UC1.AV29
DDR_B_D7: JDIMM2.143 UC1.AU29
DDR_B_D8: JDIMM2.5 UC1.AY27
DDR_B_D9: JDIMM2.6 UC1.AW27
DDR_B_D10: JDIMM2.15 UC1.AY25
DDR_B_D11: JDIMM2.17 UC1.AW25
DDR_B_D12: JDIMM2.4 UC1.AV27
DDR_B_D13: JDIMM2.16 UC1.AU27
DDR_B_D14: JDIMM2.7 UC1.AV25
DDR_B_D15: JDIMM2.18 UC1.AU25
DDR_B_D16: JDIMM2.146 UC1.AM29
DDR_B_D17: JDIMM2.148 UC1.AK29
DDR_B_D18: JDIMM2.160 UC1.AL28
DDR_B_D19: JDIMM2.158 UC1.AK28
DDR_B_D20: JDIMM2.149 UC1.AR29
DDR_B_D21: JDIMM2.147 UC1.AN29
DDR_B_D22: JDIMM2.157 UC1.AR28
DDR_B_D23: JDIMM2.159 UC1.AP28
DDR_B_D24: JDIMM2.24 UC1.AN26
DDR_B_D25: JDIMM2.22 UC1.AR26
DDR_B_D26: JDIMM2.33 UC1.AR25
DDR_B_D27: JDIMM2.35 UC1.AP25
DDR_B_D28: JDIMM2.21 UC1.AK26
DDR_B_D29: JDIMM2.23 UC1.AM26
DDR_B_D30: JDIMM2.34 UC1.AK25
DDR_B_D31: JDIMM2.36 UC1.AL25
DDR_B_D32: JDIMM2.166 UC1.AY23
DDR_B_D33: JDIMM2.165 UC1.AW23
DDR_B_D34: JDIMM2.174 UC1.AY21
DDR_B_D35: JDIMM2.175 UC1.AW21
DDR_B_D36: JDIMM2.163 UC1.AV23
DDR_B_D37: JDIMM2.164 UC1.AU23
DDR_B_D38: JDIMM2.176 UC1.AV21
DDR_B_D39: JDIMM2.177 UC1.AU21
DDR_B_D40: JDIMM2.39 UC1.AY19
DDR_B_D41: JDIMM2.41 UC1.AW19
DDR_B_D42: JDIMM2.53 UC1.AY17
DDR_B_D43: JDIMM2.52 UC1.AW17
DDR_B_D44: JDIMM2.42 UC1.AV19
DDR_B_D45: JDIMM2.40 UC1.AU19
DDR_B_D46: JDIMM2.51 UC1.AV17
DDR_B_D47: JDIMM2.50 UC1.AU17
DDR_B_D48: JDIMM2.191 UC1.AR21
DDR_B_D49: JDIMM2.183 UC1.AR22
DDR_B_D50: JDIMM2.194 UC1.AL21
DDR_B_D51: JDIMM2.180 UC1.AM22
DDR_B_D52: JDIMM2.181 UC1.AN22
DDR_B_D53: JDIMM2.193 UC1.AP21
DDR_B_D54: JDIMM2.192 UC1.AK21
DDR_B_D55: JDIMM2.182 UC1.AK22
DDR_B_D56: JDIMM2.57 UC1.AN20
DDR_B_D57: JDIMM2.59 UC1.AR20
DDR_B_D58: JDIMM2.69 UC1.AK18
DDR_B_D59: JDIMM2.67 UC1.AL18
DDR_B_D60: JDIMM2.58 UC1.AK20
DDR_B_D61: JDIMM2.56 UC1.AM20
DDR_B_D62: JDIMM2.70 UC1.AR18
DDR_B_D63: JDIMM2.68 UC1.AP18
DDR_B_DQS0: JDIMM2.137 UC1.AV30
DDR_B_DQS1: JDIMM2.12 UC1.AW26
DDR_B_DQS2: JDIMM2.154 UC1.AM28
DDR_B_DQS3: JDIMM2.29 UC1.AM25
DDR_B_DQS4: JDIMM2.171 UC1.AV22
DDR_B_DQS5: JDIMM2.47 UC1.AW18
DDR_B_DQS6: JDIMM2.188 UC1.AM21
DDR_B_DQS7: JDIMM2.64 UC1.AM18
DDR_B_DQS#0: JDIMM2.135 UC1.AW30
DDR_B_DQS#1: JDIMM2.10 UC1.AV26
DDR_B_DQS#2: JDIMM2.152 UC1.AN28
DDR_B_DQS#3: JDIMM2.27 UC1.AN25
DDR_B_DQS#4: JDIMM2.169 UC1.AW22
DDR_B_DQS#5: JDIMM2.45 UC1.AV18
DDR_B_DQS#6: JDIMM2.186 UC1.AN21
DDR_B_DQS#7: JDIMM2.62 UC1.AN18
DDR_B_MA0: JDIMM2.98 UC1.AP40
DDR_B_MA1: JDIMM2.97 UC1.AR40
DDR_B_MA2: JDIMM2.96 UC1.AP42
DDR_B_MA3: JDIMM2.95 UC1.AR42
DDR_B_MA4: JDIMM2.92 UC1.AR45
DDR_B_MA5: JDIMM2.91 UC1.AP45
DDR_B_MA6: JDIMM2.90 UC1.AW46
DDR_B_MA7: JDIMM2.86 UC1.AY46
DDR_B_MA8: JDIMM2.89 UC1.AY47
DDR_B_MA9: JDIMM2.85 UC1.AU46
DDR_B_MA10: JDIMM2.107 UC1.AK36
DDR_B_MA11: JDIMM2.84 UC1.AV47
DDR_B_MA12: JDIMM2.83 UC1.AU47
DDR_B_MA13: JDIMM2.119 UC1.AK33
DDR_B_MA14: JDIMM2.80 UC1.AR46
DDR_B_MA15: JDIMM2.78 UC1.AP46
DDR_B_RAS#: JDIMM2.110 UC1.AM35
DDR_B_WE#: JDIMM2.113 UC1.AK35
DDR_CKE0_DIMMA: JDIMM1.73 UC1.AU43
DDR_CKE1_DIMMA: JDIMM1.74 UC1.AW43
DDR_CKE2_DIMMB: JDIMM2.73 UC1.AY49
DDR_CKE3_DIMMB: JDIMM2.74 UC1.AU50
DDR_CS0_DIMMA#: JDIMM1.114 UC1.AP33
DDR_CS1_DIMMA#: JDIMM1.121 UC1.AR32
DDR_CS2_DIMMB#: JDIMM2.114 UC1.AM32
DDR_CS3_DIMMB#: JDIMM2.121 UC1.AK32
DDR_PG_CTRL: UC1.AV61 UD1.2
DDR_XDP_WAN_SMBCLK: JDIMM1.202 JDIMM2.202 JXDP1.53 QC1.1 RN4.2 UN1.4
DDR_XDP_WAN_SMBDAT: JDIMM1.200 JDIMM2.200 JXDP1.51 QC1.4 RN3.2 UN1.6
DEW1: RN20.2 RN21.2 UN2.16
DEW2: RN18.2 RN19.2 UN2.6
DGPU_PWROK: RPC18.5 UC1.P4
DH_1.35V: PQ200.4 PU200.17
DIMM_DET: RC302.2 RC303.1 UC1.U4
DIS_BAT_PROCHOT#: PR812.1 UE1.B51
DISP_ON: DV2.1 JEDP1.22 RV2.1
DK_AC_OFF: PD815.3 PU800.25
DK_AC_OFF_EN: PR850.1 PU800.22
DK_CSS_GC: PR709.1 PU800.11
DK_PWRBAR: PR832.1 PU800.33
DL_1.35V: PQ201.4 PU200.15
DMIC0: CA6.1 JEDP1.7 UA1.47
DMIC1: MIC1.5 UA1.4
DMIC_CLK0: CA5.1 CA54.1 JEDP1.9 RA14.2
DMIC_CLK1: CA30.1 MIC1.4 RA40.2
DMIC_CLK_L: RA14.1 RA40.1 UA1.2
DOCK_AC_OFF: JDOCK1.2 PD815.1 PR844.1
DOCK_AC_OFF_EC: PR850.2 PR858.1 UE1.A63
DOCK_DCIN_IS+: JDOCK1.134 PQ703.6
DOCK_DCIN_IS-: JDOCK1.136 PQ703.4
DOCK_DET#: D19.2 PQ817.2 PR853.1 R272.1 UE1.B41
DOCK_DET_R#: D19.1 JDOCK1.142 JDOCK1.144
DOCK_HP_DET: QA3.2 RA29.2 UE1.A7
DOCK_LOM_ACTLED_YEL#: JDOCK1.100 UL4.19
DOCK_LOM_SPD10LED_GRN#: JDOCK1.3 UL4.40
DOCK_LOM_SPD100LED_ORG#: JDOCK1.4 UL4.20
DOCK_LOM_TRD0+: JDOCK1.104 UL4.36
DOCK_LOM_TRD0-: JDOCK1.106 UL4.35
DOCK_LOM_TRD1+: JDOCK1.110 UL4.32
DOCK_LOM_TRD1-: JDOCK1.112 UL4.31
DOCK_LOM_TRD2+: JDOCK1.122 UL4.27
DOCK_LOM_TRD2-: JDOCK1.124 UL4.26
DOCK_LOM_TRD3+: JDOCK1.128 UL4.23
DOCK_LOM_TRD3-: JDOCK1.130 UL4.22
DOCK_MIC_DET: QA3.5 RA26.2 UE1.B8
DOCK_POR_RST#: JDOCK1.140 RE277.2 UE2.A21
DOCK_PSID: JDOCK1.135 PU1.1
DOCK_PWR_BTN#: CE44.1 JDOCK1.139 RE42.2
DOCK_PWR_SW#: CE45.1 RE42.1 RE62.2 UE2.A63
DOCK_SMB_ALERT#: JDOCK1.133 PQ1.3 RE9.2 UE1.A51
DOCK_SMB_CLK: JDOCK1.127 RPE3.2 UE2.B4
DOCK_SMB_DAT: JDOCK1.129 RPE3.1 UE2.A3
DOCK_USB3RN1: JDOCK1.84 UI4.22
DOCK_USB3RP1: JDOCK1.86 UI4.23
DOCK_USB3TN1: JDOCK1.90 UI4.24
DOCK_USB3TP1: JDOCK1.92 UI4.25
DOCK_USBP0+: JDOCK1.72 UI4.15
DOCK_USBP0-: JDOCK1.74 UI4.14
DOCK_USBP3+: JDOCK1.66 UI5.3
DOCK_USBP3-: JDOCK1.68 UI5.4
DOCKED: QV11.2 UE1.A38 UI4.10 UI4.32 UL4.13 UV16.30
DOCKED_LIO_EN: UE1.B52 UI5.9
DPB_CA_DET: JDOCK1.6 QV9.2 RV508.2 UV8.M14 UV11.1 UV11.4
DPB_CA_DET#: QV9.1 RV90.2 UV11.10 UV11.13
DPB_DOCK_AUX: JDOCK1.34 UV11.3 UV11.11
DPB_DOCK_AUX#: JDOCK1.36 UV11.6 UV11.8
DPB_DOCK_HPD: C311.1 JDOCK1.40 R271.1 UV8.K14
DPB_DOCK_LANE_N0: JDOCK1.12 R261.1
DPB_DOCK_LANE_N1: JDOCK1.18 R256.1
DPB_DOCK_LANE_N2: JDOCK1.24 R264.1
DPB_DOCK_LANE_N3: JDOCK1.30 R267.1
DPB_DOCK_LANE_P0: JDOCK1.10 R260.1
DPB_DOCK_LANE_P1: JDOCK1.16 R254.1
DPB_DOCK_LANE_P2: JDOCK1.22 R262.1
DPB_DOCK_LANE_P3: JDOCK1.28 R258.1
DPB_HPD: QV5.3 RV18.1 UC1.C8
DPB_LANE_N0: C296.1 UV8.E14
DPB_LANE_N0_C: C296.2 R261.2
DPB_LANE_N1: C303.1 UV8.F14
DPB_LANE_N1_C: C303.2 R256.2
DPB_LANE_N2: C307.1 UV8.G14
DPB_LANE_N2_C: C307.2 R264.2
DPB_LANE_N3: C309.1 UV8.H14
DPB_LANE_N3_C: C309.2 R267.2
DPB_LANE_P0: C294.1 UV8.E13
DPB_LANE_P0_C: C294.2 R260.2
DPB_LANE_P1: C298.1 UV8.F13
DPB_LANE_P1_C: C298.2 R254.2
DPB_LANE_P2: C305.1 UV8.G13
DPB_LANE_P2_C: C305.2 R262.2
DPB_LANE_P3: C308.1 UV8.H13
DPB_LANE_P3_C: C308.2 R258.2
DPC_CA_DET: JDOCK1.5 QV10.2 RV509.2 UV8.A14 UV12.1 UV12.4
DPC_CA_DET#: QV10.1 RV91.2 UV12.10 UV12.13
DPC_DOCK_AUX: JDOCK1.33 UV12.3 UV12.11
DPC_DOCK_AUX#: JDOCK1.35 UV12.6 UV12.8
DPC_DOCK_HPD: C310.1 JDOCK1.39 R268.1 UV8.A6
DPC_DOCK_LANE_N0: JDOCK1.11 R252.2
DPC_DOCK_LANE_N1: JDOCK1.17 R255.2
DPC_DOCK_LANE_N2: JDOCK1.23 R263.2
DPC_DOCK_LANE_N3: JDOCK1.29 R266.2
DPC_DOCK_LANE_P0: JDOCK1.9 R259.2
DPC_DOCK_LANE_P1: JDOCK1.15 R253.2
DPC_DOCK_LANE_P2: JDOCK1.21 R257.2
DPC_DOCK_LANE_P3: JDOCK1.27 R265.2
DPC_HPD: RC142.2 UC1.A8 UV7.3
DPC_LANE_N0: C295.2 UV8.A7
DPC_LANE_N0_C: C295.1 R252.1
DPC_LANE_N1: C299.2 UV8.A8
DPC_LANE_N1_C: C299.1 R255.1
DPC_LANE_N2: C306.2 UV8.A9
DPC_LANE_N2_C: C306.1 R263.1
DPC_LANE_N3: C301.2 UV8.A10
DPC_LANE_N3_C: C301.1 R266.1
DPC_LANE_P0: C302.2 UV8.B7
DPC_LANE_P0_C: C302.1 R259.1
DPC_LANE_P1: C297.2 UV8.B8
DPC_LANE_P1_C: C297.1 R253.1
DPC_LANE_P2: C304.2 UV8.B9
DPC_LANE_P2_C: C304.1 R257.1
DPC_LANE_P3: C300.2 UV8.B10
DPC_LANE_P3_C: C300.1 R265.1
DSWODVREN: RC78.1 UC1.AW7
EC5048_TX: JDEG1.9 RE74.2 UE1.B2
EC_32KHZ_MEC5085: UE1.B35 UE2.B2 UZ11.2
EDP_BIA_PWM: DV1.3 UC1.B8
EDP_COMP: RC133.2 UC1.D20
EDP_CPU_AUX: CV2.1 UC1.B45
EDP_CPU_AUX#: CV1.1 UC1.A45
EDP_CPU_AUX#_C: CV1.2 JEDP1.33
EDP_CPU_AUX_C: CV2.2 JEDP1.34
EDP_CPU_HPD: JEDP1.26 RC141.2 UC1.D6
EDP_CPU_LANE_N0: CV4.1 UC1.C45
EDP_CPU_LANE_N0_C: CV4.2 JEDP1.36
EDP_CPU_LANE_N1: CV6.1 UC1.A47
EDP_CPU_LANE_N1_C: CV6.2 JEDP1.38
EDP_CPU_LANE_P0: CV3.1 UC1.B46
EDP_CPU_LANE_P0_C: CV3.2 JEDP1.35
EDP_CPU_LANE_P1: CV5.1 UC1.B47
EDP_CPU_LANE_P1_C: CV5.2 JEDP1.37
EN: PC119.1 PR113.2 PU100.6 PU100.20
EN_+V1.05SP: PR303.1 PU300.1 RZ41.2 RZ42.2
EN_DK_PWRBAR: PR857.1 PR874.1 PU800.17
EN_DOCK_PWR_BAR: PR857.2 UE1.B37
EN_I2S_NB_CODEC#: UA1.1 UE1.B36
EN_INVPWR: QV2.2 RE55.2 UE2.A25
EN_LCDPWR: DV3.1 RV3.2 UV24.3
ENVDD_PCH: DV3.3 RC139.2 UC1.C6 UE2.A7
ERC1: PC815.1 PU800.3
ERC2: PC817.1 PU800.13
ERC3: PC816.1 PU800.12
EXPRESS_DET#: T97.1(TP-1) UE1.B15
F-IMAX: PR503.1 PR508.2 PU500.10
FAN1_PWM: JFAN1.2 RE48.2 UE2.A24
FAN1_TACH: JFAN1.3 RE51.2 UE2.B22
FB_3V: PR100.2 PR102.2 PU100.4
FB_5V: PR101.1 PR104.1 PU100.2
FB_+V1.05SP: PR307.2 PR309.2 PR310.1 PU300.4
FFS_INT2: QN1.2 RC158.2 UC1.G2 UN1.9
FFS_INT2_Q: JSATA1.19 QN1.3 RN1.2
FWP#: RE81.2 RE82.2 UE2.B65
GC6_EVENT#_Q: RPC4.8 UC1.R6
GFB: PR532.2 PU500.23
GPIO_PSID_SELECT: PU1.6 UE1.A6
GPU_GC6_FB_EN: RPC15.3 UC1.L6
GPU_SMBCLK: RPE3.4 UE2.B49
GPU_SMBDAT: RPE3.3 UE2.B48
GREEN: CV55.1 DV5.3 JCRT1.2 LV17.2
GREEN_2320: RV77.1 UV8.M7 UV16.2
GREEN_CRT: CV52.1 LV17.1 RV33.1 UV16.25
GREEN_DOCK: JDOCK1.59 UV16.24
H_CATERR#: RC114.2 UC1.K61
H_CPU_SVIDALRT#: RC207.1 UC1.L62
H_CPUPWRGD: CC83.1 RC103.1 RC123.1 UC1.C61
H_PROCHOT#: CC20.1 PC514.2 PR534.1 PR717.1 RC116.2 RC121.1 UE2.A46
H_PROCHOT#_R: RC121.2 UC1.K63
H_THERMTRIP#: QE4.3 RC25.2 RC161.1
H_THERMTRIP#_R: RC161.2 UC1.D60
H_VCCST_PWRGD: CC24.1 RC102.1 RC202.1 UC1.B59 UC8.4
H_VCCST_PWRGD_XDP: JXDP1.39 RC102.2 RC103.2
H_VR_EN: PR536.1 RC201.2 UC1.F60
H_VR_READY: PR539.2 RC199.2 RC201.1 UC1.C59
HDD_A_EQ: RN12.1 RN13.2 UN2.17
HDD_A_EQ2: RN24.2 RN25.1 UN2.18
HDD_A_PRE: RN8.2 RN9.2 UN2.9
HDD_B_EQ: RN14.2 RN16.2 UN2.19
HDD_B_EQ2: RN22.2 RN23.1 UN2.13
HDD_B_PRE: RN10.1 RN11.2 UN2.8
HDD_DET#: JSATA1.13 RPC17.6 UC1.U1
HDD_DEVSLP: JSATA1.11 RN5.2 UC1.L2
HDD_FALL_INT: RPC18.6 UC1.N4 UN1.11
HDMI_CEC: JHDMI1.13 RV8.2
HDMI_HPD_SINK: JHDMI1.19 QV5.1 RV20.1
HDMI_OB: QV4.1 RV10.2 RV11.2 RV12.2 RV13.2 RV14.2 RV15.2 RV16.2 RV17.2
HOST_ALERT1_R_N: RC179.2 UC1.AD6
HOST_DEBUG_TX: JDEG1.8 RE73.2 UE2.B44
HSYNC_2320: UV8.M9 UV16.6
HSYNC_CONN: CV59.1 JCRT1.13 LV19.2 RV38.2
HSYNC_CRT: LV19.1 UV16.20
HSYNC_DOCK: JDOCK1.65 UV16.19
HW_GPS_DISABLE2#: DZ6.1 RE12.2 UE1.A35
HW_GPS_DISABLE2#_R: DZ6.2 JNGFF2.18
I2C1_SCL_VMM: RPV2.4 UV8.A2
I2C1_SDA_VMM: RPV2.3 UV8.A1
I2S_BCLK: RA31.2 UA1.16
I2S_DO: RA32.2 UA1.17
I2S_MCLK: RA30.2 UA1.15
I_ADP: PR716.1 UE2.A12
I_BATT: PR718.1 RE64.2
I_SYS: PR720.1 UE2.A57
ILIM_SEL: RI13.1 UI3.4
ILMT_1.05V: PR306.2 PR308.1 PU300.3
IMON: PC500.2 PR501.2 PU500.13
INT_SPK_L+: CA22.1 LA6.1 UA1.42
INT_SPK_L-: CA23.1 LA7.1 UA1.43
INT_SPK_R+: CA19.1 LA8.1 UA1.45
INT_SPK_R-: CA24.1 LA9.1 UA1.44
INT_SPKR_L+: DA6.2 JSPK1.1 LA6.2
INT_SPKR_L-: DA6.3 JSPK1.2 LA7.2
INT_SPKR_R+: DA7.2 JSPK1.3 LA8.2
INT_SPKR_R-: DA7.3 JSPK1.4 LA9.2
INTRUDER#: RC9.2 UC1.AU6
IO_LDOSEL: RR6.2 RR8.1 UR1.18
IRQ_SERIRQ: RPC4.6 UC1.T4 UE1.B21 UE2.A28
JCRT-11: JCRT1.11 T87.1(TP-1)
JTAG_CLK: JDEG1.4 RPE7.3 UE2.B56
JTAG_RST#: CE30.1 JTAG1.1 RE63.2 RE65.1 UE2.B47
JTAG_TDI: JDEG1.2 RPE7.1 UE2.A51
JTAG_TDO: JDEG1.5 RPE7.4 UE2.B55
JTAG_TMS: JDEG1.3 RPE7.2 UE2.A53
KB_DET#: JKBTP1.16 RPC7.7 UC1.AT3
LAN_ACTLED_YEL#: QL1.6 RL14.1
LAN_ACTLED_YEL_R#: JLOM1.10 RL14.2
LAN_DISABLE#_R: RL5.2 RL7.2 RL9.1 UE1.B53 UL1.3
LAN_TEST_EN: RL12.1 UL1.30
LAN_TX0+: RL21.1 UL1.13
LAN_TX0+L: RL21.2 UL4.2
LAN_TX0-: RL22.1 UL1.14
LAN_TX0-L: RL22.2 UL4.3
LAN_TX1+: RL23.1 UL1.17
LAN_TX1+L: RL23.2 UL4.6
LAN_TX1-: RL24.1 UL1.18
LAN_TX1-L: RL24.2 UL4.7
LAN_TX2+: RL25.1 UL1.20
LAN_TX2+L: RL25.2 UL4.9
LAN_TX2-: RL26.1 UL1.21
LAN_TX2-L: RL26.2 UL4.10
LAN_TX3+: RL27.1 UL1.23
LAN_TX3+L: RL27.2 UL4.11
LAN_TX3-: RL28.1 UL1.24
LAN_TX3-L: RL28.2 UL4.12
LAN_WAKE#: RC153.1 UC1.AN5 UE2.B27 UL1.2
LANCLK_REQ#: RL4.1 RPC5.7 UC1.AD1 UL1.48
LCD_CBL_DET#: JEDP1.40 RPC6.8 UC1.J3
LCD_TST: JEDP1.29 RE20.2 UE1.A36
LCD_VCC_TEST_EN: DV3.2 UE1.A40
LED_10_GRN#: QL2.6 RL19.1
LED_10_GRN_R#: JLOM1.11 RL19.2
LED_100_ORG#: QL1.3 RL20.1
LED_100_ORG_R#: JLOM1.13 RL20.2
LED_SATA_DIAG_OUT#: DZ4.1 UE1.A10
LG_3V: PQ102.4 PU100.11
LG_5V: PQ103.4 PU100.15
LID_CL#: JLED1.7 RE26.1 UZ10.2
LID_CL_SIO#: CE8.1 RE25.2 RE26.2 UE1.B54
LOM_ACTLED_YEL#: UL1.26 UL4.15
LOM_SPD10LED_GRN#: UL1.25 UL2.2 UL4.42
LOM_SPD100LED_ORG#: UL1.27 UL2.1 UL4.16
LP_CTL: RV79.1 RV516.1 UV8.B2
LP_EN: QV21.2 UV8.A5
LP_EN#: QV21.5 QV21.6 RV212.2
LPC_LAD0: JLPDE1.3 UC1.AU14 UE1.A27 UE2.A30
LPC_LAD1: JLPDE1.4 UC1.AW12 UE1.A26 UE2.B32
LPC_LAD2: JLPDE1.5 UC1.AY12 UE1.B26 UE2.A31
LPC_LAD3: JLPDE1.6 UC1.AW11 UE1.B25 UE2.B33
LPC_LDRQ1#: RPE8.2 UE1.A22
LPC_LFRAME#: JLPDE1.7 UC1.AV12 UE1.A21 UE2.B31
M_CLK_DDR0: JDIMM1.101 UC1.AV37
M_CLK_DDR1: JDIMM1.102 UC1.AY36
M_CLK_DDR2: JDIMM2.101 UC1.AN38
M_CLK_DDR3: JDIMM2.102 UC1.AL38
M_CLK_DDR#0: JDIMM1.103 UC1.AU37
M_CLK_DDR#1: JDIMM1.104 UC1.AW36
M_CLK_DDR#2: JDIMM2.103 UC1.AM38
M_CLK_DDR#3: JDIMM2.104 UC1.AK38
M_ID2#: CV57.1 JCRT1.4
M_ODT0: JDIMM1.116 RD10.2
M_ODT1: JDIMM1.120 RD11.2
M_ODT2: JDIMM2.116 RD12.2
M_ODT3: JDIMM2.120 RD13.2
MASK_BASE_LEDS#: QZ7.5 UZ10.4
MASK_SATA_LED#: QZ3.5 UE1.B9
MCARD_PCIE#_SATA: RPC9.5 UC1.AC1 UE2.B8
MCP_TESTLOW1: RC240.1 UC1.C35
MCP_TESTLOW2: RC241.1 UC1.C34
MCP_TESTLOW3: RC242.1 UC1.AK8
MCP_TESTLOW4: RC243.1 UC1.AL8
ME_FWP: RC11.1 RC301.1 SW1.3
ME_FWP_EC: RC301.2 SW1.1 UE2.B46
ME_RESET#: RC80.1 RC95.2 UC4.2
ME_SUS_PWR_ACK: RC79.2 UC1.AV4 UE2.A8
MEC_XTAL1: CE28.1 UE2.A61 YE1.1
MEC_XTAL2: CE29.1 RE61.2 YE1.2
MEC_XTAL2_R: RE61.1 UE2.A62
MEDIACARD_IRQ#: RPC9.8 UC1.AB6 UR1.16
MEDIACARD_PWREN: RR15.2 UR1.14
MEDIACARD_RST#: RPC10.8 UC1.AG6
MEM_SMBCLK: QC1.6 RPC14.1 UC1.AP2
MEM_SMBDATA: QC1.3 RPC14.2 UC1.AH1
MIC1_L: CA43.1 UA1.19
MIC1_R: CA44.1 UA1.20
MMICLK_REQ#: RPC17.7 UC1.U2 UR1.17
MPCIE_RST#: RPC17.5 UC1.V1
MPHYP_PWR_EN: QZ10.2 RC155.1 RC171.1 UC1.Y2
MPHYP_PWR_EN#: QZ10.5 QZ10.6 RZ16.2
MSATA_DEVSLP: JNGFF2.30 RZ39.2 UC1.P2
MSCLK: JDEG1.6 RE72.2 UE2.B43
MSDATA: JDEG1.7 RE75.2 RE86.2 UE2.A40
NB_LAN_TX0+: JLOM1.1 TL1.19
NB_LAN_TX0-: JLOM1.2 TL1.20
NB_LAN_TX1+: JLOM1.3 TL1.23
NB_LAN_TX1-: JLOM1.6 TL1.24
NB_LAN_TX2+: JLOM1.4 TL1.13
NB_LAN_TX2-: JLOM1.5 TL1.14
NB_LAN_TX3+: JLOM1.7 TL1.17
NB_LAN_TX3-: JLOM1.8 TL1.18
NB_PSID: PJPDC1.1 PL3.2
NB_PSID_TS5A63157: PR8.1 PR9.2 PU1.3
NFC_IRQ: RC175.1 UC1.AN3
NGFF_CONFIG_0: JNGFF2.13 RPE4.1 UE1.B12
NGFF_CONFIG_1: JNGFF2.61 RPE4.2 UE1.A18
NGFF_CONFIG_2: JNGFF2.67 RPE4.3 UE1.A44
NGFF_CONFIG_3: JNGFF2.1 RPE4.4 UE1.B34
O-USR: PR504.1 PR509.2 PU500.9
OCP-I: PR501.1 PR506.2 PR524.2 PU500.12
OUT1_CA_DET: RV67.2 UV7.43
OUT2_CA_DET: RV68.2 UV7.33
P33ALW: PR859.1 PU800.18
P33ALW2: PR855.2 PU800.9
PANEL_BKEN_EC: DV2.2 UE1.B38
PANEL_BKLEN: DV2.3 UC1.A9
PBAT_PRES#: PD4.1 PR2.2 PR728.1 PRP2.1 PU804.1 UE2.A49
PBAT_PRES#_C: PBATT1.6 PD2.2 PRP2.8
PBAT_SMBCLK: PRP2.3 RE43.2 UE2.A56
PBAT_SMBCLK_C: PBATT1.4 PD1.2 PRP2.6
PBAT_SMBDAT: PRP2.2 RE37.2 UE2.B59
PBAT_SMBDAT_C: PBATT1.5 PD1.3 PRP2.7
PBATT+_C: PBATT1.1 PBATT1.2 PBATT1.3 PC3.1 PL1.1 PL2.1
PCH_ALW_ON: RPE10.4 UE2.A34 UZ8.5
PCH_AZ_BITCLK: RC23.2 UC1.AW8
PCH_AZ_CODEC_BITCLK: CC5.1 RA17.1 RC23.1 UA1.6
PCH_AZ_CODEC_RST#: RC22.1 UA1.11
PCH_AZ_CODEC_SDIN0: RA9.1 UC1.AY10
PCH_AZ_CODEC_SDOUT: RC19.1 UA1.5
PCH_AZ_CODEC_SYNC: RC20.1 UA1.10
PCH_AZ_RST#: RC22.2 UC1.AU8
PCH_AZ_SDIN0_R: RA9.2 UA1.8
PCH_AZ_SDOUT: RC11.2 RC19.2 UC1.AU11
PCH_AZ_SYNC: RC20.2 UC1.AV11
PCH_BATLOW#: RPC19.1 UC1.AN4
PCH_CL_CLK1: JNGFF1.34 UC1.AF2
PCH_CL_DATA1: JNGFF1.32 UC1.AD2
PCH_CL_RST1#: JNGFF1.30 UC1.AF4
PCH_DPWROK: UC1.AV5 UE2.A36
PCH_GPIO4: RPC8.3 UC1.F2
PCH_GPIO5: RPC8.4 UC1.F3
PCH_GPIO6: RPC8.1 UC1.G4
PCH_GPIO7: RPC8.2 UC1.F1
PCH_GPIO9: RPC19.4 UC1.AM3
PCH_GPIO10: T27.1(TP-1) UC1.AM2
PCH_GPIO14: T21.1(TP-1) UC1.AH4
PCH_GPIO16: RPC5.8 UC1.Y1
PCH_GPIO19: RC66.2 UC1.Y5
PCH_GPIO44: RPC5.5 UC1.AK4
PCH_GPIO46: RPC1.7 UC1.AG3
PCH_GPIO49: T22.1(TP-1) UC1.Y3
PCH_GPIO52: RPC16.8 UC1.L1
PCH_GPIO53: RC140.1 UC1.L4
PCH_GPIO57: RPC7.5 UC1.AP1
PCH_GPIO59: RC245.1 UC1.AT5
PCH_GPIO66: RC176.2 RC181.1 UC1.D3
PCH_GPIO68: RC164.2 UC1.C3
PCH_GPIO69: RPC6.5 UC1.E2
PCH_GPIO73: RPC1.5 UC1.AU4
PCH_GPIO76: RPC17.8 UC1.P1
PCH_GPIO80: RPC16.7 UC1.N2
PCH_GPIO85: RPC18.7 UC1.N6
PCH_GPIO87: RPC9.7 UC1.R7
PCH_INTVRMEN: RC1.2 UC1.AV7
PCH_JTAG_JTAGX: RC18.1 RC112.2 RC115.2 UC1.AE63
PCH_JTAG_TCK: JXDP1.55 RC21.1 RC119.2 UC1.AE62
PCH_JTAG_TDI: JXDP1.56 RC14.1 RC99.1 UC1.AD61
PCH_JTAG_TDO: RC15.1 RC98.1 RC118.2 UC1.AE61
PCH_JTAG_TMS: JXDP1.58 RC16.1 UC1.AD62 UC7.9
PCH_JTAG_TRST#: RC109.2 UC1.AU62
PCH_OPI_COMP: RC178.1 UC1.AW15
PCH_PCIE_RCOMP: RC149.2 UC1.A27
PCH_PCIE_WAKE#: RE274.2 RPC1.8 UC1.AJ5 UE2.A44
PCH_PLTRST#: RC87.2 RC88.2 RC89.2 RC219.2 UC1.AG7 UC5.1 UC5.2
PCH_PLTRST#_EC: JLPDE1.8 JNGFF1.44 JNGFF1.58 JNGFF2.42 RC106.1 RC304.1 UC5.4 UE1.B22 UE2.B30 UZ1.16
PCH_RSMRST#: RE88.1 UE2.A45 UZ6.1
PCH_RSMRST#_Q: RC91.2 UC1.AW6 UZ6.4
PCH_RTCRST#: CC4.2 CMOS1.2 JAPS1.9 RC8.2 UC1.AU7
PCH_RTCX1: RC4.2 RC7.1 UC1.AW5
PCH_RTCX1_R: CC1.2 RC4.1 YC1.1
PCH_RTCX2: CC2.2 RC7.2 UC1.AY5 YC1.2
PCH_SMB_ALERT#: RPC19.2 UC1.AN2
PCH_SPI_CLK: JSPI1.13 RC227.2 RZ26.1 UC1.AA3
PCH_SPI_CS0#: JSPI1.11 RC228.2 UC1.Y7
PCH_SPI_CS1#: JSPI1.19 RC224.2 UC1.Y4
PCH_SPI_CS2#: RZ17.1 UC1.AC2
PCH_SPI_CS2#_R: RZ17.2 UZ1.22
PCH_SPI_DIN: JSPI1.15 RC226.2 RZ30.1 UC1.AA4
PCH_SPI_DO: JSPI1.17 RC225.2 RZ29.1 UC1.AA2
PCH_SPI_DO2: JSPI1.9 RC229.2 UC1.Y6
PCH_SPI_DO3: JSPI1.7 RC230.2 UC1.AF1
PCI_CLK_LPC_0: RC72.1 RC74.1 UC1.AN15
PCI_CLK_LPC_1: RC67.1 RC70.1 UC1.AP15
PCIE_PRX_GLANTX_N3: CL2.2 UC1.G11
PCIE_PRX_GLANTX_N3_C: CL2.1 UL1.39
PCIE_PRX_GLANTX_P3: CL1.2 UC1.F11
PCIE_PRX_GLANTX_P3_C: CL1.1 UL1.38
PCIE_PRX_MMITX_N1: CR27.1 UC1.G17
PCIE_PRX_MMITX_N1_C: CR27.2 UR1.8
PCIE_PRX_MMITX_P1: CR26.1 UC1.F17
PCIE_PRX_MMITX_P1_C: CR26.2 UR1.7
PCIE_PRX_SATATX_N6_L0: JNGFF2.35 UC1.F5
PCIE_PRX_SATATX_N6_L1: JNGFF2.21 UC1.J6
PCIE_PRX_SATATX_P6_L0: JNGFF2.33 UC1.E5
PCIE_PRX_SATATX_P6_L1: JNGFF2.23 UC1.H6
PCIE_PRX_WIGIGTX_N5: JNGFF1.59 UC1.F10
PCIE_PRX_WIGIGTX_P5: JNGFF1.57 UC1.E10
PCIE_PRX_WLANTX_N4: JNGFF1.35 UC1.F13
PCIE_PRX_WLANTX_P4: JNGFF1.33 UC1.G13
PCIE_PTX_GLANRX_N3: CL6.1 UC1.C29
PCIE_PTX_GLANRX_N3_C: CL6.2 UL1.42
PCIE_PTX_GLANRX_P3: CL5.1 UC1.B30
PCIE_PTX_GLANRX_P3_C: CL5.2 UL1.41
PCIE_PTX_MMIRX_N1: CR25.1 UC1.C30
PCIE_PTX_MMIRX_N1_C: CR25.2 UR1.5
PCIE_PTX_MMIRX_P1: CR24.1 UC1.C31
PCIE_PTX_MMIRX_P1_C: CR24.2 UR1.6
PCIE_PTX_SATARX_N6_L0: CZ58.1 UC1.C17
PCIE_PTX_SATARX_N6_L0_C: CZ58.2 JNGFF2.39
PCIE_PTX_SATARX_N6_L1: CZ32.1 UC1.B14
PCIE_PTX_SATARX_N6_L1_C: CZ32.2 JNGFF2.27
PCIE_PTX_SATARX_P6_L0: CZ59.1 UC1.D17
PCIE_PTX_SATARX_P6_L0_C: CZ59.2 JNGFF2.41
PCIE_PTX_SATARX_P6_L1: CZ33.1 UC1.C15
PCIE_PTX_SATARX_P6_L1_C: CZ33.2 JNGFF2.29
PCIE_PTX_WIGIGRX_N5: CZ22.1 UC1.C23
PCIE_PTX_WIGIGRX_N5_C: CZ22.2 JNGFF1.53
PCIE_PTX_WIGIGRX_P5: CZ21.1 UC1.C22
PCIE_PTX_WIGIGRX_P5_C: CZ21.2 JNGFF1.51
PCIE_PTX_WLANRX_N4: CZ14.1 UC1.B29
PCIE_PTX_WLANRX_N4_C: CZ14.2 JNGFF1.29
PCIE_PTX_WLANRX_P4: CZ13.1 UC1.A29
PCIE_PTX_WLANRX_P4_C: CZ13.2 JNGFF1.27
PCIE_WAKE#: JNGFF1.47 JNGFF1.62 JNGFF2.46 RE274.1 RE275.1
PCIE_WAKE#_R: RE35.2 RE275.2 UE1.B10
PE_REXT: RR2.2 UR1.4
PECI_EC: RE60.2 UC1.N62
PECI_EC_R: RE60.1 UE2.A48
PGOOD_3V_5V: PR107.1 PR108.2 PU100.7
PLTRST_LAN#: RC89.1 UL1.36
PLTRST_MMI#: RC88.1 UR1.15
PLTRST_USH#: CZ68.1 JUSH1.6 RC87.1
PLTRST_VMM2320#: RC219.1 UV8.A13
PM_APWROK: RC26.1 UE2.A9
PM_APWROK_L: RC26.2 RC27.2 UC6.2
PM_APWROK_R: UC1.AB5 UC6.4
PM_LANPHY_ENABLE: RC92.1 RL7.1 UC1.AM7
PM_TEST_RST: CC100.2 RC300.2 UC1.AC4
POA_WAKE#: RPE5.3 UE2.B68
POWER_SW#_MB: CE10.1 JAPS1.11 RE33.2 SW3.2 SW3.4
POWER_SW_IN#: CE12.1 RE31.2 RE33.1 UE2.B67
PROC_OPI_RCOMP: RC187.1 UC1.AY15
PROCHOT_GATE: RE83.2 UE1.A50
PS8338_CFG0: RV51.2 UV7.59
PS8338_SW: QV11.1 RV52.2 UV7.18
PS8338B_P0: RV60.2 UV7.60
PS8338B_P1: RV53.2 RV100.1 UV7.1
PS8338B_PC10: RV58.2 RV65.1 UV7.56
PS8338B_PC11: RV57.2 RV63.1 UV7.55
PS8338B_PC20: RV56.2 RV64.1 UV7.54
PS8338B_PC21: RV55.2 RV62.1 UV7.53
PS8338B_PEQ: RV54.2 RV61.1 UV7.8
PS_ID: PU1.4 UE2.B24
PS_USBP1_D+: LI7.1 UI3.10
PS_USBP1_D-: LI7.4 UI3.11
PSID_DISABLE#: PR13.2 UE1.A37
PWM1: PU500.6 PU501.8
PWR_SRC_ON: CV11.2 QV1.3 RV4.2 RV5.1
RED: CV54.1 DV5.2 JCRT1.1 LV16.2
RED_2320: RV76.1 UV8.M6 UV16.1
RED_CRT: CV51.1 LV16.1 RV32.1 UV16.27
RED_DOCK: JDOCK1.53 UV16.26
REGCTL_PNP10: LL1.1 UL1.7
REM_DIODE1_N: CE24.1 CE35.1 QE3.3 UE2.B13
REM_DIODE1_P: CE24.2 CE35.2 QE3.1 QE3.2 UE2.A13
REM_DIODE2_N: CE26.1 CE37.2 CE46.2 QE5.3 QE7.1 QE7.2 UE2.B14
REM_DIODE2_P: CE26.2 CE37.1 CE46.1 QE5.1 QE5.2 QE7.3 UE2.A14
REM_DIODE4_N: CE27.1 CE39.1 QE6.3 UE2.A16
REM_DIODE4_P: CE27.2 CE39.2 QE6.1 QE6.2 UE2.B17
RES_BIAS: RL13.1 UL1.12
RESET_OUT#: RE56.2 UC1.AY7 UC8.2 UE2.B39
RING2: LA10.1 RA5.1 UA1.28
RING2_R: CA4.1 CA13.2 DA3.2 JHP1.3 LA10.2
RSMRST#: RZ22.2 RZ51.2 UZ5.3 UZ6.2
RUN_ON: QE2.2 RE279.2 RE280.2 RPE10.1 RZ41.1 UZ7.3 UZ9.3 UZ9.5
RUN_ON#: QE2.5 QE2.6 RE68.2
RUN_ON_EC: RE279.1 UE2.B9
RUNPWROK: QE2.3 RE67.2 UC7.1 UC7.4 UC7.10 UC7.13 UE1.A4 UE2.B26
S5_1.35V: PC215.1 PR207.2 PU200.8
SATA2_PCIE6_L1: RPC3.6 UC1.V6 UE1.A62
SATA_ACT#: QZ3.4 UC1.U3
SATA_COMP: RC17.1 UC1.C12
SATA_LED: JLED1.3 QZ4.3
SATA_LED#: QZ3.6 QZ4.2
SATA_PRX_DKTX_N0: C313.2 JDOCK1.56
SATA_PRX_DKTX_N0_C: C313.1 UC1.J5
SATA_PRX_DKTX_P0: C312.2 JDOCK1.54
SATA_PRX_DKTX_P0_C: C312.1 UC1.H5
SATA_PRX_DTX_N1: CN25.1 UC1.J8
SATA_PRX_DTX_N1_C: CN25.2 UN2.4
SATA_PRX_DTX_N1_RP: CN18.2 UN2.12
SATA_PRX_DTX_N1_RP_C: CN18.1 JSATA1.5
SATA_PRX_DTX_P1: CN26.1 UC1.H8
SATA_PRX_DTX_P1_C: CN26.2 UN2.5
SATA_PRX_DTX_P1_RP: CN17.2 UN2.11
SATA_PRX_DTX_P1_RP_C: CN17.1 JSATA1.6
SATA_PTX_DKRX_N0: C315.1 JDOCK1.62
SATA_PTX_DKRX_N0_C: C315.2 UC1.B15
SATA_PTX_DKRX_P0: C314.1 JDOCK1.60
SATA_PTX_DKRX_P0_C: C314.2 UC1.A15
SATA_PTX_DRX_N1: CN30.1 UC1.A17
SATA_PTX_DRX_N1_C: CN30.2 UN2.2
SATA_PTX_DRX_N1_RP: CN20.2 UN2.14
SATA_PTX_DRX_N1_RP_C: CN20.1 JSATA1.3
SATA_PTX_DRX_P1: CN23.1 UC1.B17
SATA_PTX_DRX_P1_C: CN23.2 UN2.1
SATA_PTX_DRX_P1_RP: CN19.2 UN2.15
SATA_PTX_DRX_P1_RP_C: CN19.1 JSATA1.2
SATACLK_REQ#: JNGFF2.44 RC68.2 UC1.T2
SD/MMCCD#: CR35.1 JSD1.18 RR11.1 UR1.21
SD/MMCCLK: CR23.1 JSD1.5 RR1.2
SD/MMCCLK_R: RR1.1 UR1.43
SD/MMCCMD: JSD1.2 UR1.45
SD/MMCDAT0: JSD1.7 UR1.30 UR1.38
SD/MMCDAT1: JSD1.8 UR1.29 UR1.37
SD/MMCDAT2: RR4.1 UR1.48
SD/MMCDAT2_R: JSD1.9 RR4.2
SD/MMCDAT3: RR3.1 UR1.47
SD/MMCDAT3_R: JSD1.1 RR3.2
SD_REXT: RR5.1 UR1.26
SD_UHS2_D0N: JSD1.12 UR1.34
SD_UHS2_D0P: JSD1.11 UR1.35
SD_UHS2_D1N: JSD1.15 UR1.33
SD_UHS2_D1P: JSD1.16 UR1.32
SDWP: JSD1.19 UR1.20
SIO_EXT_SCI#: RC156.1 UC1.N5 UE2.A33
SIO_EXT_SMI#: RPC9.6 UC1.AG5 UE2.A6
SIO_EXT_WAKE#: RPC1.6 UC1.AU2 UE2.B5
SIO_PWRBTN#: JXDP1.41 UC1.AL7 UE2.B58
SIO_RCIN#: RPC3.5 UC1.V4 UE2.A27
SIO_SLP_A#: JAPS1.6 UC1.AL5 UC6.1 UE2.B28
SIO_SLP_LAN#: UC1.AJ7 UE2.B37 UZ2.5
SIO_SLP_S0#: JAPS1.15 UC1.AF3
SIO_SLP_S3#: JAPS1.2 RE280.1 UC1.AT4 UE2.A35
SIO_SLP_S4#: JAPS1.5 RE282.2 T9.1(TP-1) UC1.AJ6 UE2.B36
SIO_SLP_S5#: JAPS1.4 T8.1(TP-1) UC1.AP5 UE2.A18
SIO_SLP_SUS#: UC1.AP4 UE2.B52
SIO_SLP_WLAN#: UC1.AM5 UE1.A14
SKIP#: PR520.2 PU500.7
SKIP#1: PR520.1 PU501.1
SL_BAT_PRES#: PR854.1 PU800.21
SLATE_MODE: RPC10.6 UC1.AL4
SLEEVE: LA11.1 QA2.3 RA6.1 UA1.29
SLEEVE_R: CA1.1 CA12.1 DA1.3 JHP1.4 LA11.2
SLEWA: PR500.1 PR510.2 PU500.15
SLICE_BAT_ON: PR845.2 RE17.2 UE1.A31
SLICE_BAT_PRES#: JDOCK1.141 JDOCK1.143 PR6.1 PR854.2 RE5.2 UE1.B33
SM_RCOMP0: RC130.1 UC1.AU60
SM_RCOMP1: RC131.1 UC1.AV60
SM_RCOMP2: RC132.1 UC1.AU61
SMART_DET#: T99.1(TP-1) UE1.A15
SML0_SMBCLK: RC33.2 UC1.AN1 UL1.28
SML0_SMBDATA: RC34.2 UC1.AK1 UL1.31
SML1_SMBCLK: RPC14.3 UC1.AU3 UE2.B6
SML1_SMBDATA: RPC14.4 UC1.AH3 UE2.A5
SNB_1.05V: PC301.1 PR305.2
SNUB_1.35V: PC208.1 PR203.2
SNUB_3V: PC111.1 PR111.2
SNUB_5V: PC114.1 PR112.2
SOFT_START_GC: PR17.2 PU800.2
SPI_CLK32: RC61.2 RPC12.7 UC3.6
SPI_CLK64: RC62.2 RPC11.6 UC2.6
SPI_CLKTPM: RZ26.2 RZ35.2 UZ1.21
SPI_DIN32: RPC12.5 UC3.2
SPI_DIN64: RPC11.8 UC2.2
