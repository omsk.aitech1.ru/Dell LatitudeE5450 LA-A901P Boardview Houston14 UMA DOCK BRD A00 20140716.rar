# Allegro board Houston14_UMA_DOCK_BRD_A00_20140716.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_B_D34: length 91.3
  IN4 w0.089: v1(157.86,42.35) 158.45,42.35 159.41,41.39 159.99,41.39 160.22,41.16 163,41.16 165,39.17 165.31,39.17 167.96,36.52 167.96,36.23 168.76,35.43 176.85,35.43 178,34.29 198.01,34.29 200.15,32.14 201.02,32.14 219.85,13.31 219.85,10.34 220.4,9.79 220.4,6.91 v1(221.03,6.28)
  BOTTOM w0.076: v1(157.86,42.35) 156.96,43.25 156.96,46.15 156.82,46.29 156.82,47.48 UC1.AY21
  BOTTOM w0.102: JDIMM2.174 219.26,4.52 v1(221.03,6.28)
DDR_B_D35: length 92.1
  IN4 w0.089: v1(157.88,42.91) 158.06,42.72 158.33,42.72 159.48,41.57 160.06,41.57 160.29,41.34 163.17,41.34 165.06,39.45 165.56,39.45 167.97,37.04 168.35,37.04 168.83,36.56 172.84,36.56 173.67,35.73 179.49,35.73 180.63,34.59 181.23,34.59 181.31,34.68 181.31,35.02 181.4,35.11 181.72,35.11 181.81,35.02 181.81,34.68 181.9,34.59 182.22,34.59 182.31,34.68 182.31,35.02 182.39,35.11 182.71,35.11 182.8,35.02 182.8,34.68 182.89,34.59 183.21,34.59 183.3,34.68 183.3,35.02 183.38,35.11 183.7,35.11 183.79,35.02 183.79,34.68 183.88,34.59 184.2,34.59 184.29,34.68 184.29,35.02 184.38,35.11 184.69,35.11 184.78,35.02 184.78,34.68 184.87,34.59 185.19,34.59 185.28,34.68 185.28,35.02 185.37,35.11 185.68,35.11 185.77,35.02 185.77,34.68 185.86,34.59 198.13,34.59 200.27,32.45 201.14,32.45 220.26,13.34 220.26,10.36 221.03,9.59 v1(221.03,9.33)
  BOTTOM w0.076: UC1.AW21 156.69,48.02 156.99,47.73 156.99,46.36 157.13,46.22 157.13,43.65 v1(157.88,42.91)
  BOTTOM w0.102: JDIMM2.175 219.56,9.96 220.19,9.33 v1(221.03,9.33)
DDR_B_D36: length 93
  IN4 w0.089: v1(156.28,42.37) 156.55,42.37 156.64,42.28 156.64,41.52 156.64,41.38 156.91,41.11 157.37,40.65 157.72,40.65 157.87,40.65 158.48,40.65 158.84,40.29 159.53,40.29 159.76,40.07 160.27,40.07 163.22,37.12 163.44,37.12 167.32,33.24 176.05,33.24 177.13,32.16 185.92,32.16 186.24,31.84 196.55,31.84 197.59,30.81 198.24,30.81 199.58,29.47 200.38,29.47 213.08,16.78 213.2,16.78 213.24,16.81 213.36,16.81 213.59,16.59 213.59,16.46 213.55,16.43 213.55,16.3 213.78,16.08 213.9,16.08 213.94,16.11 214.06,16.11 214.29,15.89 214.29,15.76 214.25,15.73 214.25,15.6 214.53,15.32 214.66,15.32 214.69,15.35 214.82,15.35 215.04,15.13 215.04,15 215.01,14.97 215.01,14.85 215.23,14.62 215.36,14.62 215.39,14.65 215.52,14.65 215.74,14.43 215.74,14.3 215.71,14.27 215.71,14.14 215.93,13.92 216.06,13.92 216.09,13.95 216.22,13.95 216.44,13.73 216.44,13.6 216.41,13.57 216.41,13.44 216.56,13.29 216.56,12.64 216.69,12.51 216.97,12.51 217.09,12.38 217.09,7.55 217.22,7.42 217.49,7.42 217.62,7.55 v1(217.62,7.81)
  BOTTOM w0.076: UC1.AV23 154.96,48.52 154.96,47.86 154.9,47.76 154.88,47.72 154.88,47.34 155.01,47.21 155.01,46.25 155.26,46 155.26,42.73 155.62,42.37 v1(156.28,42.37)
  BOTTOM w0.102: JDIMM2.163 215.96,10.14 216.7,9.4 216.7,8.72 v1(217.62,7.81)
DDR_B_D37: length 94.1
  IN4 w0.089: v1(217.62,6.28) 217.62,6.03 217.49,5.9 216.92,5.9 216.79,6.03 216.79,10.48 216.66,10.61 216.39,10.61 216.26,10.73 216.26,11.08 216.35,11.17 216.61,11.17 216.7,11.26 216.7,11.58 216.61,11.67 216.35,11.67 216.26,11.76 216.26,13.16 200.64,28.78 200.25,29.17 199.45,29.17 198.12,30.5 197.46,30.5 196.42,31.54 186.11,31.54 185.79,31.86 177,31.86 175.92,32.94 167.19,32.94 163.39,36.74 163.17,36.74 160.02,39.89 159.69,39.89 159.46,40.12 158.77,40.12 158.41,40.47 157.95,40.47 157.79,40.47 157.79,40.47 157.27,40.47 156.28,41.46 v1(156.28,41.83)
  BOTTOM w0.076: UC1.AU23 156.11,49.56 156.31,49.35 156.31,49.11 156.29,49.09 156.29,48.72 156.31,48.7 156.31,48.51 156.3,48.5 156.28,48.45 156.24,48.36 156.24,48.15 156.27,48.08 156.31,47.99 156.31,47.87 156.24,47.71 156.24,47.41 156.47,47.18 156.47,46.18 156.63,46.01 156.63,42.19 v1(156.28,41.83)
  BOTTOM w0.102: v1(217.62,6.28) 216.74,5.41 216.74,4.59 216.26,4.11 JDIMM2.164
DDR_B_D38: length 93.1
  IN4 w0.089: v1(221.03,4.76) 220.1,5.69 220.1,9.65 219.55,10.21 219.55,13.19 201,31.73 199.88,31.73 198.99,32.61 198.39,32.61 197.03,33.97 177.88,33.97 176.8,35.05 168.09,35.05 165.34,37.8 165.34,38.45 162.8,40.99 160.14,40.99 159.91,41.21 159.28,41.21 158.72,41.78 v1(157.88,41.78)
  BOTTOM w0.076: v1(157.88,41.78) 156.8,42.85 156.8,46.08 156.64,46.24 156.64,47.24 156.4,47.48 156.4,47.67 156.45,47.78 156.45,47.78 156.47,47.83 156.47,48.03 156.45,48.09 156.45,48.09 156.41,48.17 156.41,48.17 156.4,48.19 156.4,48.32 156.43,48.37 156.45,48.43 156.59,48.56 UC1.AV21
  BOTTOM w0.102: JDIMM2.176 219.86,3.96 220.66,4.76 v1(221.03,4.76)
DDR_B_D39: length 93.5
  IN4 w0.089: v1(221.03,7.81) 221.45,8.23 221.45,9.6 220.61,10.44 220.61,13.41 201.27,32.76 200.4,32.76 198.26,34.9 191.9,34.9 191.38,35.42 186.89,35.42 186.8,35.33 186.8,34.98 186.71,34.9 186.39,34.9 186.31,34.98 186.31,35.33 186.22,35.42 180.24,35.42 179.62,36.04 173.89,36.04 173.04,36.9 168.99,36.9 168.52,37.37 168.08,37.37 165.66,39.79 164.99,39.79 163.27,41.52 160.36,41.52 160.1,41.78 159.62,41.78 159.41,41.99 158.69,42.71 158.69,42.92 158.15,43.45 v1(157.88,43.45)
  BOTTOM w0.076: v1(157.88,43.45) 157.3,44.03 157.3,46.29 157.15,46.43 157.15,47.8 157.02,47.92 157.02,48.34 156.87,48.49 156.87,48.81 156.93,48.87 156.93,49.21 UC1.AU21
  BOTTOM w0.102: JDIMM2.177 220.16,10.18 220.6,9.74 221.2,9.74 221.46,9.48 221.46,8.24 v1(221.03,7.81)
DDR_B_D40: length 56.1
  IN1 w0.089: v1(157.86,44.55) 158.25,44.16 158.25,41.49 159.93,39.81 159.93,31.67 176.33,15.27 176.33,6.29 176.46,6.16 176.81,6.16 176.93,6.29 176.93,7.9 177.01,7.98 v1(177.33,7.98)
  BOTTOM w0.076: v1(157.86,44.55) 158.44,45.13 158.44,45.91 157.65,46.7 157.65,47.48 UC1.AY19
  BOTTOM w0.102: v1(177.33,7.98) 176.36,8.96 JDIMM2.39
DDR_B_D41: length 57
  IN1 w0.089: v1(177.33,9.51) 176.78,10.06 176.78,10.48 176.87,10.57 177.42,10.57 177.51,10.65 177.51,10.97 177.42,11.06 176.87,11.06 176.78,11.15 176.78,11.47 176.87,11.56 177.42,11.56 177.51,11.64 177.51,11.96 177.42,12.05 176.87,12.05 176.78,12.14 176.78,14.03 176.87,14.12 177.24,14.12 177.33,14.21 177.33,14.52 177.24,14.61 176.87,14.61 176.78,14.7 176.78,15.25 164.28,27.76 164.28,27.88 164.51,28.12 164.51,28.24 164.29,28.47 164.16,28.47 163.93,28.23 163.8,28.23 163.58,28.46 163.58,28.58 163.81,28.82 163.81,28.94 163.59,29.17 163.46,29.17 163.23,28.93 163.1,28.93 162.88,29.16 162.88,29.28 163.11,29.52 163.11,29.64 162.89,29.87 162.76,29.87 162.53,29.63 162.4,29.63 162.14,29.89 162.14,30.02 162.38,30.25 162.38,30.38 162.15,30.6 162.03,30.6 161.79,30.37 161.67,30.37 161.44,30.59 161.44,30.72 161.68,30.95 161.68,31.08 161.45,31.3 161.33,31.3 161.09,31.07 160.97,31.07 160.76,31.28 160.76,31.44 160.95,31.63 160.95,31.81 160.25,32.51 160.25,39.78 158.5,41.53 158.5,44.48 v1(157.88,45.1)
  BOTTOM w0.076: UC1.AW19 157.77,48.02 157.48,47.73 157.48,46.63 158.27,45.84 158.27,45.49 v1(157.88,45.1)
  BOTTOM w0.102: v1(177.33,9.51) 176.96,9.88 JDIMM2.41
DDR_B_D42: length 55.9
  IN1 w0.089: v1(159.69,45.49) 161.36,43.83 161.36,42.74 164.13,39.96 164.13,38.13 163.8,37.8 163.8,34.57 164.56,33.81 164.56,33.69 164.35,33.47 164.35,33.27 164.49,33.12 164.7,33.12 164.91,33.34 165.04,33.34 165.26,33.11 165.26,32.99 164.92,32.65 164.92,32.52 165.15,32.3 165.27,32.3 165.61,32.64 165.74,32.64 165.96,32.41 165.96,32.29 165.81,32.14 165.81,31.96 165.99,31.79 166.16,31.79 166.31,31.94 166.44,31.94 170.38,28 170.38,25.51 181.33,14.55 181.33,8.4 v1(180.92,7.98)
  BOTTOM w0.076: v1(159.69,45.49) 159.69,45.9 159.11,46.48 159.11,47.59 UC1.AY17
  BOTTOM w0.102: JDIMM2.53 180.56,10.17 180.68,10.05 181.06,10.05 181.43,9.68 181.43,8.49 v1(180.92,7.98)
DDR_B_D43: length 56.9
  IN1 w0.089: v1(160.3,42.43) 160.62,42.43 162.1,40.95 162.1,39.09 162.46,38.74 162.46,34.7 163.26,33.9 163.26,33.33 163.63,32.95 163.63,32.83 163.34,32.53 163.34,32.41 163.56,32.18 163.69,32.18 163.98,32.48 164.11,32.48 164.31,32.27 164.31,32.17 164.17,32.02 164.17,31.9 164.39,31.67 164.52,31.67 164.62,31.78 164.81,31.78 169.77,26.82 169.77,25.26 180.51,14.52 180.51,6.87 v1(180.92,6.46)
  BOTTOM w0.076: UC1.AW17 159.34,48.04 159.34,47.83 159.41,47.68 159.42,47.67 159.42,47.48 159.29,47.36 159.29,46.61 160.11,45.79 160.11,44.83 160.17,44.77 160.17,42.56 v1(160.3,42.43)
  BOTTOM w0.102: JDIMM2.52 180.26,4.14 180.49,4.37 180.94,4.37 181.43,4.87 181.43,5.95 v1(180.92,6.46)
DDR_B_D44: length 57
  IN1 w0.089: v1(157.88,45.65) 158.69,44.83 158.69,41.63 160.59,39.73 160.59,32.6 165.13,28.06 165.13,27.93 164.89,27.7 164.89,27.57 165.12,27.34 165.24,27.34 165.48,27.58 165.61,27.58 165.83,27.36 165.83,27.23 165.6,26.99 165.6,26.87 165.82,26.64 165.95,26.64 166.18,26.88 166.31,26.88 166.53,26.66 166.53,26.53 166.3,26.29 166.3,26.17 177.81,14.65 177.81,6.94 v1(177.33,6.46)
  BOTTOM w0.076: v1(157.88,45.65) 157.88,45.94 157.32,46.5 157.32,47.8 157.48,47.97 157.48,48.38 157.88,48.78 UC1.AV19
  BOTTOM w0.102: JDIMM2.42 177.26,4.11 177.84,4.69 177.84,5.96 v1(177.33,6.46)
DDR_B_D45: length 57.8
  IN1 w0.089: v1(177.33,4.94) 178.12,5.72 178.12,14.78 167.65,25.24 167.65,25.37 167.89,25.61 167.89,25.73 167.66,25.96 167.54,25.96 167.3,25.72 167.18,25.72 166.95,25.95 166.95,26.07 167.19,26.31 167.19,26.43 160.92,32.7 160.92,39.71 158.9,41.73 158.9,43.53 v1(159.77,44.39)
  BOTTOM w0.076: v1(159.77,44.39) 159.39,44.39 159.08,44.71 159.08,46.05 158.78,46.35 158.78,47.26 158.67,47.37 158.67,47.71 158.73,47.85 158.74,47.87 158.74,47.99 158.73,48.01 158.7,48.08 158.67,48.15 158.67,48.36 158.71,48.45 158.73,48.5 158.74,48.51 158.74,49.35 158.54,49.56 UC1.AU19
  BOTTOM w0.102: JDIMM2.40 176.66,4.26 v1(177.33,4.94)
DDR_B_D46: length 56.6
  IN1 w0.089: v1(180.92,9.51) 180.92,14.53 170.07,25.38 170.07,26.95 169.4,27.62 169.4,27.75 169.68,28.03 169.68,28.24 169.54,28.38 169.33,28.38 169.05,28.1 168.92,28.1 168.59,28.42 168.59,28.55 168.93,28.89 168.93,29.01 168.71,29.24 168.58,29.24 168.24,28.9 168.12,28.9 167.89,29.13 167.89,29.26 168.22,29.59 168.22,29.72 168,29.94 167.87,29.94 167.54,29.61 167.41,29.61 167.19,29.83 167.19,29.96 167.52,30.29 167.52,30.42 167.3,30.64 167.17,30.64 166.84,30.31 166.71,30.31 166.49,30.53 166.49,30.66 166.82,30.99 166.82,31.12 166.6,31.34 166.47,31.34 166.14,31.01 166.01,31.01 163.68,33.34 163.68,34.19 163.32,34.55 163.32,40.49 161.14,42.68 161.14,43.54 v1(159.74,44.94)
  BOTTOM w0.076: v1(159.74,44.94) 159.34,45.33 159.34,46.02 158.94,46.41 158.94,47.33 158.83,47.44 158.83,47.67 158.88,47.78 158.91,47.83 158.91,48.03 158.88,48.09 158.84,48.17 158.84,48.17 158.83,48.19 158.83,48.32 158.86,48.37 158.88,48.43 158.98,48.52 159.12,48.67 UC1.AV17
  BOTTOM w0.102: v1(180.92,9.51) 180.45,9.51 179.96,10 JDIMM2.51
DDR_B_D47: length 57.7
  IN1 w0.089: v1(180.92,4.94) 179.97,5.89 179.97,14.62 169.46,25.13 169.46,25.85 164.73,30.59 164.73,30.71 164.88,30.87 164.88,30.99 164.66,31.22 164.53,31.22 164.38,31.06 164.25,31.06 162.85,32.46 162.85,33.71 162.15,34.41 162.15,38.72 161.93,38.95 161.93,40.85 160.87,41.9 v1(160.53,41.9)
  BOTTOM w0.076: UC1.AU17 159.44,49.25 159.44,48.49 159.51,48.42 159.51,47.86 159.53,47.81 159.54,47.8 159.56,47.76 159.58,47.73 159.58,47.41 159.45,47.29 159.45,46.83 160.28,46.01 160.28,44.91 160.36,44.83 160.36,43.73 160.97,43.12 160.97,42.43 160.53,41.99 v1(160.53,41.9)
  BOTTOM w0.102: JDIMM2.50 179.66,4.52 180.08,4.94 v1(180.92,4.94)
DDR_B_D48: length 97
  IN4 w0.086: 167.4,41.47 168.03,40.83
  IN4 w0.089: v1(156.84,50.39) 156.84,50.2 159.01,48.03 159.94,48.03 161.52,46.45 161.52,46.28 162.51,45.29 162.51,44.61 165.66,41.47 167.4,41.47 ; 168.03,40.83 168.34,40.52 178.19,40.52 179.43,39.29 179.43,39.23 179.93,38.72 188.93,38.72 189.59,38.06 199.66,38.06 219.44,18.28 220.38,18.28 224.47,14.19 224.47,10.7 224.56,10.61 224.87,10.61 224.96,10.52 224.96,10.2 224.87,10.12 224.56,10.12 224.47,10.03 224.47,9.56 224.56,9.47 225.12,9.47 225.21,9.38 225.21,9.07 225.12,8.98 224.56,8.98 224.47,8.89 224.47,8.2 224.6,8.06 v1(225.75,8.06)
  BOTTOM w0.076: UC1.AR21 157.17,50.72 v1(156.84,50.39)
  BOTTOM w0.102: v1(225.75,8.06) 224.36,9.45 JDIMM2.191
DDR_B_D49: length 98.2
  IN4 w0.089: v1(155.89,50.39) 155.89,48.91 158.2,46.6 159.98,46.6 160.82,45.76 160.82,44.24 161.97,43.09 163.07,43.09 165.35,40.81 166.67,40.81 168.5,38.98 169.07,38.98 169.72,38.33 173.6,38.33 174.48,37.45 180.32,37.45 180.41,37.36 180.41,37.33 180.53,37.21 180.95,37.21 181.07,37.33 181.07,37.36 181.16,37.45 181.4,37.45 181.49,37.36 181.49,37.33 181.58,37.24 181.89,37.24 181.98,37.33 181.98,37.36 182.07,37.45 182.39,37.45 182.48,37.36 182.48,37.33 182.57,37.24 182.88,37.24 182.97,37.33 182.97,37.36 183.06,37.45 183.38,37.45 183.47,37.36 183.47,37.33 183.56,37.24 183.87,37.24 183.96,37.33 183.96,37.36 184.05,37.45 184.37,37.45 184.46,37.36 184.46,37.33 184.55,37.24 184.87,37.24 184.95,37.33 184.95,37.36 185.04,37.45 185.36,37.45 185.45,37.36 185.45,37.33 185.54,37.24 185.86,37.24 185.95,37.33 185.95,37.36 186.03,37.45 186.35,37.45 186.44,37.36 186.44,37.33 186.53,37.24 186.85,37.24 186.94,37.33 186.94,37.36 187.02,37.45 188.18,37.45 188.8,36.83 191.96,36.83 192.48,36.31 193.02,36.31 193.11,36.39 193.11,36.77 193.2,36.86 193.52,36.86 193.61,36.77 193.61,36.39 193.7,36.31 194.01,36.31 194.1,36.39 194.1,36.77 194.19,36.86 194.51,36.86 194.6,36.77 194.6,36.39 194.69,36.31 195.01,36.31 195.09,36.39 195.09,36.77 195.18,36.86 195.5,36.86 195.59,36.77 195.59,36.39 195.68,36.31 196.81,36.31 196.9,36.39 196.9,36.77 196.99,36.86 197.31,36.86 197.4,36.77 197.4,36.39 197.49,36.31 198.84,36.31 200.98,34.17 201.85,34.17 218.94,17.08 219.89,17.08 222.61,14.36 222.61,12.37 222.69,12.28 223.15,12.28 223.24,12.2 223.24,11.88 223.15,11.79 222.69,11.79 222.61,11.7 222.61,11.38 222.69,11.29 222.99,11.29 223.11,11.17 223.11,10.93 222.99,10.8 222.86,10.8 222.73,10.67 222.73,10.48 222.86,10.35 223.06,10.35 223.19,10.23 v1(223.19,9.58)
  BOTTOM w0.076: v1(155.89,50.39) 156.21,50.72 UC1.AR22
  BOTTOM w0.102: JDIMM2.183 221.96,10.36 222.74,9.58 v1(223.19,9.58)
DDR_B_D50: length 100.6
  IN4 w0.086: 165.29,42.42 165.84,41.87 167.74,41.87 168.47,41.14 170.65,41.14
  IN4 w0.089: 170.65,41.14 179.72,41.14 181.54,39.33 189.19,39.33 189.85,38.67 199.91,38.67 216.64,21.94 216.77,21.94 216.86,22.03 217.01,22.03 217.11,21.93 217.11,21.78 217.02,21.69 217.02,21.56 217.15,21.43 217.27,21.43 217.5,21.66 217.62,21.66 217.75,21.53 217.75,21.41 217.52,21.18 217.52,21.06 219.69,18.89 220.64,18.89 226.16,13.36 226.16,6.95 v1(225.75,6.54) ; v1(156.84,52.99) 157.4,52.43 157.4,50.26 159.26,48.4 160.08,48.4 162.08,46.41 162.08,46.38 162.94,45.51 162.94,44.77 165.29,42.42
  BOTTOM w0.076: UC1.AL21 157.17,53.32 v1(156.84,52.99)
  BOTTOM w0.102: v1(225.75,6.54) 225.98,6.54 226.26,6.25 226.26,4.71 226,4.45 225.61,4.45 225.26,4.11 JDIMM2.194
DDR_B_D51: length 100.4
  IN4 w0.089: v1(223.19,6.54) 223.05,6.54 222.92,6.41 222.92,6.23 222.8,6.1 222.38,6.1 222.25,6.23 222.25,9.97 221.41,10.81 221.41,13.74 220.43,14.73 220.43,15.67 219.65,16.46 218.7,16.46 201.6,33.56 200.73,33.56 198.59,35.7 192.23,35.7 191.71,36.22 186.92,36.22 186.55,36.58 180.2,36.58 179.95,36.84 174.23,36.84 173.34,37.72 169.35,37.72 168.87,38.21 168.41,38.21 166.27,40.35 165.18,40.35 163.12,42.41 161.94,42.41 160.46,43.89 160.46,45.61 159.86,46.22 158.08,46.22 154.66,49.64 154.66,50.74 155.49,51.58 155.49,51.95 v1(155.89,52.34)
  BOTTOM w0.076: UC1.AM22 156.21,52.67 v1(155.89,52.34)
  BOTTOM w0.102: v1(223.19,6.54) 222.44,5.79 222.44,5.42 221.06,4.04 221.06,3.41 JDIMM2.180
DDR_B_D52: length 99.2
  IN4 w0.089: v1(223.19,8.06) 223.19,7.81 223.06,7.69 222.68,7.69 222.55,7.81 222.55,10.1 222.22,10.43 222.22,10.99 222.1,11.12 221.84,11.12 221.72,11.24 221.72,11.59 221.84,11.71 222.21,11.71 222.3,11.8 222.3,12.12 222.21,12.21 221.81,12.21 221.72,12.3 221.72,14.04 221.46,14.29 221.46,14.42 221.7,14.65 221.7,14.83 221.49,15.04 221.31,15.04 221.09,14.82 220.91,14.82 220.74,14.99 220.74,15.17 220.99,15.42 220.99,15.55 219.76,16.77 218.81,16.77 201.73,33.86 200.86,33.86 198.72,36 192.36,36 191.84,36.52 187.05,36.52 186.68,36.89 180.33,36.89 180.07,37.14 174.35,37.14 173.79,37.71 173.47,38.03 169.57,38.03 169.08,38.51 168.53,38.51 166.47,40.58 165.25,40.58 163.02,42.81 161.91,42.81 160.64,44.08 160.64,45.69 159.9,46.42 158.13,46.42 155.49,49.05 155.49,51.21 155.89,51.61 v1(155.89,51.69)
  BOTTOM w0.076: v1(155.89,51.69) 156.21,52.02 UC1.AN22
  BOTTOM w0.102: JDIMM2.181 221.36,10.44 222.12,9.68 222.12,9.12 v1(223.19,8.06)
DDR_B_D53: length 98.2
  IN4 w0.086: 170.65,40.84 168.39,40.84 167.56,41.67
  IN4 w0.089: v1(156.84,51.04) 157.21,50.67 157.21,50.18 159.18,48.21 160.02,48.21 161.9,46.33 161.9,46.28 162.76,45.42 162.76,44.67 165.76,41.67 167.56,41.67 ; v1(225.75,9.58) 225.75,9.78 225.62,9.91 225.39,9.91 225.26,10.04 225.26,10.35 225.39,10.48 225.73,10.48 225.86,10.61 225.86,10.79 225.73,10.91 224.9,10.91 224.77,11.04 224.77,11.29 224.86,11.38 225.77,11.38 225.86,11.47 225.86,11.79 225.77,11.88 224.86,11.88 224.77,11.97 224.77,12.38 224.86,12.47 225.14,12.47 225.27,12.6 225.27,12.84 225.14,12.97 224.86,12.97 224.77,13.06 224.77,14.32 220.51,18.58 219.57,18.58 199.79,38.36 189.72,38.36 189.06,39.02 181.34,39.02 180.92,39.44 180.8,39.44 180.62,39.26 180.47,39.26 180.37,39.37 180.37,39.52 180.57,39.72 180.57,39.86 180.21,40.21 180.03,40.21 179.57,39.75 179.39,39.75 179.22,39.92 179.22,40.1 179.68,40.56 179.68,40.71 179.55,40.84 179.26,40.84 178.87,40.45 178.74,40.45 178.35,40.84 170.65,40.84
  BOTTOM w0.076: v1(156.84,51.04) 157.17,51.37 UC1.AP21
  BOTTOM w0.102: JDIMM2.193 224.96,10.37 v1(225.75,9.58)
DDR_B_D54: length 100.6
  IN4 w0.089: v1(156.82,53.64) 157.16,53.3 157.95,53.3 158.24,53.01 158.24,49.7 158.25,49.7 159.33,48.62 160.13,48.62 162.25,46.5 162.25,46.45 163.14,45.56 163.14,44.85 165.94,42.05 168.14,42.05 168.66,41.53 179.96,41.53 181.83,39.65 192.05,39.65 192.72,38.98 200.03,38.98 216.19,22.82 217.17,22.82 226.5,13.49 226.5,5.76 v1(225.75,5.01)
  BOTTOM w0.076: v1(156.82,53.64) 157.14,53.97 UC1.AK21
  BOTTOM w0.102: v1(225.75,5.01) 225.42,5.01 224.66,4.25 JDIMM2.192
DDR_B_D55: length 101.2
  IN4 w0.089: v1(223.19,5.01) 222.87,4.7 222.07,4.7 221.95,4.83 221.95,9.81 221.11,10.65 221.11,13.62 201.47,33.25 200.6,33.25 198.46,35.39 192.1,35.39 191.58,35.91 186.79,35.91 186.42,36.28 180.08,36.28 179.82,36.53 174.1,36.53 173.24,37.39 169.2,37.39 168.72,37.87 168.31,37.87 166.08,40.11 165.17,40.11 163.07,42.2 161.87,42.2 160.26,43.82 160.26,45.56 159.8,46.03 158.01,46.03 157.73,46.31 154.48,49.57 154.48,51.81 155.49,52.82 155.49,53.25 v1(155.89,53.64)
  BOTTOM w0.076: UC1.AK22 156.21,53.97 v1(155.89,53.64)
  BOTTOM w0.102: JDIMM2.182 221.66,4.1 222.57,5.01 v1(223.19,5.01)
DDR_B_D56: length 62.9
  IN1 w0.089: v1(157.79,51.69) 157.43,51.33 157.43,49.64 158.77,48.3 158.77,47.98 159.24,47.51 159.24,46.85 159.7,46.38 159.93,46.38 162.09,44.22 162.09,43.01 165.11,39.99 165.11,39.14 165.35,38.9 165.35,35.42 168.84,31.94 168.84,31.81 168.54,31.52 168.54,31.4 168.77,31.17 168.89,31.17 169.19,31.46 169.31,31.46 169.54,31.24 169.54,31.11 169.24,30.82 169.24,30.7 169.47,30.47 169.59,30.47 169.89,30.76 170.01,30.76 170.24,30.54 170.24,30.41 169.94,30.12 169.94,29.99 170.17,29.77 170.29,29.77 170.59,30.06 170.71,30.06 170.94,29.84 170.94,29.71 170.65,29.42 170.65,29.29 170.87,29.07 171,29.07 171.29,29.36 171.41,29.36 171.76,29.02 171.76,25.69 182.57,14.88 182.57,8.39 v1(182.97,7.98)
  BOTTOM w0.076: v1(157.79,51.69) 158.12,52.02 UC1.AN20
  BOTTOM w0.102: JDIMM2.57 181.76,10.39 182.13,10.02 182.13,8.82 v1(182.97,7.98)
DDR_B_D57: length 62
  IN1 w0.089: v1(157.79,50.39) 157.79,49.53 158.94,48.38 158.94,48.06 159.42,47.58 159.42,46.95 159.75,46.61 160.02,46.61 162.4,44.23 162.4,42.95 165.29,40.06 165.29,39.39 166.19,38.48 166.19,37.73 165.87,37.42 165.87,37.02 166,36.9 166.19,36.9 166.32,36.77 166.32,36.57 166.2,36.45 165.94,36.45 165.87,36.39 165.87,36.16 166.28,35.76 166.28,35.63 166.02,35.37 166.02,35.19 166.19,35.02 166.37,35.02 166.61,35.25 166.79,35.25 166.96,35.08 166.96,34.9 166.72,34.67 166.72,34.49 166.89,34.32 167.07,34.32 167.33,34.58 167.46,34.58 167.8,34.24 167.8,34.12 167.54,33.86 167.54,33.74 167.76,33.51 167.89,33.51 168.15,33.77 168.27,33.77 168.5,33.54 168.5,33.42 168.24,33.16 168.24,33.03 168.46,32.81 168.59,32.81 168.85,33.07 168.97,33.07 169.2,32.84 169.2,32.72 168.94,32.46 168.94,32.33 169.16,32.11 169.29,32.11 169.55,32.37 169.67,32.37 169.9,32.14 169.9,32.02 169.64,31.76 169.64,31.63 169.86,31.41 169.99,31.41 170.25,31.67 170.37,31.67 170.6,31.44 170.6,31.32 170.34,31.06 170.34,30.93 170.56,30.71 170.69,30.71 170.95,30.97 171.07,30.97 171.3,30.74 171.3,30.62 171.04,30.36 171.04,30.23 171.27,30.01 171.39,30.01 171.65,30.26 171.77,30.26 172.06,29.98 172.06,25.82 182.87,15.01 182.87,9.6 v1(182.97,9.51)
  BOTTOM w0.076: UC1.AR20 158.12,50.72 v1(157.79,50.39)
  BOTTOM w0.102: JDIMM2.59 182.36,10.36 182.97,9.76 v1(182.97,9.51)
DDR_B_D58: length 63.6
  IN1 w0.086: 168.94,38.35 167.91,39.37 167.91,39.48 164.17,43.22 164.17,44.42 164.11,44.48
  IN1 w0.089: v1(185.59,9.51) 185.77,9.69 185.77,15.7 175.68,25.79 175.68,27.92 175.59,28.01 174.75,28.01 174.66,28.1 174.66,28.41 174.75,28.5 175.59,28.5 175.68,28.59 175.68,28.91 175.59,29 174.75,29 174.66,29.09 174.66,29.41 174.75,29.49 175.59,29.49 175.68,29.58 175.68,29.9 175.59,29.99 174.75,29.99 174.66,30.08 174.66,30.4 174.75,30.48 175.59,30.48 175.68,30.57 175.68,30.99 175.62,31.05 175.11,31.05 174.85,31.31 174.85,32.43 168.94,38.35 ; v1(158.71,53.6) 159.65,52.66 159.65,49.92 160.3,49.27 160.3,48.48 161.82,46.95 161.82,46.77 164.11,44.48
  BOTTOM w0.076: UC1.AK18 159.07,53.97 v1(158.71,53.6)
  BOTTOM w0.102: JDIMM2.69 185.36,9.74 v1(185.59,9.51)
DDR_B_D59: length 63.7
  IN1 w0.086: 167,40.05 167,39.77 168.34,38.43
  IN1 w0.089: 168.34,38.43 169.94,36.83 169.94,36.13 171.52,34.54 171.65,34.54 171.92,34.81 172.04,34.81 172.27,34.59 172.27,34.46 172,34.19 172,34.07 172.22,33.84 172.35,33.84 172.62,34.11 172.74,34.11 172.97,33.88 172.97,33.76 172.7,33.49 172.7,33.37 172.92,33.14 173.05,33.14 173.32,33.41 173.44,33.41 173.67,33.18 173.67,33.06 173.4,32.79 173.4,32.66 173.63,32.44 173.75,32.44 173.83,32.52 174.09,32.52 174.36,32.25 174.36,26.68 185.47,15.57 185.47,10.82 185.17,10.53 185.17,8.4 v1(185.59,7.98) ; v1(158.72,52.99) 159.35,52.36 159.35,49.96 160.1,49.22 160.1,48.42 161.61,46.91 161.61,46.67 163.81,44.47 163.81,43.24 167,40.05
  BOTTOM w0.076: UC1.AL18 159.05,53.32 v1(158.72,52.99)
  BOTTOM w0.102: JDIMM2.67 184.76,8.81 v1(185.59,7.98)
DDR_B_D60: length 64.4
  IN1 w0.089: v1(182.97,4.94) 181.95,5.96 181.95,14.64 170.87,25.71 170.87,28.2 164.72,34.36 164.72,38.77 164.59,38.9 164.59,40.01 161.71,42.89 161.71,44.07 159.79,45.99 159.51,45.99 159.43,46.07 158.76,46.74 158.76,47.36 158.2,47.91 158.2,48.26 156.43,50.04 156.43,53.83 156.69,54.09 157.4,54.09 v1(157.79,53.71)
  BOTTOM w0.076: UC1.AK20 158.05,53.97 v1(157.79,53.71)
  BOTTOM w0.102: v1(182.97,4.94) 182.97,4.89 182.06,3.98 JDIMM2.58
DDR_B_D61: length 63.3
  IN1 w0.089: v1(157.79,52.34) 157.24,51.79 157.24,49.48 158.5,48.22 158.5,47.95 159.01,47.43 159.01,46.79 159.64,46.17 159.87,46.17 161.89,44.14 161.89,42.96 164.91,39.94 164.91,38.96 165.04,38.83 165.04,34.47 166.74,32.77 166.86,32.77 167.16,33.06 167.28,33.06 167.51,32.84 167.51,32.71 167.21,32.42 167.21,32.3 167.44,32.07 167.56,32.07 167.86,32.36 167.98,32.36 168.21,32.14 168.21,32.01 167.91,31.72 167.91,31.6 171.18,28.33 171.18,25.84 182.25,14.77 182.25,7.18 v1(182.97,6.46)
  BOTTOM w0.076: UC1.AM20 158.12,52.67 v1(157.79,52.34)
  BOTTOM w0.102: JDIMM2.56 181.46,4.03 182.04,4.61 182.04,5.53 v1(182.97,6.46)
DDR_B_D62: length 60
  IN1 w0.089: v1(185.59,4.94) 185.15,5.38 185.15,6.65 184.87,6.93 184.87,7.75 184.51,8.11 184.51,10.83 184.86,11.18 184.86,14.72 173.26,26.32 173.26,29.86 173.35,29.95 173.66,29.95 173.75,30.04 173.75,30.36 173.66,30.45 173.35,30.45 173.26,30.54 173.26,30.93 168,36.19 168,37.9 166.42,39.47 166.42,39.86 163.11,43.17 163.11,44.54 161.17,46.47 161.17,46.82 159.72,48.28 159.72,48.9 158.75,49.87 v1(158.75,50.39)
  BOTTOM w0.076: UC1.AR18 159.07,50.72 v1(158.75,50.39)
  BOTTOM w0.102: JDIMM2.70 185.66,4.86 v1(185.59,4.94)
DDR_B_D63: length 61.3
  IN1 w0.089: v1(185.59,6.46) 185.59,6.64 185.17,7.05 185.17,7.87 184.87,8.18 184.87,10.71 185.16,11 185.16,15.44 174.05,26.55 174.05,30.95 173.77,31.23 173.77,31.36 173.93,31.52 173.93,31.64 173.7,31.87 173.58,31.87 173.42,31.71 173.29,31.71 173.07,31.93 173.07,32.06 173.23,32.22 173.23,32.35 173,32.57 172.88,32.57 172.72,32.41 172.59,32.41 168.99,36.01 168.99,37.34 166.78,39.55 166.78,39.94 163.45,43.27 163.45,44.55 161.41,46.6 161.41,46.84 159.91,48.34 159.91,49.03 159.12,49.82 159.12,50.67 v1(158.75,51.04)
  BOTTOM w0.076: v1(158.75,51.04) 159.07,51.37 UC1.AP18
  BOTTOM w0.102: v1(185.59,6.46) 184.99,5.86 184.99,4.82 185.06,4.74 JDIMM2.68
DDR_B_DQS0: length 87.9
  IN4 w0.102: v1(150.67,45.76) 150.67,45.95 150.74,46.03 150.97,46.03 151.64,45.36 151.64,40.49 151.66,40.48 152.78,39.36 153.58,38.56 153.58,37.78 164.09,27.26 173.61,27.26 175.03,25.85 191.21,25.85 191.84,25.22 194.73,25.22 195.54,24.41 196.1,24.41 206.29,14.21 206.29,12.55 209.29,9.55 209.29,8.07 209.21,8 209.1,8 v1(208.86,8.24)
  BOTTOM w0.076: UC1.AV30 150.59,48.94 150.59,48.79 150.51,48.7 150.51,48.2 150.48,48.15 150.47,48.13 150.45,48.09 150.43,48.03 150.43,47.83 150.45,47.78 150.45,47.77 150.5,47.67 150.5,47.42 150.16,47.08 150.16,46.26 v1(150.67,45.76)
  BOTTOM w0.102: v1(208.86,8.24) 208.53,8.24 208.14,8.63 208.14,10.23 208.16,10.25 JDIMM2.137
DDR_B_DQS1: length 55.9
  IN1 w0.102: v1(167.22,6.84) 167.22,6.62 167.34,6.5 167.76,6.5 167.84,6.59 167.84,9.55 167.27,10.12 167.27,15.52 163.18,19.62 163.18,20.46 154.06,29.57 154.06,33.15 153.68,33.53 153.68,39.2 152.91,39.96 152.91,41.91 153.26,42.27 153.26,43.07 153.66,43.47 154.06,43.47 154.37,43.78 v1(154.37,43.89)
  BOTTOM w0.076: UC1.AW26 153.11,48.38 153.11,48.16 153.07,48.08 153.04,48.01 153.03,47.99 153.03,47.87 153.06,47.82 153.06,47.81 153.11,47.71 153.11,47.25 152.77,46.91 152.77,46.54 153.76,45.55 153.76,43.9 154.03,43.63 154.22,43.63 154.37,43.79 v1(154.37,43.89)
  BOTTOM w0.102: JDIMM2.12 168.26,4 168.07,4.19 168.07,6.2 167.73,6.55 167.29,6.55 167.22,6.62 v1(167.22,6.84)
DDR_B_DQS2: length 95
  IN4 w0.102: v1(214.29,6.16) 214.1,6.35 213.7,6.35 213.46,6.58 213.46,7.83 213.83,8.19 213.83,8.68 213.55,8.96 213.55,10.79 211.83,12.51 211.83,13.36 210.45,14.74 210.45,15.19 197.66,27.98 197.01,27.98 195.55,29.43 185.24,29.43 184.92,29.75 176.13,29.75 175.05,30.83 166.32,30.83 162.68,34.47 162.26,34.47 158.29,38.44 158.29,38.49 157.96,38.82 157.4,38.82 156.88,39.34 156.77,39.34 154.76,41.35 154.76,45.84 153.93,46.66 153.93,47.48 153.73,47.69 153.27,47.69 152.8,48.16 152.8,48.62 151.62,49.79 151.62,51.78 v1(152.18,52.34)
  BOTTOM w0.076: UC1.AM28 152.51,52.67 v1(152.18,52.34)
  BOTTOM w0.102: v1(214.29,6.16) 214.08,6.37 213.91,6.37 213.69,6.15 213.69,4.74 213.26,4.31 JDIMM2.154
DDR_B_DQS3: length 58.8
  IN1 w0.086: 153.66,49.35 153.65,49.36 153.65,49.37 153.61,49.41 153.61,49.42 153.54,49.48 153.54,51.73 153.63,51.82 153.63,51.89 v1(154.09,52.34)
  IN1 w0.102: 153.66,49.35 153.66,49.34 155.42,47.59 155.42,46.72 155.7,46.43 155.7,41.36 157.32,39.74 157.32,35.25 157.61,34.97 157.61,31.01 169.31,19.31 169.31,18.47 173.54,14.24 173.54,12.54 173.57,12.52 173.57,11.9 173.78,11.68 173.97,11.68 174.09,11.55 174.09,11.3 173.97,11.17 173.76,11.17 173.52,10.93 173.52,10.02 173.76,9.78 173.76,9.78 173.77,9.76 173.77,8.22 173.69,8.13 173.5,8.13 v1(173.26,8.36)
  BOTTOM w0.076: UC1.AM25 154.41,52.67 v1(154.09,52.34)
  BOTTOM w0.102: v1(173.26,8.36) 173.26,8.12 173.13,7.99 172.98,7.99 172.82,8.16 172.81,8.16 172.81,9.44 173.18,9.81 173.18,10.08 173.36,10.26 JDIMM2.29
DDR_B_DQS4: length 92.5
  IN4 w0.102: v1(218.89,8.19) 218.99,8.08 219.17,8.08 219.4,8.31 219.4,9.37 218.45,10.32 218.45,13.29 201.14,30.6 200.02,30.6 198.71,31.92 198.1,31.92 197.07,32.95 189.85,32.95 189.53,33.28 177.59,33.28 176.51,34.36 167.8,34.36 163.8,38.35 163.38,38.35 162.75,38.99 162.68,39.05 161.12,40.61 159.98,40.61 159.76,40.83 159.06,40.83 158.71,41.19 157.65,41.19 157.27,41.57 157.27,45.4 157.14,45.53 156.93,45.53 156.81,45.4 156.38,45.4 v1(156.28,45.3)
  BOTTOM w0.076: v1(156.28,45.3) 155.78,45.8 155.78,46.5 155.52,46.75 155.52,47.38 155.63,47.48 155.63,47.67 155.59,47.77 155.59,47.78 155.56,47.83 155.56,48.03 155.59,48.09 155.61,48.13 155.61,48.15 155.64,48.2 155.64,48.85 UC1.AV22
  BOTTOM w0.102: JDIMM2.171 218.36,10.37 218.2,10.2 218.2,9.89 218.38,9.71 218.38,8 218.45,7.92 218.62,7.92 v1(218.89,8.19)
DDR_B_DQS5: length 56.8
  IN1 w0.102: v1(159.76,43.29) 159.76,43.22 159.43,42.9 159.3,42.9 159.14,42.74 159.14,41.78 159.81,41.11 160.63,41.11 161.44,40.3 161.44,32.89 168.77,25.56 168.77,24.84 179.27,14.33 179.27,8.09 179.18,7.99 178.88,7.99 178.77,8.1 v1(178.77,8.36)
  BOTTOM w0.076: v1(159.76,43.29) 159.76,43.2 159.43,42.88 159.25,42.88 158.83,43.3 158.83,46.05 158,46.87 158,47.18 158.24,47.41 158.24,47.71 158.19,47.81 158.19,47.82 158.17,47.87 158.17,47.99 158.17,48.01 158.2,48.08 158.24,48.16 158.24,48.48 158.34,48.58 UC1.AW18
  BOTTOM w0.102: v1(178.77,8.36) 178.77,8.11 178.65,7.99 178.38,7.99 178.26,8.1 178.26,9.89 178.39,10.02 178.55,10.02 178.76,10.23 JDIMM2.47
DDR_B_DQS6: length 98.7
  IN4 w0.102: v1(156.84,52.34) 156.26,51.76 156.26,50.17 158.8,47.63 159.8,47.63 160.41,47.02 160.41,46.63 161.66,45.38 161.66,43.97 162.09,43.54 162.93,43.54 165.41,41.06 166.72,41.06 167.86,39.91 169.83,39.91 169.92,39.82 177.46,39.82 179.27,38.02 188.55,38.02 189.21,37.36 199.37,37.36 219.15,17.58 220.09,17.58 223.77,13.91 223.77,6.63 224.06,6.34 224.3,6.34 v1(224.48,6.16)
  BOTTOM w0.076: v1(156.84,52.34) 157.17,52.67 UC1.AM21
  BOTTOM w0.102: v1(224.48,6.16) 224.48,6.2 224.33,6.35 224.1,6.35 224,6.25 224,4.73 223.46,4.19 JDIMM2.188
DDR_B_DQS7: length 62.1
  IN1 w0.102: v1(184.24,6.15) 184.1,6.29 183.81,6.29 183.58,6.51 183.58,11.39 183.93,11.74 183.93,14.66 172.56,26.03 172.56,30.19 166.82,35.93 166.82,38.24 165.52,39.55 165.52,40.22 162.59,43.15 162.59,44.4 160.78,46.21 160.78,46.67 159.31,48.14 159.31,48.44 158.17,49.57 158.17,51.77 158.42,52.02 v1(158.75,52.34)
  BOTTOM w0.076: v1(158.75,52.34) 159.07,52.67 UC1.AM18
  BOTTOM w0.102: JDIMM2.64 183.86,4.28 183.7,4.44 183.7,6.24 183.85,6.39 183.99,6.39 v1(184.24,6.15)
DDR_B_DQS#0: length 88
  IN4 w0.102: v1(150.67,46.41) 150.83,46.24 151.06,46.24 151.85,45.45 151.85,40.56 152.91,39.5 153.78,38.64 153.78,37.86 164.17,27.46 173.7,27.46 175.11,26.04 191.29,26.04 191.92,25.42 194.81,25.42 195.63,24.6 196.18,24.6 206.49,14.29 206.49,12.63 209.49,9.63 209.49,7.99 209.3,7.8 209.08,7.8 208.86,7.58 v1(208.86,7.48)
  BOTTOM w0.076: UC1.AW30 150.68,48.38 150.68,48.16 150.64,48.08 150.61,48.01 150.6,47.99 150.6,47.87 150.63,47.82 150.63,47.81 150.68,47.71 150.68,47.35 150.33,47.01 150.33,46.47 150.39,46.41 v1(150.67,46.41)
  BOTTOM w0.102: JDIMM2.135 207.56,10.31 207.94,9.93 207.94,8.55 208.86,7.63 v1(208.86,7.48)
DDR_B_DQS#1: length 56
  IN1 w0.102: v1(154.37,43.26) 153.75,43.26 153.47,42.99 153.47,42.2 153.11,41.83 153.11,40.04 153.87,39.28 153.87,33.61 154.26,33.23 154.26,29.66 163.37,20.54 163.37,19.7 166.11,16.95 167.47,15.6 167.47,10.2 168.04,9.63 168.04,6.51 167.84,6.31 167.32,6.31 167.22,6.21 v1(167.22,6.08)
  BOTTOM w0.076: v1(154.37,43.26) 154.18,43.45 153.95,43.45 153.58,43.82 153.58,45.48 152.59,46.47 152.59,46.98 152.93,47.32 152.93,47.67 152.88,47.77 152.88,47.78 152.86,47.83 152.86,48.03 152.88,48.09 152.9,48.13 152.91,48.15 152.94,48.2 152.94,48.7 153.03,48.79 153.03,48.94 UC1.AV26
  BOTTOM w0.102: v1(167.22,6.08) 167.49,6.35 167.64,6.35 167.87,6.12 167.87,4.46 167.86,4.46 167.86,4.37 167.66,4.17 JDIMM2.10
DDR_B_DQS#2: length 95.1
  IN4 w0.102: v1(152.22,51.69) 152.13,51.78 151.95,51.78 151.82,51.65 151.82,49.88 152.99,48.7 152.99,48.24 153.35,47.88 153.81,47.88 154.13,47.56 154.13,46.74 154.95,45.92 154.95,41.43 156.85,39.54 156.96,39.54 157.48,39.02 158.04,39.02 158.48,38.57 158.48,38.52 162.34,34.66 162.77,34.66 166.4,31.03 175.13,31.03 176.21,29.95 185,29.95 185.32,29.63 195.63,29.63 197.09,28.17 197.74,28.17 210.65,15.27 210.65,14.82 212.03,13.44 212.03,12.59 213.75,10.87 213.75,9.04 214.03,8.76 214.03,8.11 213.66,7.75 213.66,6.66 213.78,6.54 214.17,6.54 214.29,6.67 v1(214.29,6.92)
  BOTTOM w0.076: v1(152.22,51.69) 152.54,52.02 UC1.AN28
  BOTTOM w0.102: JDIMM2.152 212.66,4.13 212.79,4.26 212.92,4.26 213.49,4.82 213.49,6.23 213.82,6.57 214,6.57 214.29,6.86 v1(214.29,6.92)
DDR_B_DQS#3: length 58.9
  IN1 w0.086: 153.8,49.48 153.72,49.56 153.72,51.59 153.82,51.69 v1(154.09,51.69)
  IN1 w0.102: 153.8,49.48 155.61,47.68 155.61,46.8 155.9,46.51 155.9,41.44 157.52,39.82 157.52,35.33 157.81,35.05 157.81,31.09 169.5,19.39 169.5,18.55 173.74,14.32 173.74,12.62 173.76,12.6 173.76,11.98 173.86,11.88 174.05,11.88 174.29,11.63 174.29,11.22 174.05,10.98 173.84,10.98 173.71,10.85 173.71,10.1 173.84,9.97 173.84,9.97 173.97,9.85 173.97,8.14 173.77,7.93 173.39,7.93 173.26,7.8 v1(173.26,7.6)
  BOTTOM w0.089: v1(154.09,51.69) 154.09,51.79 154.32,52.02 UC1.AN25
  BOTTOM w0.102: v1(173.26,7.6) 173.26,7.62 173.09,7.79 172.9,7.79 172.61,8.07 172.61,9.5 172.61,9.5 172.61,9.52 172.98,9.89 172.98,9.98 172.89,10.07 172.88,10.07 172.76,10.19 172.76,10.48 JDIMM2.27
DDR_B_DQS#4: length 92.6
  IN4 w0.102: v1(156.28,45.86) 156.28,45.82 156.5,45.6 156.73,45.6 156.85,45.72 157.23,45.72 157.47,45.48 157.47,41.65 157.73,41.38 158.79,41.38 159.14,41.03 159.84,41.03 160.07,40.8 161.2,40.8 162.76,39.25 162.76,39.25 162.88,39.13 163.47,38.55 163.88,38.55 167.88,34.55 176.59,34.55 177.67,33.47 189.61,33.47 189.94,33.15 197.15,33.15 198.18,32.11 198.79,32.11 200.1,30.8 201.22,30.8 218.65,13.37 218.65,10.4 219.6,9.45 219.6,8.23 219.25,7.89 219.16,7.89 218.89,7.61 v1(218.89,7.43)
  BOTTOM w0.076: UC1.AW22 155.81,48.38 155.81,48.16 155.77,48.08 155.74,48.01 155.74,47.99 155.74,47.87 155.76,47.82 155.76,47.81 155.81,47.71 155.81,47.41 155.7,47.3 155.7,46.82 155.95,46.57 155.95,46.55 155.97,46.54 155.97,46.07 156.17,45.86 v1(156.28,45.86)
  BOTTOM w0.102: JDIMM2.169 217.76,10.37 218,10.13 218,9.81 218.18,9.63 218.18,7.91 218.36,7.72 218.64,7.72 218.89,7.48 v1(218.89,7.43)
DDR_B_DQS#5: length 56.9
  IN1 w0.102: v1(159.76,42.7) 159.46,42.7 159.34,42.57 159.34,41.86 159.89,41.3 160.71,41.3 161.63,40.38 161.63,32.97 168.96,25.65 168.96,24.92 179.47,14.42 179.47,8.01 179.25,7.79 178.95,7.79 v1(178.77,7.6)
  BOTTOM w0.076: UC1.AV18 158.45,49.03 158.07,48.65 158.07,48.2 158.04,48.15 158.04,48.13 158.02,48.09 157.99,48.03 157.99,47.83 158.02,47.78 158.02,47.77 158.06,47.67 158.06,47.48 157.83,47.25 157.83,46.8 158.65,45.98 158.65,43.22 159.17,42.7 v1(159.76,42.7)
  BOTTOM w0.102: JDIMM2.45 178.16,10.08 178.06,9.98 178.06,8.02 178.29,7.79 178.58,7.79 v1(178.77,7.6)
DDR_B_DQS#6: length 98.8
  IN4 w0.102: v1(224.48,6.92) 224.48,6.68 224.33,6.53 224.14,6.53 223.97,6.71 223.97,13.99 220.17,17.78 219.23,17.78 199.45,37.56 189.29,37.56 188.63,38.22 179.35,38.22 177.54,40.02 170,40.02 169.91,40.11 167.94,40.11 166.8,41.25 165.49,41.25 163.01,43.73 162.17,43.73 161.85,44.05 161.85,45.46 160.6,46.71 160.6,47.1 159.88,47.82 158.88,47.82 156.45,50.25 156.45,51.6 156.54,51.69 v1(156.85,51.69)
  BOTTOM w0.089: v1(156.85,51.69) 157.18,52.02 UC1.AN21
  BOTTOM w0.102: v1(224.48,6.92) 224.48,6.71 224.32,6.55 224.01,6.55 223.79,6.34 223.79,4.81 223.38,4.4 223.18,4.4 223.13,4.35 222.86,4.09 JDIMM2.186
DDR_B_DQS#7: length 62.2
  IN1 w0.102: v1(158.75,51.69) 158.75,51.76 158.69,51.82 158.5,51.82 158.37,51.69 158.37,49.65 159.5,48.52 159.5,48.22 160.97,46.76 160.97,46.29 162.78,44.48 162.78,43.23 165.71,40.3 165.71,39.63 167.02,38.32 167.02,36.01 172.76,30.27 172.76,26.11 184.13,14.74 184.13,11.66 183.78,11.31 183.78,6.59 183.89,6.48 184.01,6.48 184.24,6.71 v1(184.24,6.91)
  BOTTOM w0.076: UC1.AN18 158.92,52.02 158.75,51.84 v1(158.75,51.69)
  BOTTOM w0.102: v1(184.24,6.91) 184.24,6.74 184.09,6.59 183.77,6.59 183.5,6.33 183.5,4.42 183.26,4.18 JDIMM2.62
DDR_B_MA0: length 86.4
  IN4 w0.086: v1(144.48,51.69) 144.12,51.34 144.12,49.8 144.2,49.72 144.2,43.22 144.36,43.06 144.36,40.92
  IN4 w0.145: 144.36,40.92 144.36,34.32 163.34,15.34 189.28,15.34 190.92,13.7 191.38,13.7 195.42,9.66 195.42,6.56 v1(196.34,5.64)
  BOTTOM w0.076: UC1.AP40 144.8,51.37 v1(144.48,51.69)
  BOTTOM w0.168: JDIMM2.98 196.46,4.09 196.34,4.21 v1(196.34,5.64)
DDR_B_MA1: length 86.9
  IN4 w0.086: 145.21,40.92 145.21,43.6 144.63,44.18 144.63,49.81 144.86,50.03 144.86,50.57 144.49,50.94 v1(144.49,51.02)
  IN4 w0.145: v1(196.79,8.69) 196.33,9.15 196.33,10.07 196,10.4 196,10.61 196.05,10.65 196.05,10.86 195.84,11.06 195.64,11.06 195.59,11.02 195.39,11.02 195.18,11.22 195.18,11.43 195.23,11.47 195.23,11.68 195.02,11.88 194.82,11.88 194.77,11.84 194.57,11.84 194.27,12.13 194.27,13.86 193.26,14.88 192.2,14.88 192.05,15.03 192.05,15.95 191.91,16.09 191.38,16.09 191.24,15.95 191.24,15.32 191.03,15.12 190.72,15.12 190.51,15.32 190.51,15.94 190.26,16.19 163.7,16.19 145.21,34.68 145.21,40.92
  BOTTOM w0.076: UC1.AR40 144.79,50.72 v1(144.49,51.02)
  BOTTOM w0.168: v1(196.79,8.69) 196.16,9.32 JDIMM2.97
DDR_B_MA2: length 89.2
  IN4 w0.086: v1(143.5,50.98) 143.07,50.55 143.07,43.3 143.46,42.91 143.46,40.92
  IN4 w0.145: v1(194.96,7.17) 194.01,8.12 194.01,9.87 191.02,12.86 190.57,12.86 188.92,14.5 184.48,14.5 184.33,14.35 184.33,14.2 184.19,14.06 183.75,14.06 183.61,14.2 183.61,14.35 183.46,14.5 183.03,14.5 182.88,14.35 182.88,14.2 182.74,14.06 182.3,14.06 182.16,14.2 182.16,14.35 182.01,14.5 181.58,14.5 181.44,14.35 181.44,14.2 181.29,14.06 180.86,14.06 180.71,14.2 180.71,14.35 180.57,14.5 180.13,14.5 179.99,14.35 179.99,14.2 179.84,14.06 179.41,14.06 179.26,14.2 179.26,14.35 179.12,14.5 178.68,14.5 178.54,14.35 178.54,14.2 178.39,14.06 177.96,14.06 177.82,14.2 177.82,14.35 177.67,14.5 177.24,14.5 177.09,14.35 177.09,14.2 176.95,14.06 163.43,14.06 143.46,34.03 143.46,40.92
  BOTTOM w0.076: v1(143.5,50.98) 143.88,51.37 UC1.AP42
  BOTTOM w0.168: v1(194.96,7.17) 195.86,6.27 JDIMM2.96
DDR_B_MA3: length 88
  IN4 w0.086: v1(144.49,50.37) 144.49,50 144.42,49.93 144.42,43.87 144.79,43.51 144.79,40.92
  IN4 w0.145: v1(196.79,7.17) 195.88,8.08 195.88,9.88 193.52,12.23 193.52,12.45 193.84,12.77 193.84,13.46 193.62,13.68 193.29,13.68 192.82,13.21 192.47,13.21 192.14,13.54 192.14,13.74 192.34,13.94 192.34,14.14 192.13,14.35 191.93,14.35 191.73,14.15 191.53,14.15 191.23,14.45 190.78,14.45 189.47,15.77 163.52,15.77 144.79,34.5 144.79,40.92
  BOTTOM w0.076: v1(144.49,50.37) 144.14,50.72 UC1.AR42
  BOTTOM w0.168: v1(196.79,7.17) 196.14,7.82 196.14,8.52 195.56,9.1 JDIMM2.95
DDR_B_MA4: length 93.4
  IN4 w0.086: 143.04,40.92 143.04,42.67 142.7,43 142.7,49.52 142.57,49.65 141.43,49.65 141.34,49.74 141.34,50.16 v1(141.64,50.47)
  IN4 w0.145: v1(194.96,5.64) 195.58,5.03 195.58,4.52 195.47,4.41 194.51,4.41 194.4,4.52 194.4,5.38 194.24,5.54 193.73,5.54 193.59,5.68 193.59,6.12 193.73,6.26 194.24,6.26 194.39,6.4 194.39,6.84 194.24,6.98 193.73,6.98 193.59,7.13 193.59,9.69 190.85,12.43 190.39,12.43 189.19,13.63 188.74,13.63 188.6,13.78 188.6,13.93 188.45,14.07 188.02,14.07 187.87,13.93 187.87,13.78 187.73,13.63 187.29,13.63 187.15,13.78 187.15,13.93 187,14.07 186.57,14.07 186.43,13.93 186.43,13.78 186.28,13.63 185.85,13.63 185.7,13.78 185.7,13.93 185.56,14.07 185.12,14.07 184.98,13.93 184.98,13.78 184.83,13.63 163.25,13.63 143.04,33.85 143.04,40.92
  BOTTOM w0.076: v1(141.64,50.47) 141.89,50.72 UC1.AR45
  BOTTOM w0.168: v1(194.96,5.64) 194.48,5.16 194.48,4.49 194.66,4.31 JDIMM2.92
DDR_B_MA5: length 91.5
  IN4 w0.086: 143.94,40.92 143.94,42.93 143.43,43.44 143.43,50.1 143.87,50.54 143.87,51.21 143.73,51.35 143.23,51.35 142.9,51.68 141.81,51.68 141.71,51.58 v1(141.71,51.12)
  IN4 w0.145: 143.94,40.92 143.94,34.15 163.16,14.92 164.19,14.92 164.33,14.78 164.33,14.62 164.48,14.48 164.91,14.48 165.06,14.62 165.06,14.78 165.2,14.92 165.64,14.92 165.78,14.78 165.78,14.62 165.93,14.48 166.36,14.48 166.51,14.62 166.51,14.78 166.65,14.92 167.09,14.92 167.23,14.78 167.23,14.62 167.38,14.48 167.81,14.48 167.95,14.62 167.95,14.78 168.1,14.92 168.53,14.92 168.68,14.78 168.68,14.62 168.82,14.48 169.26,14.48 169.4,14.62 169.4,14.78 169.55,14.92 169.98,14.92 170.13,14.78 170.13,14.62 170.27,14.48 170.71,14.48 170.85,14.62 170.85,14.78 170.99,14.92 171.37,14.92 171.52,14.78 171.52,14.62 171.66,14.48 172.09,14.48 172.24,14.62 172.24,14.78 172.38,14.92 172.82,14.92 172.96,14.78 172.96,14.62 173.11,14.48 173.54,14.48 173.69,14.62 173.69,14.78 173.83,14.92 174.21,14.92 174.35,14.78 174.35,14.62 174.5,14.48 174.93,14.48 175.08,14.62 175.08,14.78 175.22,14.92 175.59,14.92 175.73,14.78 175.73,14.62 175.87,14.48 176.31,14.48 176.45,14.62 176.45,14.78 176.6,14.92 189.1,14.92 190.74,13.28 191.2,13.28 194.43,10.05 194.43,8.48 194.54,8.37 194.84,8.37 194.96,8.49 v1(194.96,8.69)
  BOTTOM w0.076: UC1.AP45 141.96,51.37 v1(141.71,51.12)
  BOTTOM w0.168: JDIMM2.91 194.36,9.3 v1(194.96,8.69)
DDR_B_MA6: length 96.4
  IN4 w0.086: v1(140.68,47.96) 140.31,47.59 140.31,47.04 140.5,46.85 140.82,46.85 141.47,46.21 141.47,42.24 142.19,41.52 142.19,40.92
  IN4 w0.145: v1(193.13,7.17) 192.42,7.17 192.19,7.4 192.19,9.89 190.5,11.58 190.04,11.58 189.56,12.06 163.45,12.06 149.94,25.58 149.73,25.58 149.56,25.41 149.39,25.41 149.05,25.74 149.05,25.92 149.22,26.09 149.22,26.29 148.94,26.57 148.73,26.57 148.12,25.96 147.92,25.96 147.61,26.27 147.61,26.47 148.22,27.09 148.22,27.29 147.81,27.7 147.61,27.7 147,27.09 146.8,27.09 146.49,27.4 146.49,27.61 147.1,28.21 147.1,28.42 146.79,28.72 146.58,28.72 145.98,28.12 145.77,28.12 145.47,28.43 145.47,28.63 146.07,29.24 146.07,29.44 145.76,29.75 145.56,29.75 144.95,29.14 144.75,29.14 144.44,29.45 144.44,29.65 145.05,30.26 145.05,30.47 144.74,30.77 144.54,30.77 143.93,30.17 143.72,30.17 143.42,30.47 143.42,30.68 144.02,31.29 144.02,31.49 143.72,31.8 143.51,31.8 142.9,31.19 142.7,31.19 142.39,31.5 142.39,31.7 143,32.31 143,32.51 142.19,33.33 142.19,40.92
  BOTTOM w0.076: UC1.AW46 140.98,48.26 v1(140.68,47.96)
  BOTTOM w0.168: v1(193.13,7.17) 194.06,6.24 JDIMM2.90
DDR_B_MA7: length 95.9
  IN4 w0.086: 141.76,40.92 141.76,41.66 141.24,42.18 141.24,45.89 v1(140.69,46.44)
  IN4 w0.145: v1(193.13,5.64) 192.81,5.64 192.68,5.52 192.68,4 192.81,3.88 195.96,3.88 196.09,3.75 196.09,3.06 195.96,2.94 191.88,2.94 191.75,3.06 191.75,9.73 190.32,11.16 189.81,11.16 189.33,11.64 163.27,11.64 149.96,24.95 148.33,24.95 141.76,31.51 141.76,40.92
  BOTTOM w0.076: v1(140.69,46.44) 141.09,46.84 UC1.AY46
  BOTTOM w0.168: JDIMM2.86 192.86,4.37 192.53,4.7 192.53,5.04 v1(193.13,5.64)
DDR_B_MA8: length 94.5
  IN4 w0.086: 142.61,40.92 142.61,41.68 141.86,42.43 141.86,46.08 v1(140.68,47.25)
  IN4 w0.145: v1(193.13,8.69) 192.8,8.69 192.68,8.82 192.68,10 190.67,12.01 190.21,12.01 189.73,12.49 188.72,12.49 188.49,12.72 188.49,13.02 188.3,13.21 187.43,13.21 187.29,13.06 187.29,12.63 187.14,12.49 186.71,12.49 186.56,12.63 186.56,13.06 186.42,13.21 185.98,13.21 185.84,13.06 185.84,12.63 185.69,12.49 185.26,12.49 185.11,12.63 185.11,13.06 184.97,13.21 184.57,13.21 184.44,13.08 184.44,12.82 184.32,12.69 183.9,12.69 183.77,12.82 183.77,13.08 183.64,13.21 182.85,13.21 182.7,13.06 182.7,12.63 182.56,12.49 182.12,12.49 181.98,12.63 181.98,13.06 181.83,13.21 181.4,13.21 181.25,13.06 181.25,12.63 181.11,12.49 180.68,12.49 180.53,12.63 180.53,13.06 180.39,13.21 179.95,13.21 179.81,13.06 179.81,12.63 179.66,12.49 179.23,12.49 179.08,12.63 179.08,13.06 178.94,13.21 178.49,13.21 178.36,13.08 178.36,12.64 178.23,12.51 177.79,12.51 177.66,12.64 177.66,13.08 177.53,13.21 176.92,13.21 176.8,13.08 176.8,12.63 176.67,12.5 176.16,12.5 176.03,12.63 176.03,13.08 175.91,13.21 175.43,13.21 175.3,13.08 175.3,12.65 175.17,12.52 174.71,12.52 174.59,12.65 174.59,13.08 174.46,13.21 173.71,13.21 173.57,13.06 173.57,12.66 173.44,12.54 172.97,12.54 172.85,12.66 172.85,13.06 172.7,13.21 171.17,13.21 171.02,13.06 171.02,12.63 170.88,12.49 170.44,12.49 170.3,12.63 170.3,13.06 170.15,13.21 169.72,13.21 169.58,13.06 169.58,12.63 169.43,12.49 169,12.49 168.85,12.63 168.85,13.06 168.71,13.21 167.64,13.21 167.5,13.06 167.5,12.63 167.35,12.49 166.92,12.49 166.77,12.63 166.77,13.06 166.63,13.21 164.38,13.21 164.25,13.08 164.25,12.64 164.12,12.51 163.6,12.51 163.47,12.64 163.47,13.08 163.35,13.21 163.08,13.21 142.61,33.67 142.61,40.92
  BOTTOM w0.076: UC1.AY47 140.33,47.61 v1(140.68,47.25)
  BOTTOM w0.168: v1(193.13,8.69) 193.76,9.32 JDIMM2.89
DDR_B_MA9: length 97.3
  IN4 w0.086: 140.17,40.92 140.32,41.07 140.32,43.49 140.72,43.88 140.72,45.35 140.13,45.94 140.13,49.11 140.28,49.26 v1(140.69,49.26)
  IN4 w0.145: v1(190.85,8.57) 190.49,8.57 190.33,8.73 190.33,9.91 189.92,10.31 189.45,10.31 188.97,10.79 162.88,10.79 156.96,16.71 156.76,16.71 156.16,16.12 155.96,16.12 155.65,16.42 155.65,16.63 156.25,17.23 156.25,17.43 155.94,17.74 155.73,17.74 155.14,17.14 154.93,17.14 154.62,17.45 154.62,17.65 155.22,18.25 155.22,18.45 154.91,18.76 154.71,18.76 154.11,18.16 153.91,18.16 153.6,18.47 153.6,18.68 154.2,19.27 154.2,19.48 153.89,19.79 153.69,19.79 153.09,19.19 152.88,19.19 152.58,19.5 152.58,19.7 153.17,20.3 153.17,20.5 152.87,20.81 152.66,20.81 152.06,20.21 151.86,20.21 151.55,20.52 151.55,20.72 152.15,21.32 152.15,21.53 151.84,21.83 151.64,21.83 151.04,21.24 150.83,21.24 150.53,21.54 150.53,21.75 151.12,22.35 151.12,22.55 150.82,22.86 150.61,22.86 150.02,22.26 149.81,22.26 139.69,32.38 139.69,40.05 140.13,40.49 140.13,40.87 140.17,40.92
  BOTTOM w0.076: UC1.AU46 140.99,49.56 v1(140.69,49.26)
  BOTTOM w0.168: JDIMM2.85 192.56,9.58 192.45,9.46 192.45,8.32 192.24,8.12 191.74,8.12 191.29,8.57 v1(190.85,8.57)
DDR_B_MA10: length 101.2
  IN4 w0.086: 147.33,40.92 147.27,40.98 147.27,43.63 146.34,44.56 146.34,53.25 v1(146.89,53.8)
  IN4 w0.145: 147.33,40.92 147.33,35.51 163.63,19.22 168.76,19.22 168.96,19.01 168.96,18.4 169.08,18.29 169.55,18.29 169.7,18.43 169.7,19.09 169.84,19.23 170.28,19.23 170.42,19.09 170.42,18.43 170.57,18.29 171,18.29 171.15,18.43 171.15,19.09 171.29,19.23 171.72,19.23 171.87,19.09 171.87,18.43 172.01,18.29 172.45,18.29 172.59,18.43 172.59,19.09 172.74,19.23 173.17,19.23 173.32,19.09 173.32,18.43 173.46,18.29 173.9,18.29 174.04,18.43 174.04,19.09 174.19,19.23 174.62,19.23 174.77,19.09 174.77,18.43 174.91,18.29 175.34,18.29 175.49,18.43 175.49,19.09 175.63,19.23 176.07,19.23 176.21,19.09 176.21,18.43 176.36,18.29 176.72,18.29 176.86,18.43 176.86,19.09 177.01,19.23 177.44,19.23 177.59,19.09 177.59,18.43 177.73,18.29 178.17,18.29 178.31,18.43 178.31,19.09 178.46,19.23 178.89,19.23 179.03,19.09 179.03,18.43 179.18,18.29 179.57,18.29 179.72,18.43 179.72,19.09 179.86,19.23 180.3,19.23 180.44,19.09 180.44,18.43 180.59,18.29 192.83,18.29 197.42,13.69 197.42,12.7 200.42,9.7 200.42,8.79 200.32,8.69 v1(199.99,8.69)
  BOTTOM w0.076: UC1.AK36 147.25,53.81 146.91,53.81 v1(146.89,53.8)
  BOTTOM w0.168: v1(199.99,8.69) 199.99,8.79 199.56,9.22 199.31,9.22 199.05,9.49 199.05,10.3 199.16,10.42 JDIMM2.107
DDR_B_MA11: length 97.1
  IN4 w0.086: 141.34,40.92 141.34,41.56 141.01,41.89 141.01,45.57 v1(140.69,45.89)
  IN4 w0.145: v1(190.85,7.04) 191.16,7.04 191.32,7.2 191.32,9.55 190.14,10.73 189.63,10.73 189.15,11.22 163.09,11.22 150.73,23.58 150.53,23.58 149.91,22.96 149.71,22.96 149.4,23.27 149.4,23.48 150.01,24.09 150.01,24.29 149.79,24.52 149.51,24.52 148.97,23.98 148.69,23.98 141.34,31.33 141.34,31.71 141.21,31.84 140.83,31.84 140.7,31.97 140.7,32.5 140.83,32.63 141.21,32.63 141.34,32.76 141.34,33.25 141.19,33.39 140.44,33.39 140.29,33.54 140.29,33.97 140.44,34.11 141.19,34.11 141.34,34.26 141.34,34.69 141.19,34.84 140.44,34.84 140.29,34.98 140.29,35.42 140.44,35.56 141.19,35.56 141.34,35.71 141.34,36.14 141.19,36.29 140.44,36.29 140.29,36.43 140.29,36.87 140.44,37.01 141.19,37.01 141.34,37.16 141.34,37.59 141.19,37.73 140.44,37.73 140.29,37.88 140.29,38.31 140.44,38.46 141.19,38.46 141.34,38.6 141.34,39.04 141.19,39.18 140.44,39.18 140.29,39.33 140.29,39.76 140.44,39.91 141.19,39.91 141.34,40.05 141.34,40.92
  BOTTOM w0.076: v1(140.69,45.89) 140.17,45.89 139.94,46.13 139.94,48.04 139.98,48.07 139.98,48.62 UC1.AV47
  BOTTOM w0.168: v1(190.85,7.04) 191.95,5.94 191.95,4.55 192.26,4.24 JDIMM2.84
DDR_B_MA12: length 93.8
  IN4 w0.086: v1(139.1,47.96) 139.54,47.52 139.54,45.27 138.78,44.51 138.78,42.89 137.1,41.21 137.1,40.92
  IN4 w0.145: 137.1,40.92 137.1,32.12 137.11,32.11 137.11,31.31 137.74,30.68 157.18,11.24 157.18,9.44 163.66,2.96 186.37,2.96 187.71,4.3 188.33,4.3 188.73,4.7 188.73,6.43 v1(189.47,7.17)
  BOTTOM w0.076: v1(139.1,47.96) 139.12,47.93 139.6,47.93 139.81,48.14 139.81,48.69 139.87,48.74 139.87,48.94 140.21,49.28 UC1.AU47
  BOTTOM w0.168: v1(189.47,7.17) 190.4,8.1 190.4,9.5 190.71,9.81 191.41,9.81 191.96,10.35 JDIMM2.83
DDR_B_MA13: length 101.8
  IN4 w0.086: 149.91,40.92 149.91,41.3 149.53,41.69 149.53,50.01 149.23,50.31 149.23,53.28 v1(148.79,53.71)
  IN4 w0.145: v1(203.55,8.69) 203.89,8.69 203.98,8.78 203.98,9.89 201.48,12.39 201.48,13.54 197.26,17.76 197.26,17.96 197.38,18.08 197.38,18.26 197.05,18.59 196.87,18.59 196.75,18.47 196.55,18.47 196.24,18.78 196.24,18.99 196.35,19.09 196.35,19.3 196.04,19.6 195.83,19.6 195.73,19.5 195.52,19.5 195.22,19.81 195.22,20.01 195.32,20.12 195.32,20.32 195.01,20.63 194.81,20.63 194.7,20.52 194.5,20.52 194.19,20.83 193.15,20.83 193.01,20.98 193.01,21.38 192.86,21.53 192.43,21.53 192.28,21.38 192.28,20.98 192.14,20.83 191.7,20.83 191.56,20.98 191.56,21.38 191.41,21.53 190.98,21.53 190.83,21.38 190.83,20.98 190.69,20.83 190.25,20.83 190.12,20.96 190.12,22.35 189.99,22.47 189.48,22.47 189.36,22.35 189.36,20.96 189.23,20.83 188.82,20.83 188.67,20.98 188.67,22.39 188.55,22.52 188.08,22.52 187.95,22.39 187.95,20.98 187.8,20.83 187.32,20.83 187.2,20.96 187.2,22.39 187.07,22.52 186.73,22.52 186.6,22.39 186.6,22.03 186.47,21.91 186.08,21.91 185.94,22.05 185.94,22.37 185.79,22.52 185.36,22.52 185.21,22.37 185.21,22.05 185.07,21.91 184.63,21.91 184.49,22.05 184.49,22.37 184.34,22.52 183.91,22.52 183.76,22.37 183.76,22.05 183.62,21.91 183.19,21.91 183.1,22 183.1,22.41 182.98,22.52 173.18,22.52 171.69,24.01 162.48,24.01 149.91,36.57 149.91,40.92
  BOTTOM w0.076: v1(148.79,53.71) 149.06,53.97 UC1.AK33
  BOTTOM w0.168: v1(203.55,8.69) 202.98,9.26 202.98,9.63 202.76,9.85 JDIMM2.119
DDR_B_MA14: length 99.2
  IN4 w0.086: 136.68,40.92 136.68,41.2 138.56,43.08 138.56,44.6 139.27,45.31 139.27,46.49 138.68,47.07 138.68,49.31 138.96,49.59 140.02,49.59 140.42,50 140.42,50.27 v1(140.69,50.54)
  IN4 w0.145: v1(190.85,5.52) 190.78,5.52 190.23,4.97 190.23,2.69 190.02,2.48 189.64,2.48 189.49,2.62 189.49,3.85 189.35,3.99 188.91,3.99 188.77,3.85 188.77,2.62 188.62,2.48 188.15,2.48 188.02,2.61 188.02,3.19 187.9,3.31 187.33,3.31 187.2,3.19 187.2,2.61 187.07,2.48 163.53,2.48 156.6,9.41 156.6,11.22 137.56,30.25 136.69,31.13 136.69,31.93 136.68,31.94 136.68,40.92
  BOTTOM w0.076: UC1.AR46 140.87,50.72 v1(140.69,50.54)
  BOTTOM w0.168: JDIMM2.80 191.06,4.21 191.35,4.5 191.35,5.02 v1(190.85,5.52)
