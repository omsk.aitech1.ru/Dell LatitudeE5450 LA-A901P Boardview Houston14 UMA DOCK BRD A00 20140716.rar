# Allegro board Houston14_UMA_DOCK_BRD_A00_20140716.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
MCP_TESTLOW2: length 6.8
  BOTTOM w0.076: UC1.C34 148.69,68.78 148.25,69.23 148.07,69.23 147.91,69.39 147.86,69.45 147.83,69.56 147.83,69.61 147.89,69.75 147.91,69.82 147.91,69.99 147.89,70.07 147.87,70.12 147.84,70.21 147.84,71.54 148.33,72.04 148.33,73.39
  BOTTOM w0.102: 148.33,73.39 v3(148.33,73.7) 148.33,74.5 RC241.1
MCP_TESTLOW3: length 21
  TOP w0.076: v1(170.47,38.85) 170.47,38.81 170.65,38.64 ; v2(164.63,53.86) 164.29,53.52 v1(164.29,53.43)
  TOP w0.102: 170.65,38.64 171.42,37.86 RC242.1
  IN3 w0.089: v1(164.29,53.43) 164.36,53.43 164.87,52.91 164.87,46.18 166.54,44.52 168.19,44.52 169.13,43.57 169.13,41.8 170.65,40.28 ; 170.65,39.03 v1(170.47,38.85)
  IN3 w0.122: 170.65,39.03 170.85,39.23 170.85,40.08 170.65,40.28
  BOTTOM w0.076: v1(164.29,53.43) 164.31,53.43 164.67,53.78 UC1.AK8
MCP_TESTLOW4: length 19
  TOP w0.076: 170.26,38.35 169.8,38.81 v1(169.8,39.41)
  TOP w0.102: RC243.1 170.47,38.14 170.26,38.35
  IN3 w0.089: v1(169.8,39.41) 169.74,39.41 166.28,42.87 166.28,44.14 163.28,47.13 163.28,49.98 163.4,50.09 163.4,52.16 163.63,52.4 163.84,52.4 164.26,52.82 v1(164.33,52.82)
  BOTTOM w0.076: v1(164.33,52.82) 164.64,53.13 UC1.AL8
ME_FWP: length 116.9
  TOP w0.102: v1(163.75,38.95) 163.39,38.59 v2(163.39,35.82) 163.39,35.44 167.37,31.45 189.71,31.45 192.58,34.32 192.58,35.08 197.58,40.07 198.04,40.07 198.55,40.58 198.71,40.58 199.1,40.96 223.85,40.96 225.12,42.23 235.72,42.23 236.32,42.83 236.32,43.49 236.98,44.15 236.98,45.83 237.86,46.71 237.86,49.85 239.03,51.02 239.03,54.43 238.58,54.88 v1(238.58,57.84)
  IN2 w0.122: v1(238.58,57.84) 237.2,57.84 v1(236.88,58.16)
  BOTTOM w0.076: v1(163.75,38.95) 164.15,39.35 164.15,39.64 163.97,39.82 RC301.1 RC11.1
  BOTTOM w0.102: SW1.3 232.6,67.71 236.96,63.34 236.96,60.47 237.41,60.02 237.41,58.98 236.88,58.45 v1(236.88,58.16)
ME_FWP_EC: length 137.9
  TOP w0.102: UE2.B46 253.61,58 253.66,57.95 254.18,57.95 254.55,58.32 254.55,58.35 v1(254.57,58.37) ; v1(237.01,59.5) 237.01,59.87 v4(237.2,60.06)
  IN2 w0.122: v1(254.57,58.37) 254.17,58.78 253.81,58.78 253.31,58.27 253.31,56.65 251.53,54.87 249.91,54.87 248.19,56.59 246.53,56.59 245.64,57.48 244.13,57.48 243.35,58.26 243.35,58.67 242.52,59.5 v1(237.01,59.5)
  IN3 w0.122: v1(237.01,59.5) 237.31,59.2 237.31,56.52 235.84,55.04 235.84,49.23 234.56,47.95 227.47,47.95 225.64,46.12 225.64,45.14 222.67,42.17 207.23,42.17 205.77,43.63 205.27,43.63 204.88,43.23 204.88,40.99 198.56,34.67 197.84,34.67 195.14,31.97 184.6,31.97 179.49,37.07 167.65,37.07 165.18,39.55 v1(163.72,39.55)
  BOTTOM w0.076: v1(163.72,39.55) 163.54,39.73 163.54,40.72 163.97,41.15 RC301.2
  BOTTOM w0.102: SW1.1 228.6,67.56 229.96,66.19 233.43,66.19 235.75,63.87 235.75,60.76 v1(237.01,59.5)
ME_RESET#: length 4.5
  TOP w0.102: UC4.2 177.38,59.5 177.56,59.68 177.56,60.11 v2(178.09,60.65) 177.46,61.28 RC80.1 RC95.2
ME_SUS_PWR_ACK: length 142.4
  TOP w0.076: 170.65,44.35 169.89,45.11 169.89,45.35 v1(169.58,45.66)
  TOP w0.102: v1(263.99,59.08) 263.83,59.25 UE2.A8 ; v1(264.31,45.76) 263.91,46.17 v2(263.44,46.17) ; 170.65,44.35 172.44,42.56 172.44,40.85 172.17,40.58 v1(172.17,38.79) 172.17,38.59 172.5,38.25 RC79.2
  IN2 w0.122: v1(264.31,45.76) 263.92,45.37 258.71,45.37 258.1,45.98 258.1,47.53 257.83,47.8 256.19,47.8 255.99,48 252.11,48 250.2,49.9 246.76,49.9 244.48,47.61 243.6,47.61 243.1,47.11 242.37,47.11 239.81,44.55 239.72,44.55 238.53,43.36 238.53,43.36 237.47,42.3 237.47,41.3 232.12,35.94 231.27,35.94 226.82,31.5 215.23,31.5 214.41,30.69 185.29,30.69 179.37,36.61 179.36,36.61 178.71,37.25 178.71,38.28 178.11,38.87 177.19,38.87 176.87,39.19 176.87,40.03 174.48,42.42 172.8,42.42 172.17,41.8 v1(172.17,38.79)
  BOTTOM w0.076: UC1.AV4 167.33,48.6 167.33,48.13 167.39,48.08 167.39,47.48 167.58,47.28 167.96,47.28 168.32,46.92
  BOTTOM w0.102: 168.32,46.92 v1(169.58,45.66) ; v1(264.31,45.76) 263.79,46.28 263.79,53.38 263.99,53.58 263.99,54.89 263.72,55.17 263.72,57.36 263.63,57.44 263.63,58.71 v1(263.99,59.08)
MEC_XTAL1: length 9.7
  TOP w0.102: UE2.A61 260.1,52.63 CE28.1 261.25,51.48 261.32,51.48 262.06,50.73 262.06,50.41 262.12,50.36 262.12,48.91 261.42,48.22 YE1.1 261.42,46.95 261.16,46.69 260.36,46.69 v2(260.17,46.5)
MEC_XTAL2: length 4.8
  TOP w0.102: RE61.2 262.72,50.61 CE29.1 262.72,49.02 YE1.2 264.83,47.82 v2(265.21,48.2)
MEC_XTAL2_R: length 3.6
  TOP w0.102: RE61.1 262.28,51.58 v2(261.3,52.56) 260.6,53.26 UE2.A62
MEDIACARD_IRQ#: length 203.9
  TOP w0.102: UR1.16 308.66,59.86 v1(308.6,59.79) ; v1(242.3,80) 241.97,79.68 v2(241.97,78.43)
  IN3 w0.122: v1(310.29,72.89) 309.68,73.5 301.21,73.5 300.05,72.34 294.65,72.34 293.71,73.28 285.74,73.28 282.32,69.86 275.7,69.86 271.78,73.78 270.08,73.78 269.76,73.46 268.17,73.46 267.1,74.53 262.83,74.53 262.05,75.31 261.63,75.31 261.49,75.45 260.73,75.45 260.36,75.82 260.36,79.86 261.28,80.77 261.28,81.09 261.02,81.35 260.27,81.35 258.85,79.92 252.44,79.92 251.24,78.72 245.39,78.72 245.04,79.07 243.14,79.07 242.3,79.9 v1(242.3,80)
  IN4 w0.086: v1(165.39,58.69) 165.39,58.5 165.61,58.28 167,58.28 167.22,58.5 167.49,58.5 167.83,58.85 168.31,58.85 169,58.16 171.51,58.16 171.77,58.41
  IN4 w0.089: v1(310.29,72.89) 310.44,72.74 312.57,72.74 314.11,71.2 314.11,67.87 313.07,66.83 313.07,64.32 313.8,63.58 314.31,63.58 314.79,63.1 314.79,61.74 314.22,61.17 309.97,61.17 v1(308.6,59.79) ; 171.77,58.41 176.8,58.41 176.88,58.49 179.47,58.49 179.68,58.28 181.99,58.28 v1(182.33,57.94) 182.35,57.94 182.71,57.57 186.27,57.57 186.53,57.83 187.22,57.83 187.97,58.57 190.84,58.57 191.94,59.67 191.94,59.78 194.76,62.6 195.36,62.6 196.46,63.7 196.46,66.75 196.52,66.81 196.52,72.19 202.06,77.73 202.06,78.91 203.89,80.75 204.17,80.75 204.38,80.97 217.84,80.97 218.27,81.4 220.69,81.4 221.09,81 230.17,81 231.2,79.97 239.51,79.97 240.1,80.56 241.74,80.56 v1(242.3,80)
  BOTTOM w0.076: v1(165.39,58.69) 165.53,58.55 165.53,58.35 UC1.AB6
  BOTTOM w0.102: v1(182.33,57.94) 182.33,58.16 182.65,58.47 RPC9.8
MEDIACARD_PWREN: length 3.1
  TOP w0.102: UR1.14 307.86,59.48 v2(307.63,59.25) 307.12,58.74 RR15.2
MEDIACARD_RST#: length 20.5
  TOP w0.102: v2(181.65,54.17) v1(182.17,54.69)
  IN4 w0.086: v1(165.39,54.8) 165.73,54.47 172.84,54.47
  IN4 w0.089: v1(182.17,54.69) 182.14,54.66 182.14,54.42 181.89,54.17 179.94,54.17 179.71,54.39 173.37,54.39 173.29,54.47 172.84,54.47
  BOTTOM w0.076: UC1.AG6 165.39,55.02 v1(165.39,54.8)
  BOTTOM w0.102: RPC10.8 183.3,55.43 182.94,55.06 182.55,55.06 182.18,54.69 v1(182.17,54.69)
MEM_SMBCLK: length 64.2
  TOP w0.102: v1(190.32,64.29) 190.35,64.29 190.45,64.19 190.45,63.97 191.33,63.1 191.33,57.87 190.11,56.66 189.12,56.66 188.58,56.12 188.58,53.62 189.36,52.84 v1(189.36,51.88) ; v1(174.69,62.42) 174.69,62.69 175.42,63.42 QC1.6 ; RPC14.1 179.39,61.27 v1(178.77,61.89)
  IN1 w0.086: 172.84,53.41 172.76,53.34 ; 171.77,52.34 171.06,51.63 v1(170.6,51.63)
  IN1 w0.089: v1(190.32,64.29) 190.22,64.39 189.15,64.39 188.33,65.22 188.33,66.54 187.95,66.92 185.31,66.92 185.08,67.15 182.18,67.15 181.19,66.16 181.19,63.26 180.58,62.65 179.46,62.65 178.78,61.97 178.77,61.95 v1(178.77,61.89) 178.33,61.46 177.28,61.46 175.86,62.88 175.15,62.88 v1(174.69,62.42) ; v1(189.36,51.88) 189.36,51.88 188.81,51.34 184.96,51.34 184.78,51.51 179.46,51.51 177.79,53.19 177.79,53.46 177.06,54.19 173.62,54.19 172.84,53.41 ; 172.76,53.34 171.77,52.34
  BOTTOM w0.076: v1(170.6,51.63) 170.12,51.15 169.28,51.15 169.12,51.31 168.85,51.31 168.57,51.02 UC1.AP2
MEM_SMBDATA: length 65.4
  TOP w0.102: QC1.3 176.54,64.72 v1(176.36,64.9) ; v1(190.08,51.98) 190.08,52.57 189.04,53.61 189.04,55.9 189.32,56.17 190.31,56.17 191.81,57.67 191.81,63.3 190.93,64.17 v1(190.93,64.29) ; RPC14.2 179.25,60.77 v1(178.13,61.89)
  IN1 w0.086: 172.51,53.74 172.49,53.73 172.49,53.73 172.45,53.68 172.45,53.68 172.43,53.67
  IN1 w0.089: v1(190.93,64.29) 190.93,64.35 190.42,64.86 189.35,64.86 188.8,65.41 188.8,66.73 188.14,67.39 185.5,67.39 185.27,67.62 181.99,67.62 180.72,66.35 180.72,63.46 180.39,63.12 179.36,63.12 v1(178.13,61.89) 177.51,61.89 176.95,62.45 176.95,63.24 176.36,63.82 v1(176.36,64.9) ; 172.43,53.67 172.09,53.32 170.85,53.32 170.5,53.67 v1(170.5,53.72) ; 172.51,53.74 173.43,54.66 177.25,54.66 178.55,53.37 178.55,53.09 179.66,51.98 184.98,51.98 185.22,51.74 188.56,51.74 189.02,52.21 189.02,52.22 189.17,52.36 189.7,52.36 v1(190.08,51.98)
  BOTTOM w0.076: v1(170.5,53.72) 170.22,53.72 170.06,53.89 170.05,53.89 169.16,54.77 UC1.AH1
MIC1_L: length 2.8
  TOP w0.203: UA1.19 26.51,98.39 v2(27.08,98.96) 27.08,99.32 27.79,100.03 CA43.1
MIC1_R: length 2.4
  TOP w0.203: UA1.20 26.11,98.49
  TOP w0.254: CA44.1 26.64,99.44 26.11,98.91 26.11,98.49
MMICLK_REQ#: length 197.6
  TOP w0.102: UR1.17 309.06,59.45 v1(308.88,59.26) ; v1(235.64,65.28) 235.18,65.74 235.18,68.87 v2(228.4,75.65) 227.7,76.35 227.7,79.25 226.85,80.1 221.85,80.1 220.28,81.68 215.02,81.68 213.8,82.9 v1(213.8,82.91)
  IN1 w0.089: v1(308.88,59.26) 309.02,59.4 309.02,60.59 307.33,62.29 307.33,64.57 307.03,64.87 299.97,64.87 298.62,66.23 291.66,66.23 291.06,65.64 276.61,65.64 276.19,65.22 268.16,65.22 266.81,66.56 265.63,66.56 262.94,63.87 261.12,63.87 260.65,63.41 260.65,62.38 259.73,61.46 254.28,61.46 254.18,61.56 253.26,61.56 253.03,61.79 253.03,62.7 252.7,63.03 252.7,63.24 251.89,64.05 249.36,64.05 248.84,63.54 241.5,63.54 240.94,64.1 236.82,64.1 v1(235.64,65.28)
  IN2 w0.122: v1(213.8,82.91) 213.8,82.82 213.37,82.39 209.91,82.39 209.18,81.66 203.11,81.66 199.69,78.24 199.69,76.83 199.98,76.55 199.98,70.62 199.11,69.75 199.11,68.27 199.71,67.67 199.71,65.23 199.71,64.34 202.93,61.12 202.93,60.49 198.31,55.87 194.99,55.87 194.47,56.39 189.11,56.39 188.46,55.73 187.2,55.73 186.28,56.65 184.9,56.65 183.33,55.07 182.37,55.07 181.98,55.46 181.29,55.46 181.28,55.47 179.31,57.44 178.84,57.44 178.49,57.8 v1(178.49,57.84)
  BOTTOM w0.076: 171.77,61.31 171.16,61.31 170.99,61.47 170.99,61.75 170.86,61.88 170.7,62.05 170.42,62.05 170.13,61.76 170.13,61.54 169.8,61.22 168.78,61.22 UC1.U2
  BOTTOM w0.102: 171.77,61.31 172.35,61.31 173.75,59.91 175.43,59.91 177,58.33 177.99,58.33 v1(178.49,57.84) 178.73,57.84 178.86,57.97 RPC17.7
MPCIE_RST#: length 12
  BOTTOM w0.076: 171.77,59.86 171.23,60.39 169.45,60.39 169.08,60.02 UC1.V1
  BOTTOM w0.102: RPC17.5 179.07,56.97 178.9,56.81 v2(177.24,56.81) 174.92,59.13 172.49,59.13 171.77,59.86
MPHYP_PWR_EN: length 77.6
  TOP w0.102: QZ10.2 176.03,83.38 175.84,83.57 175.84,84.57 v1(175.96,84.69) ; v1(183.21,58.93) 183.53,59.25 RC171.1 RC155.1 ; v1(191.62,84.52) 191.62,84.08 v2(191.43,83.89)
  IN1 w0.086: 171.77,59.06 171.65,59.06 v1(171.06,59.65)
  IN1 w0.089: v1(183.21,58.93) 182.73,59.41 180.78,59.41 180.3,59.9 173.83,59.9 173,59.06 171.77,59.06
  IN2 w0.086: v1(171.06,59.65) 171.77,59.65
  IN2 w0.122: 171.77,59.65 171.86,59.65 174.19,61.98 175.58,61.98 175.88,62.28 175.88,63.32 176.06,63.5 178.42,63.5 178.46,63.54 179.69,63.54 181.49,65.34 183.72,65.34 185.5,67.11 187.29,67.11 187.44,66.96 189.67,66.96 v1(190,67.29)
  IN3 w0.122: v1(191.62,84.52) 191.62,84.4 191.42,84.2 176.4,84.2 175.96,84.64 v1(175.96,84.69)
  BOTTOM w0.076: UC1.Y2 168.48,59.27 168.62,59.13 168.63,59.13 168.8,58.96 169.23,58.96 169.3,59.04 170.44,59.04 v1(171.06,59.65)
  BOTTOM w0.102: v1(191.62,84.52) 189.9,82.81 189.9,67.39 v1(190,67.29)
MPHYP_PWR_EN#: length 3.4
  TOP w0.102: QZ10.6 QZ10.5 178.8,83.38 179.31,82.87 RZ16.2 v2(179.67,84.01)
MSATA_DEVSLP: length 139.9
  TOP w0.102: v2(284.06,94.5) RZ39.2 283.41,93.03 v1(283.34,93.11)
  IN1 w0.086: 171.77,63.12 171.42,62.77 170.61,62.77 170.4,62.98 170.4,63.12 v1(170.13,63.12)
  IN1 w0.089: 171.77,63.12 172.36,63.12 174.02,64.77 174.02,65.89 174.97,66.84 174.97,68.02 174.55,68.44 174.55,71.5 177.62,74.58 195.76,74.58 201.69,80.51 204.15,80.51 204.58,80.93 215.25,80.93 216.24,81.93 220.87,81.93 221.86,80.94 236.68,80.94 240.54,84.8 255.97,84.8 256.58,85.41 260.93,85.41 261.4,85.88 269.83,85.88 270.05,86.1 276.47,86.1 277.55,87.18 282.59,87.18 v1(282.74,87.33)
  IN2 w0.122: v1(283.34,93.11) 282.85,92.62 282.85,90.83 282.52,90.5 282.52,89.7 282.98,89.25 282.98,87.57 v1(282.74,87.33)
  BOTTOM w0.076: UC1.P2 168.33,62.38 168.69,62.73 169.16,62.73 169.35,62.92 169.93,62.92 v1(170.13,63.12)
  BOTTOM w0.102: JNGFF2.30 283.59,92.85 283.36,93.08 283.36,93.08 v1(283.34,93.11)
MSCLK: length 75.2
  TOP w0.102: v1(254.62,59.26) 254.47,59.41 254.47,59.46 254.2,59.73 254.2,59.72 253.88,59.72 253.67,59.52 253.27,59.52 UE2.B43
  IN1 w0.089: v1(254.62,59.26) 255.78,59.26 256.06,58.98 260.35,58.98 260.41,58.92 262.74,58.92 263,58.65 270.22,58.65 270.77,58.11 281.46,58.11 281.72,57.84 287.72,57.84 v1(288.44,58.56)
  IN2 w0.122: v1(288.44,58.56) 288.37,58.49 288.37,56.28 288.28,56.19 288.28,53.98 289.27,52.99 289.27,48.96 287.41,47.11 287.41,41.98 286.85,41.42 286.85,38.43 284.33,35.91 282.68,35.91 v1(281.69,36.89)
  BOTTOM w0.102: JDEG1.6 281.52,37.06 v1(281.69,36.89) 282.7,35.88 286.94,35.88 287.75,35.07 v2(287.75,34.74) 288.16,34.33 289.48,34.33 RE72.2
MSDATA: length 82.1
  TOP w0.102: RE86.2 250.28,60.77 250.98,60.07 ; 250.98,60.07 v1(250.99,60.07) ; 250.98,60.07 250.98,59.87 251.26,59.58 251.95,59.58 252.12,59.75 UE2.A40
  IN1 w0.089: v1(288.79,55.93) 287.74,55.93 286.37,57.3 281.59,57.3 281.26,57.64 270.57,57.64 270.03,58.18 262.67,58.18 262.45,58.4 260.05,58.4 259.94,58.51 255.16,58.51 254.88,58.79 252.07,58.79 250.99,59.87 v1(250.99,60.07)
  IN2 w0.122: v1(281.02,36.87) 281.02,36.74 282.38,35.38 284.57,35.38 287.36,38.18 287.36,40.99 287.92,41.54 287.92,46.88 289.81,48.77 289.81,53.16 288.79,54.19 v1(288.79,55.93)
  BOTTOM w0.102: RE75.2 289.56,33.84 287.81,33.84 v2(287.25,33.28) 284.28,33.28 281.02,36.53 v1(281.02,36.87) JDEG1.7
NB_LAN_TX0+: length 17.5
  BOTTOM w0.229: TL1.19 303.04,102.06 302.36,102.73 v3(297.71,102.73) 296.54,102.73 292.54,106.73 292.54,109.02 JLOM1.1
NB_LAN_TX0-: length 17.5
  BOTTOM w0.229: TL1.20 304.31,100.28 303.96,100.62 303.57,100.62 303.39,100.8 303.39,102.19 v3(303,102.57) 302.5,103.08 296.68,103.08 292.89,106.87 292.89,107.81 293.05,107.98 JLOM1.2
NB_LAN_TX1+: length 21
  BOTTOM w0.229: TL1.23 308.12,100.5 308.56,100.94 308.56,101.52 308.02,102.06 305.84,102.06 303.99,103.91 v3(301.09,103.91) 297.13,103.91 295.16,105.88 295.16,106.86 294.52,107.5 JLOM1.3
NB_LAN_TX1-: length 21
  BOTTOM w0.229: TL1.24 309.39,100.42 308.9,100.9 308.9,101.67 308.17,102.4 305.98,102.4 304.13,104.26 v3(298.83,104.26) 297.27,104.26 295.5,106.02 295.5,106.62 296.86,107.98 JLOM1.6
NB_LAN_TX2+: length 10.1
  IN4 w0.241: v1(295.98,101.5) 296.09,101.61 296.09,103.04 295.67,103.46 295.67,106.55 296.29,107.18 296.29,107.85 296.16,107.98 JLOM1.4
  BOTTOM w0.229: TL1.13 295.42,100.18 296.11,100.88 296.11,101.37 v1(295.98,101.5)
NB_LAN_TX2-: length 10.3
  IN4 w0.241: v1(296.57,101.5) 296.48,101.59 296.48,103.2 296.06,103.62 296.06,106.39 296.68,107.01 296.68,108.96 JLOM1.5
  BOTTOM w0.229: v1(296.57,101.5) 296.51,101.44 296.51,100.75 296.69,100.57 TL1.14
NB_LAN_TX3+: length 10.6
  IN4 w0.241: v1(300.33,102) 300.44,102.11 300.44,103.26 298.6,105.1 JLOM1.7
  BOTTOM w0.229: TL1.17 300.5,100.79 300.46,100.83 300.46,101.87 v1(300.33,102)
NB_LAN_TX3-: length 10.6
  IN4 w0.241: JLOM1.8 299.29,107.98 299,107.69 299,105.26 300.84,103.42 300.84,102.07 v1(300.91,102)
  BOTTOM w0.229: v1(300.91,102) 300.89,101.97 300.89,101.97 300.8,101.88 300.8,101.2 301.09,100.9 301.61,100.9 301.77,100.75 TL1.18
NB_PSID: length 10.9
  TOP w0.102: v1(47.71,89.74) v2(47.71,90.41)
  IN2 w0.254: v1(47.71,89.74) 50.08,87.38 v1(50.08,85.16)
  BOTTOM w0.254: v1(50.08,85.16) 50.5,84.74 PL3.2
NB_PSID_TS5A63157: length 3.8
  BOTTOM w0.102: 41.9,82.63 v2(41.9,83.56)
  BOTTOM w0.254: PR9.2 43.32,82.92 PR8.1 42.19,82.92 41.9,82.63 PU1.3
NFC_IRQ: length 17.3
  TOP w0.076: v1(171.1,50.4) 171.46,50.04 171.46,50.01 171.77,49.71
  TOP w0.102: RC175.1 176.2,41.79 v2(176.2,42.48) 176.2,43.11 174.02,45.29 174.02,46.61 173.9,46.73 173.9,48.28 172.86,49.32 172.16,49.32 171.77,49.71
  BOTTOM w0.076: v1(171.1,50.4) 171.1,51.63 170.71,52.03 169.15,52.03 169.11,52.07 168.86,52.07 168.69,51.9 168.69,51.72 168.46,51.48 167.94,51.48 UC1.AN3
NGFF_CONFIG_0: length 51.8
  TOP w0.102: v2(290.49,87.95) 290.74,88.2 v1(291.01,88.2) ; RPE4.1 248.84,87.07 248.81,87.04 248.81,86.59 249.19,86.21 249.19,86.17 v1(249.19,86.17) ; UE1.B12 252.92,83.78 v1(252.39,83.25)
  IN1 w0.089: v1(252.39,83.25) 253.68,81.96 255.73,81.96 256.43,82.66 264.5,82.66 266.78,84.94 269.06,84.94 269.79,84.22 279.9,84.22 281.46,85.78 287.32,85.78 289.57,88.03 290.83,88.03 v1(291.01,88.2)
  IN2 w0.122: v1(252.39,83.25) 251.22,84.42 249.81,84.42 249.24,84.99 249.24,86.11 249.19,86.16 v1(249.19,86.17)
  BOTTOM w0.102: JNGFF2.13 291.26,88.6 291.01,88.34 v1(291.01,88.2)
NGFF_CONFIG_1: length 66.4
  TOP w0.102: v1(249.22,86.77) 249.34,86.89 RPE4.2 ; v1(250,98.45) 249.97,98.48 v2(249.97,99.13) ; v1(248.09,83.25) 248.13,83.21 248.13,83.16 248.6,82.69 UE1.A18
  IN3 w0.122: v1(285.47,103.63) 284,102.16 256.21,102.16 254.19,100.14 251.69,100.14 v1(250,98.45)
  BOTTOM w0.102: v1(248.09,83.25) 248.13,83.29 248.13,85.78 249.12,86.77 v1(249.22,86.77) 249.22,89.22 250.96,90.96 250.96,95.36 250,96.33 v1(250,98.45) ; v1(285.47,103.63) 285.85,104.02 287.83,104.02 288.05,103.79 288.05,101.78 289.23,100.6 JNGFF2.61
NGFF_CONFIG_2: length 82.2
  TOP w0.102: v1(250.43,86.65) 250.3,86.65 249.84,87.12 RPE4.3 ; UE1.A44 v1(256.17,73.22)
  IN2 w0.122: v1(250.43,86.65) 256.44,86.65 v1(257.06,86.04)
  IN3 w0.122: v1(284.86,103.66) 283.71,102.5 253.62,102.5 v1(252.73,101.62)
  BOTTOM w0.102: v1(252.73,101.62) 252.65,101.69 251.69,101.69 251.36,101.36 251.36,96.33 251.83,95.86 251.83,88.41 251.55,88.13 251.55,87.77 v1(250.43,86.65) ; JNGFF2.67 290.75,102.1 290.27,101.62 288.61,101.62 288.33,101.89 288.33,103.84 287.92,104.24 285.45,104.24 v1(284.86,103.66) ; v1(257.06,86.04) 257.18,85.92 257.18,83.57 257.29,83.46 257.29,83.04 256.36,82.11 256.36,76.72 255.93,76.29 v2(255.93,74.75) 256.17,74.52 v1(256.17,73.22)
NGFF_CONFIG_3: length 87.6
  TOP w0.102: UE1.B34 249.52,75.44 v1(249.16,75.08) ; v1(294.35,84.24) v2(294.35,83.58) ; RPE4.4 250.34,87.33 250.86,86.81 250.86,86.44 v1(250.48,86.06)
  IN3 w0.122: v1(250.48,86.06) 250.48,86.12 250.85,86.48 250.85,86.6 251.68,87.43 252.35,87.43 252.93,88.02 256.17,88.02 256.9,88.75 257.7,88.75 262.05,93.11 266.5,93.11 267.3,93.91 274.37,93.91 275.41,94.95 278.36,94.95 278.78,95.37 280.48,95.37 280.87,95.76 280.87,100.66 281.11,100.9 286.77,100.9 288.19,99.47 288.19,97.98 289.31,96.87 289.31,91.01 289.61,90.71 289.61,86.46 291.84,84.23 294.34,84.23 v1(294.35,84.24)
  BOTTOM w0.102: JNGFF2.1 293.71,83.6 v1(294.35,84.24) ; v1(250.48,86.06) 250.48,85.52 249.12,84.17 249.12,81.36 250.03,80.45 250.03,78.81 250.14,78.7 251.22,78.7 251.54,78.39 251.54,77.46 251.22,77.14 249.73,77.14 249.52,76.93 249.52,75.44 v1(249.16,75.08)
O-USR: length 4.8
  TOP w0.102: v2(101.77,73.85) 102.02,73.85 v3(102.4,73.47)
  TOP w0.254: PR509.2 v3(102.4,73.47)
  BOTTOM w0.203: v3(102.4,73.47) 103.04,73.47 103.21,73.3 PU500.9
  BOTTOM w0.254: PR504.1 101.64,74.23 v3(102.4,73.47)
OCP-I: length 6.4
  TOP w0.102: v2(104.48,76.37) 104.64,76.22 PR524.2
  TOP w0.254: PR506.2 105.45,73.22 v3(104.66,74.01) 104.64,74.03 PR524.2
  BOTTOM w0.203: v3(104.66,74.01) 104.41,73.75 PU500.12
  BOTTOM w0.254: v3(104.66,74.01) 104.69,74.03 PR501.1
OUT1_CA_DET: length 3.6
  BOTTOM w0.102: v2(141.16,98.86) 142.01,98.86 RV67.2 142.19,98.58 141.36,97.75 141.36,97.16 141.25,97.04 UV7.43
OUT2_CA_DET: length 14.6
  TOP w0.102: v1(139.15,101.25) v2(139.15,101.97)
  IN4 w0.089: v1(145.75,102.75) 144.69,101.69 139.6,101.69 v1(139.15,101.25)
  BOTTOM w0.102: RV68.2 145.99,102.99 v1(145.75,102.75) ; v1(139.15,101.25) 139.09,101.25 137.05,99.2 137.05,98.01 137.25,97.81 UV7.33
P33ALW: length 5
  BOTTOM w0.102: v2(109.36,54.3) 107.58,54.3 107.28,53.99 PR859.1
  BOTTOM w0.254: PU800.18 105.85,55.22 PR859.1
P33ALW2: length 3.1
  BOTTOM w0.254: v2(105.96,61.97) PR855.2 104.4,61.43 PU800.9
PANEL_BKEN_EC: length 187.3
  TOP w0.102: v1(252.45,76.29) 252.45,75.55 251.92,75.02 UE1.B38
  IN3 w0.122: v1(252.45,76.29) 251.7,77.04 248.68,77.04 248.01,77.71 245.68,77.71 244.82,78.58 242.72,78.58 236.55,84.75 234.09,84.75 234.09,84.74 233.22,84.74 233.22,84.75 224.09,84.75 221.72,87.12 211.8,87.12 210.16,85.49 194.3,85.49 192.13,83.32 175.01,83.32 173.06,85.27 168.28,85.27 166.91,86.64 156.16,86.64 153.14,89.66 153.14,91.2 151.43,92.92 150.73,92.92 149.69,93.95 147.04,93.95 145.59,92.5 144.62,92.5 141.77,95.34 139.31,95.34 137.53,97.12 137.53,99.07 135.53,101.07 133.36,101.07 132.85,101.58 128.12,101.58 126.23,99.68 120.05,99.68 119.24,100.5 108.63,100.5 106.09,97.97 102.36,97.97 100.52,96.13 89.9,96.13 89.31,95.53 v1(89.31,94.82)
  BOTTOM w0.102: DV2.2 v2(89.06,95.32) 89.31,95.07 v1(89.31,94.82)
PANEL_BKLEN: length 112.8
  IN3 w0.086: 163.96,73.39 163.88,73.32 v1(163.88,72.53)
  IN3 w0.122: v1(87.96,92.04) 88.75,91.25 103.26,91.25 106.9,94.88 108.99,94.88 110.84,96.74 116.54,96.74 117.21,97.4 128.56,97.4 129.5,98.34 133.12,98.34 135.13,96.33 135.13,92.31 135.71,91.72 135.71,90.68 137.53,88.87 142.61,88.87 142.84,88.64 144.51,88.64 147.2,85.95 149.09,85.95 150.63,84.41 150.63,83.72 154.43,79.92 158.81,79.92 160.3,81.41 160.3,82.18 160.76,82.64 162.28,82.64 162.6,82.32 164.24,82.32 165.12,81.45 166.13,81.45 167.54,80.04 167.54,79.01 166.78,78.25 166.23,78.25 164.02,76.04 164.02,73.46 163.96,73.39
  BOTTOM w0.076: UC1.A9 163.53,72.2 163.86,72.52 163.86,72.56 v1(163.88,72.53)
  BOTTOM w0.102: v1(87.96,92.04) 87.76,92.24 DV2.3
PBAT_PRES#: length 306.4
  TOP w0.102: UE2.A49 254.1,53.84 253.92,53.66 253.28,53.66 253.05,53.89 v1(253.05,54.75)
  TOP w0.254: v1(86.59,53.45) 86.71,53.45 86.84,53.58 88.42,53.58 88.98,53.03 v2(96.94,53.03) 97.27,53.03 v1(97.49,53.24) ; v3(82.92,3.9) 79.55,3.9 78.89,4.56 75.09,4.56 PRP2.1 74.71,4.94 PR2.2 PD4.1 ; PR728.1 76.24,68.56 v3(76.43,68.37)
  IN1 w0.254: v1(253.05,54.75) 252.98,54.68 248.59,54.68 248.45,54.54 248.45,54.52 248.34,54.41 238.76,54.41 237.11,52.76 237.11,49.52 235.39,47.8 234.1,47.8 229.5,43.2 227.3,43.2 225.41,41.32 207.33,41.32 v1(205.94,42.7) ; v3(76.43,68.37) 76.43,67.97 78.79,65.61 80.06,65.61 82.07,63.6 86.94,63.6 88.34,62.21 88.34,57.13 86.31,55.1 86.31,53.76 86.58,53.49 86.58,53.46 v1(86.59,53.45)
  IN2 w0.254: v3(82.92,3.9) 83.96,4.94 83.96,8.31 85.43,9.78 85.43,18.51 85.95,19.02 85.95,49.83 86.59,50.47 v1(86.59,53.45) ; v1(67.5,77.61) 67.61,77.61 68.15,77.08 72.95,77.08 72.96,77.06 73.02,77.06 75.76,74.33 75.76,74.27 75.77,74.26 75.77,69.46 76.43,68.8 v3(76.43,68.37)
  IN3 w0.254: v1(104.08,42.92) 104.08,39.94 105.79,38.23 105.79,33.56 107.28,32.07 184.05,32.07 184.58,31.54 195.29,31.54 198.01,34.25 198.59,34.25 205.94,41.61 v1(205.94,42.7)
  IN4 w0.254: v1(97.49,53.24) 98.64,52.09 99.23,52.09 104.66,46.65 104.66,44.63 104.08,44.05 v1(104.08,42.92)
  BOTTOM w0.254: v1(67.5,77.61) 67.5,77.69 67.96,78.15 PU804.1
PBAT_PRES#_C: length 7.6
  TOP w0.102: v1(72.08,8.45) 71.51,8.45 v2(71.18,8.12)
  TOP w0.254: PRP2.8 73.25,6.4 73.25,6.62 72.1,7.77 PD2.2 v1(72.08,8.45)
  BOTTOM w0.254: v1(72.08,8.45) 72.38,8.74 72.38,9.87 71.43,10.82
PBAT_SMBCLK: length 217.8
  TOP w0.102: UE2.A56 257.6,53.66 257.47,53.53 257.47,53.15 v1(257.98,52.64) ; PRP2.3 75.58,5.5 75.79,5.29 79.46,5.29 v1(79.67,5.49) ; RE43.2 257.09,48.8 257.47,49.18 257.47,49.72 257.45,49.74 257.45,49.94 ; v1(257.52,50) 257.45,49.94 ; 257.45,49.94 257.19,49.94 257.17,49.96 256.99,49.96 256.98,49.95 256.48,49.95 255.79,49.27 254.98,49.27 254.26,48.54 251.83,48.54 250.16,50.21 246.98,50.21 246.73,49.95 245.15,49.95 244.68,50.42 242.57,50.42 241.57,49.42 241.57,48.81 239.4,46.63 239.4,45.65 v1(239.48,45.56)
  IN3 w0.122: v1(92.77,17.5) 92.72,17.55 88.42,17.55 86.84,15.97 84.98,15.97 80.46,11.45 80.46,6.12 79.83,5.49 v1(79.67,5.49)
  IN4 w0.089: v1(257.98,52.64) 257.89,52.56 257.89,50.72 257.52,50.35 v1(257.52,50)
  BOTTOM w0.102: v1(239.48,45.56) 239.46,45.58 238.48,45.58 236.65,43.75 235.27,43.75 235.22,43.7 235.13,43.7 234.65,43.22 234.65,38.95 225.25,29.56 207.58,29.56 202.65,24.63 175.99,24.63 173.97,26.65 112.77,26.65 106.84,20.72 94.08,20.72 92.71,19.34 92.71,17.57 v1(92.77,17.5)
PBAT_SMBCLK_C: length 8.1
  TOP w0.102: v2(73.7,10.53) 73.95,10.28 v1(73.95,9.77)
  TOP w0.254: v1(73.95,9.77) 73.59,9.41 PD1.2 73.59,7.8 74.31,7.09 74.31,6.76 PRP2.6
  BOTTOM w0.254: v1(73.95,9.77) 74.46,10.28 74.46,11.96 73.9,12.52
PBAT_SMBDAT: length 220.9
  TOP w0.102: 75.21,5.15 75.38,4.98 79.6,4.98 v1(79.72,4.87) ; v1(256.85,56.15) 257.35,55.65 UE2.B59 ; v2(91.73,17.59) 92.25,17.07 v1(92.25,17.05) ; v1(239.88,45.99) 239.88,46.43 242.05,48.61 242.05,49.22 242.77,49.94 244.48,49.94 244.94,49.47 246.93,49.47 247.18,49.72 249.96,49.72 251.63,48.06 254.46,48.06 255.18,48.78 RE37.2 255.99,48.78 256.68,49.47 v1(256.98,49.47)
  IN3 w0.122: v1(92.25,17.05) 88.63,17.05 87.05,15.47 85.19,15.47 80.86,11.14 80.86,5.95 79.78,4.87 v1(79.72,4.87)
  IN4 w0.089: v1(256.98,49.47) 257.05,49.53 257.05,50.55 257.42,50.92 257.42,55.67 256.93,56.15 v1(256.85,56.15)
  BOTTOM w0.102: v1(239.88,45.99) 239.8,46.07 238.68,46.07 238.28,46.07 236.45,44.24 235.07,44.24 235.02,44.19 234.93,44.19 234.16,43.42 234.16,39.15 225.05,30.04 207.38,30.04 202.45,25.11 176.19,25.11 174.17,27.13 112.57,27.13 106.64,21.2 93.88,21.2 92.23,19.54 92.23,17.08 v1(92.25,17.05)
PBAT_SMBDAT_C: length 7.5
  TOP w0.102: v1(72.89,9.21) 72.71,9.39 v2(72.35,9.39)
  TOP w0.254: v1(72.89,9.21) PD1.3 72.89,7.75 73.66,6.97 73.66,6.7 PRP2.7
  BOTTOM w0.254: 72.66,11.67 73.47,10.87 73.47,9.79 v1(72.89,9.21)
PBATT+_C:
  vias: v3(76.8,10.09) v3(76.8,9.32) v3(76.8,8.56) v3(76.8,7.74) v3(76.81,10.84) v3(77.53,10.75) v3(77.53,9.98) v3(77.53,9.22) v3(77.6,8.4) v3(77.6,7.64) v3(78.23,10.52) v3(78.23,9.76) v3(78.23,8.99) v3(78.23,8.23) v3(78.23,7.41) v3(78.93,10.75) v3(78.93,9.98) v3(78.93,9.22) v3(78.93,8.46) v3(78.93,7.64) v4(77.89,6.8) v4(80.59,11.98) v4(80.75,9.45)
PCH_ALW_ON: length 110
  TOP w0.102: v1(244.42,58.55) 242.99,58.55 v1(242.94,58.5) ; v1(198.84,43.2) 198.3,43.2 190.66,35.55 189.53,35.55 189.26,35.27 189.26,34.34 188.76,33.85 186.24,33.85 186.05,34.04 UZ8.5 ; RPE10.4 268.78,63.07 268.05,63.81 v4(268.05,65.86) 268.05,65.98 268.59,66.53 v1(268.83,66.53) ; UE2.A34 252.39,62.76 251.85,62.76 v1(251.65,62.97)
  IN2 w0.122: v1(251.65,62.97) 252.33,62.29 252.33,61.84 252.07,61.58 250.79,61.58 250.55,61.34 250.55,58.49 249.89,57.83 248.58,57.83 248.09,58.31 246.88,58.31 246.63,58.55 v1(244.42,58.55) ; v1(198.84,43.2) 199.7,43.2 201.11,41.79 225.72,41.79 229.35,45.41 230.25,45.41 237.44,52.61 237.44,52.92 238.51,53.99 239.38,53.99 242.94,57.55 v1(242.94,58.5)
  IN3 w0.122: v1(251.65,62.97) 252.15,63.46 252.15,63.6 253.72,65.18 259.67,65.18 260.06,65.57 260.06,65.76 261.31,67.01 264.22,67.01 264.33,67.11 268.25,67.11 v1(268.83,66.53)
PCH_AZ_BITCLK: length 8.5
  BOTTOM w0.076: 166.67,42.6 166.78,42.5 RC23.2 ; UC1.AW8 164.09,48.26 163.8,47.97 163.8,47.32 163.83,47.3
  BOTTOM w0.089: 166.67,42.6 166.19,43.08 v2(166.19,43.8) 166.19,44.29 164.44,46.03 164.44,46.68 163.83,47.3
PCH_AZ_CODEC_BITCLK: length 189.1
  TOP w0.102: UA1.6 31.32,94.61 v1(31.6,94.88) 31.65,94.94 RA17.1
  IN4 w0.089: v1(31.6,94.88) 31.71,95 32.4,95 35.59,91.82 35.59,84.03 40.33,79.29 48.76,79.29 49.49,78.55 57.3,78.55 57.89,77.96 60.94,77.96 61.49,77.41 63.73,77.41 65.86,75.28 68.76,75.28 69.31,74.73 72.88,74.73 74.28,73.32 74.28,69.21 75.24,68.25 75.24,67.82 76.84,66.22 76.84,64.27 81.2,59.91 81.2,55.64 84.76,52.08 84.76,48.03 85.39,47.4 85.39,36.29 87.52,34.15 90.24,34.15 90.61,34.52 v1(90.74,34.52)
  BOTTOM w0.076: CC5.1 RC23.1 166.78,39.64 166.67,39.54
  BOTTOM w0.102: 166.67,39.54 166.23,39.09 165.49,39.09 162.93,36.53 111.29,36.53 109.99,35.23 106.39,35.23 105.3,34.14 103.29,34.14 102.2,35.23 93.78,35.23 92.49,33.95 91.31,33.95 v1(90.74,34.52)
PCH_AZ_CODEC_RST#: length 190.3
  TOP w0.102: v1(30.59,96.57) 30.55,96.61 30.05,96.61 30.05,96.61 UA1.11
  IN4 w0.089: v1(30.59,96.57) 30.59,96.56 30.59,96.21 30.95,95.85 31.71,95.85 31.89,96.03 32.4,96.03 32.78,95.65 32.78,95.32 34.78,93.32 35.78,93.32 36.07,93.04 36.07,84.22 40.45,79.83 49.05,79.83 49.86,79.02 57.49,79.02 58.08,78.43 63.56,78.43 65.87,76.11 68.88,76.11 69.75,75.25 73,75.25 73.05,75.2 73.07,75.2 74.79,73.48 74.79,69.36 75.71,68.44 75.71,68.01 81.79,61.93 81.79,55.75 85.23,52.31 85.23,48.41 85.98,47.66 85.98,36.5 87.83,34.65 v1(90.07,34.65)
  BOTTOM w0.076: RC22.1 167.18,38.72 165.84,38.72 165.46,38.35
  BOTTOM w0.102: v1(90.07,34.65) 90.07,34.17 91.21,33.02 92.5,33.02 94.22,34.75 101.82,34.75 102.91,33.66 105.5,33.66 106.59,34.75 110.2,34.75 111.49,36.05 163.16,36.05 165.46,38.35
PCH_AZ_CODEC_SDIN0: length 198.5
  TOP w0.102: v1(35.69,95.65) 36.02,95.98 v2(36.02,96.24) 36.02,96.47 35.64,96.85 35.29,96.85 34.54,97.6 RA9.1
  IN1 w0.089: v1(35.69,95.65) 35.5,95.65 34.4,94.55 34.4,90.16 33.96,89.72 33.96,86.1 40.43,79.63 55.27,79.63 57.26,77.64 59.93,77.64 61.72,75.84 63.53,75.84 64.25,75.12 72.25,75.12 74.21,73.16 74.21,66.91 80.07,61.05 80.07,58.79 83.96,54.9 83.96,52.12 84.47,51.62 84.47,33.7 v1(84.62,33.54)
  IN4 w0.089: v1(84.62,33.54) 84.95,33.21 90.65,33.21 91.62,34.18 v1(91.62,34.48)
  BOTTOM w0.076: 150.7,38.35 151.65,39.3 158.43,39.3 ; UC1.AY10 163.36,47.5 163.68,47.18
  BOTTOM w0.102: 150.7,38.35 149.36,37.01 111.09,37.01 109.79,35.71 106.19,35.71 105.1,34.62 103.54,34.62 102.45,35.71 93.5,35.71 92.27,34.48 v1(91.62,34.48) ; 158.43,39.3 159.49,38.24 163.91,38.24 165.13,39.46 165.93,39.46 166.26,39.79 166.26,42.13 165.82,42.56 165.82,44.39 164.26,45.95 164.26,46.6 163.68,47.18
PCH_AZ_CODEC_SDOUT: length 185.2
  TOP w0.102: v1(31.08,94.12) 30.99,94.21 UA1.5
  IN4 w0.089: v1(91.54,35.17) 91.48,35.17 91.21,34.9 91.21,34.33 90.56,33.67 87.34,33.67 84.19,36.82 84.19,51.96 80.63,55.51 80.63,59.78 76.05,64.37 76.05,66.34 74.77,67.62 74.77,68.05 73.74,69.09 73.74,73.21 72.68,74.26 69.12,74.26 68.57,74.81 65.6,74.81 63.54,76.88 61.24,76.88 60.62,77.49 57.69,77.49 57.1,78.08 49.19,78.08 48.53,78.74 40.21,78.74 35.1,83.85 35.1,91.63 33.4,93.33 31.86,93.33 v1(31.08,94.12)
  BOTTOM w0.076: RC19.1 165.63,40.25 163.86,38.47 159.74,38.47 158.55,39.66 151.52,39.66 150.21,38.35
  BOTTOM w0.102: v1(91.54,35.17) 92.02,35.65 92.7,35.65 93.18,36.13 98.67,36.13 99.23,36.69 102.81,36.69 103.8,37.68 117.38,37.68 117.74,37.32 149.17,37.32 150.21,38.35
PCH_AZ_CODEC_SYNC: length 182.7
  TOP w0.102: UA1.10 30.11,96.21 30.2,96.13 30.98,96.13 v1(31.12,96.27)
  IN4 w0.089: v1(31.12,96.27) 31.23,96.38 32.54,96.38 33.12,95.8 33.12,95.42 34.93,93.61 35.9,93.61 36.53,92.99 36.53,84.64 40.61,80.55 59.55,80.55 60,80.1 63.61,80.1 67.31,76.41 68.76,76.41 69.01,76.41 69.25,76.16 69.34,76.16 69.96,75.54 72.88,75.54 73.12,75.54 73.17,75.49 73.19,75.49 75.08,73.6 75.08,73.34 75.08,69.48 76,68.56 76,68.13 82.08,62.05 82.08,55.89 85.53,52.45 85.53,48.92 86.3,48.15 86.3,37.01 87.75,35.55 90.35,35.55 v1(90.73,35.17)
  BOTTOM w0.076: RC20.1 163.32,39.99 163.32,39.36 163.06,39.09 161.68,39.09 160.9,39.88 151.17,39.88 150.15,38.87
  BOTTOM w0.102: 150.15,38.87 148.91,37.62 117.87,37.62 117.5,37.99 103.67,37.99 102.72,37.04 93.51,37.04 92.48,36.01 91.57,36.01 v1(90.73,35.17)
PCH_AZ_RST#: length 10.8
  BOTTOM w0.076: RC22.2 168.71,42.14 v2(168,42.85) ; UC1.AU8 164.45,49.25 164.45,48.8 164.4,48.75 164.4,47.22 164.39,47.21
  BOTTOM w0.089: 164.39,47.21 164.39,47.05 164.62,46.82 164.62,46.1 166.59,44.14 166.59,43.49 166.98,43.09 167.76,43.09 v2(168,42.85)
PCH_AZ_SDIN0_R: length 4.9
  TOP w0.102: UA1.8 30.11,95.41 30.26,95.26 30.74,95.26 31.58,96.1 31.58,96.33 32.19,96.94 v2(32.3,96.94) 32.91,96.94 33.36,97.39 RA9.2
PCH_AZ_SDOUT: length 10.6
  BOTTOM w0.076: RC11.2 RC19.2 165.77,41.19 165.77,42.04 v2(165.71,42.1) ; UC1.AU11 162.96,49.25 162.96,48.77 163.08,48.65 163.08,47.47
  BOTTOM w0.089: 163.08,47.47 164.07,46.48 164.07,45.88 165.6,44.36 165.6,42.22 v2(165.71,42.1)
PCH_AZ_SYNC: length 10.1
  BOTTOM w0.076: UC1.AV11 162.65,48.76 162.9,48.5 162.9,47.4 163.9,46.41 163.9,45.81 165.37,44.34 165.37,43.47 165.03,43.14 164.46,43.14 v2(163.86,42.53) 163.06,41.73 RC20.2
PCH_BATLOW#: length 23.1
  TOP w0.102: v2(186.6,50.36) 186.98,49.98 v1(186.98,49.86)
  IN4 w0.086: 171.77,51.22 168.33,51.22 v1(167.39,52.15)
  IN4 w0.089: v1(186.98,49.86) 186.45,50.4 182.49,50.4 181.28,51.6 176.66,51.6 176.26,52 174.54,52 174.14,51.6 172.15,51.6 171.77,51.22
  BOTTOM w0.076: UC1.AN4 167.03,51.79 v1(167.39,52.15)
  BOTTOM w0.102: RPC19.1 v1(186.98,49.86)
PCH_CL_CLK1: length 137.6
  IN1 w0.086: 172.84,56.27 172.42,55.84 171.89,55.84 v1(171.44,56.29)
  IN1 w0.089: v1(280.28,49.56) 280.28,49.48 279.25,48.45 277.78,48.45 277.69,48.54 277.53,48.71 272.57,48.71 272.45,48.82 268.43,48.82 266.76,50.5 257.24,50.5 255.5,48.76 255.04,48.76 254.69,48.4 252.04,48.4 251.78,48.66 251.78,49.3 251.65,49.42 251.39,49.42 251.3,49.34 251.3,48.73 251,48.43 250.57,48.43 250.27,48.73 250.27,49.34 250.18,49.42 249.28,49.42 249.06,49.65 244.44,49.65 244.15,49.94 242.75,49.94 240.86,48.05 239.48,48.05 237.42,45.99 235.39,45.99 233.23,43.83 232.72,43.83 230.33,41.44 228.02,41.44 226.23,39.65 211.4,39.65 210.71,38.95 204.23,38.95 200.94,42.24 200.82,42.24 200.46,41.89 200.1,41.89 199.74,42.25 199.74,42.62 200.09,42.97 200.09,43.1 198.69,44.5 198.69,50.35 196.46,52.58 196.46,53.88 192.8,57.53 185.05,57.53 183.65,56.14 180.29,56.14 179.32,57.11 175.81,57.11 175.55,56.85 173.42,56.85 172.84,56.27
  BOTTOM w0.076: UC1.AF2 168.61,56.55 169.89,56.55 170,56.66 171.08,56.66 v1(171.44,56.29)
  BOTTOM w0.102: v1(280.28,49.56) 280.28,49.47 280.1,49.29 JNGFF1.34
PCH_CL_DATA1: length 137
  IN1 w0.086: v1(172.07,56.28) 172.19,56.16 172.33,56.16 172.55,56.38 172.55,56.39 172.62,56.46 172.63,56.47
  IN1 w0.089: v1(279.69,49.57) 279.69,49.31 279.13,48.75 277.9,48.75 277.65,49 272.92,49 272.8,49.11 268.55,49.11 266.88,50.79 257.12,50.79 255.38,49.05 254.92,49.05 254.56,48.69 252.16,48.69 252.07,48.78 252.07,49.42 251.77,49.72 251.27,49.72 251.01,49.46 251.01,48.85 250.88,48.73 250.69,48.73 250.56,48.85 250.56,49.46 250.3,49.72 249.4,49.72 249.18,49.94 244.56,49.94 244.27,50.23 242.63,50.23 240.74,48.34 239.36,48.34 237.3,46.28 235.27,46.28 233.11,44.12 232.6,44.12 230.21,41.73 227.9,41.73 226.1,39.94 211.28,39.94 210.58,39.25 204.36,39.25 201.06,42.54 200.7,42.54 200.34,42.18 200.22,42.18 200.03,42.37 200.03,42.5 200.38,42.85 200.38,43.22 198.98,44.62 198.98,50.47 198.9,50.55 196.75,52.7 196.75,54 192.93,57.83 184.93,57.83 183.53,56.43 180.42,56.43 179.44,57.41 175.69,57.41 175.43,57.14 173.3,57.14 172.63,56.47
  BOTTOM w0.076: UC1.AD2 168.44,57.02 168.73,56.73 169.81,56.73 169.95,56.87 171.48,56.87 v1(172.07,56.28)
  BOTTOM w0.102: JNGFF1.32 279.6,49.48 v1(279.69,49.57)
PCH_CL_RST1#: length 138
  TOP w0.102: v1(174.52,60.9) 173.99,60.37 173.99,59.64 172.95,58.6 172.35,58.6 171.63,57.88 171.63,57.28 172.3,56.61 173.13,56.61 173.37,56.37 v1(173.37,56.17)
  IN1 w0.089: v1(174.52,60.9) 174.52,61.15 174.87,61.5 175.46,61.5 176.04,60.92 182.06,60.92 182.17,60.8 182.5,60.8 183.26,61.57 187.53,61.57 188.61,60.49 191.63,60.49 198.62,53.51 198.62,52.78 200.01,51.38 200.01,47.9 207.04,40.88 225.67,40.88 227.57,42.78 229.68,42.78 234.28,47.37 235.61,47.37 239.46,51.23 250.3,51.23 250.34,51.2 252.07,51.2 252.49,50.77 254.79,50.77 256.2,52.17 272.48,52.17 272.9,51.76 276.66,51.76 v1(278.73,49.68)
  BOTTOM w0.076: UC1.AF4 167.36,55.91 167.75,55.91 167.84,55.81 169.67,55.81 169.85,55.63 172.82,55.63 172.84,55.65
  BOTTOM w0.102: v1(278.73,49.68) 279.1,49.31 JNGFF1.30 ; 172.84,55.65 v1(173.37,56.17)
PCH_DPWROK: length 116.2
  TOP w0.102: UE2.A36 251.88,61.75 251.66,61.97 v1(251.66,62.08)
  IN4 w0.086: v1(168.29,45.47) 168.65,45.47 169.55,44.57 170.65,44.57
  IN4 w0.089: v1(247.13,46.43) 246.8,46.76 243.54,46.76 242.18,45.41 240.41,45.41 239.69,44.68 231.91,44.68 229,41.77 228.49,41.77 228.49,41.77 228.1,41.77 226.53,40.2 226.53,36.88 225.92,36.27 219.35,36.27 219.32,36.31 219.3,36.29 218.97,36.29 218.74,36.53 218.74,36.86 218.75,36.87 206.65,36.87 201.91,41.62 199.83,41.62 199.42,42.03 197.81,42.03 197.62,42.2 195.7,42.2 195.07,41.57 192.26,41.57 191.94,41.25 185.53,41.25 185.48,41.3 183.87,41.3 183.57,41 182.35,41 180.28,43.07 176.39,43.07 174.89,44.57 170.65,44.57 ; v1(250.49,51.65) 250.46,51.62 249.66,51.62 249.36,51.92 249.36,58.03 250.41,59.08 250.41,62.12 250.8,62.51 251.27,62.51 251.66,62.11 v1(251.66,62.08)
  BOTTOM w0.076: UC1.AV5 166.07,48.65 166.07,47.47 166.34,47.19 166.34,47.03 167.28,46.09 167.9,46.09 168.29,45.7 v1(168.29,45.47)
  BOTTOM w0.102: v1(250.49,51.65) 248.42,49.58 248.42,49.02 247.18,47.78 247.18,46.48 v1(247.13,46.43)
PCH_GPIO4: length 21.2
  IN4 w0.086: v1(170.21,67.11) 170.65,67.55
  IN4 w0.089: v1(186.33,70.08) 185.95,69.7 182.32,69.7 180.51,67.88 173.92,67.88 173.81,68 171.09,68 170.65,67.55
  BOTTOM w0.076: v1(170.21,67.11) 170.15,67.16 168.83,67.16 168.43,66.76 UC1.F2
  BOTTOM w0.102: v1(186.33,70.08) 187.27,69.15 RPC8.3
PCH_GPIO5: length 22
  IN4 w0.089: v1(170.8,67.07) 171.49,67.76 173.75,67.76 173.84,67.67 180.61,67.67 182.27,69.33 186.18,69.33 v1(186.93,70.08)
  BOTTOM w0.076: UC1.F3 168.08,67.12 168.45,67.12 168.71,67.38 169.98,67.38 170.06,67.46 170.41,67.46 170.65,67.22
  BOTTOM w0.102: RPC8.4 187.36,69.65 v1(186.93,70.08) ; 170.65,67.22 v1(170.8,67.07)
PCH_GPIO6: length 22.3
  IN4 w0.089: v1(186.42,68.15) 185.75,68.82 182.56,68.82 180.84,67.11 172.87,67.11 172.76,67.21 172.29,67.21 v1(172.12,67.05)
  BOTTOM w0.076: 170.65,66.31 170.64,66.31 170.63,66.32 170.53,66.32 170.52,66.33 169.94,66.33 169.79,66.48 168.18,66.48 168.08,66.39 167.37,66.39 UC1.G4
  BOTTOM w0.102: 170.65,66.31 171.39,66.31 v1(172.12,67.05) ; RPC8.1 v1(186.42,68.15)
PCH_GPIO7: length 20.8
  TOP w0.102: v1(186.94,68.7) 187.16,68.7 v2(187.46,69)
  IN4 w0.089: v1(171.46,67.07) 171.89,67.5 172.89,67.5 172.99,67.4 180.72,67.4 182.44,69.12 186.53,69.12 v1(186.94,68.7)
  BOTTOM w0.076: 170.65,66.61 170.05,66.61 169.91,66.76 169.02,66.76 UC1.F1
  BOTTOM w0.102: v1(171.46,67.07) 171.46,67.03 171.04,66.61 170.65,66.61 ; v1(186.94,68.7) 186.99,68.65 RPC8.2
PCH_GPIO9: length 22.1
  IN4 w0.086: 171.77,51.8 171.41,52.15 v1(168.02,52.15)
  IN4 w0.089: 171.77,51.8 171.79,51.82 174.05,51.82 174.45,52.21 176.47,52.21 176.86,51.82 181.42,51.82 181.76,51.48 185.45,51.48 v1(186.11,50.82)
  BOTTOM w0.076: UC1.AM3 167.68,52.48 v1(168.02,52.15)
  BOTTOM w0.102: RPC19.4 186.65,51.36 v1(186.11,50.82) 185.71,51.21 v2(185.71,51.37)
PCH_GPIO10: length 10.3
  TOP w0.102: v1(173.02,50.38) 176.09,53.44 T27.1
  BOTTOM w0.076: UC1.AM2 168.39,52.52 168.68,52.81 169.18,52.81 169.31,52.94 169.72,52.94 170.31,52.36 170.87,52.36 171.32,51.91 171.49,51.91 171.76,51.63
  BOTTOM w0.102: 171.76,51.63 171.77,51.63 v1(173.02,50.38)
PCH_GPIO14: length 8.5
  TOP w0.076: 172.84,54.97 172.35,54.49 169.13,54.49 168.08,55.53 167.26,55.53 166.57,54.84 v1(166.57,54.83)
  TOP w0.102: 172.84,54.97 173.27,55.4 T21.1
  BOTTOM w0.076: UC1.AH4 166.67,54.73 v1(166.57,54.83)
PCH_GPIO16: length 13.4
  BOTTOM w0.076: 171.77,59.45 171.09,60.12 170.17,60.12 169.31,59.27 UC1.Y1
  BOTTOM w0.102: 171.77,59.45 172.32,58.89 174.6,58.89 176.3,57.19 176.3,55.78 v2(176.5,55.58) 178.85,55.58 179.01,55.43 RPC5.8
PCH_GPIO19: length 51.5
  TOP w0.102: v1(188.63,70.58) v2(189.36,70.58)
  IN2 w0.086: 171.77,62.35 169.22,62.35 168.57,61.7 168.57,60.82 168.08,60.34 167,60.34 166.84,60.17 165.55,60.17 165.11,59.73 165.11,59.43 165.32,59.22 165.41,59.22 v1(165.94,58.69)
  IN2 w0.122: v1(188.63,70.58) 188.63,70.76 188.09,71.3 186.18,71.3 184.82,69.94 183.69,69.94 180.56,66.82 175.62,66.82 174.73,65.92 174.73,64.65 173.29,63.21 173.08,63.21 172.22,62.35 171.77,62.35
  IN3 w0.122: v1(188.63,70.58) 188.63,70.13 191.17,67.59 191.17,66.26 190.93,66.02 189.54,66.02 186.54,63.02 185.33,63.02 184.85,62.54 184.85,60.95 185.1,60.7 185.78,60.7 186.35,60.12 v1(186.35,59.95)
  BOTTOM w0.076: UC1.Y5 166.01,58.8 166.01,58.77 v1(165.94,58.69)
  BOTTOM w0.102: v1(186.35,59.95) 186.75,60.35 187.2,60.35 RC66.2
PCH_GPIO44: length 13.2
  BOTTOM w0.076: UC1.AK4 167.41,54.43 167.75,54.43 167.86,54.33 169.09,54.33 169.47,53.96 170.22,53.2 171.77,53.2
  BOTTOM w0.102: 171.77,53.2 v2(176.73,53.2) 177.45,53.93 RPC5.5
PCH_GPIO46: length 17
  TOP w0.076: 170.65,45.77 169.04,47.39 169.04,54.04 v1(167.92,55.15)
  TOP w0.102: 170.65,45.77 v2(172.52,43.9) 173.41,43.02 173.41,41.64 173.52,41.52 RPC1.7
  BOTTOM w0.076: UC1.AG3 167.68,55.37 167.9,55.15 v1(167.92,55.15)
PCH_GPIO49: length 3.5
  TOP w0.076: T22.1 168.76,60.39 v1(167.98,59.62)
  BOTTOM w0.076: UC1.Y3 167.68,59.32 v1(167.98,59.62)
PCH_GPIO52: length 12.5
  BOTTOM w0.076: UC1.L1 169.37,63.76 169.54,63.94 170.23,63.94 170.36,64.07 171.75,64.07 171.77,64.09
  BOTTOM w0.102: RPC16.8 177.84,61.27 177.34,61.76 v2(177.34,63.27) 176.53,64.09 171.77,64.09
PCH_GPIO53: length 20.5
  TOP w0.102: RC140.1 180.42,66.35 181.89,66.35 v1(182.38,65.85)
  IN3 w0.122: v1(173.57,64.94) 174.9,66.27 181.97,66.27 v1(182.38,65.85)
  BOTTOM w0.076: UC1.L4 167.33,63.43 168.49,63.43 168.67,63.6 168.67,63.87 168.86,64.06 169.38,64.06 169.53,64.21 170.26,64.21 170.37,64.32 171.77,64.32
  BOTTOM w0.102: v2(174.14,64.65) 173.85,64.94 v1(173.57,64.94) 172.95,64.32 171.77,64.32
PCH_GPIO57: length 24
  IN3 w0.086: v1(170.51,50.42) 170.93,50.84 171.77,50.84
  IN3 w0.122: v1(184.26,47.37) 183.77,47.87 183.77,48.81 184.27,49.31 184.27,49.72 183.89,50.1 183.89,51.17 183.39,51.68 176.92,51.68 176.09,50.84 171.77,50.84
  BOTTOM w0.076: UC1.AP1 169.14,50.87 169.74,50.87 170.2,50.42 v1(170.51,50.42)
  BOTTOM w0.102: v2(184.44,48.2) 184.26,48.02 v1(184.26,47.37) 184.76,47.37 185.32,46.81 RPC7.5
PCH_GPIO59: length 12.6
  TOP w0.076: 170.65,43.14 169.79,43.14 169.44,43.49 169.44,44.57 168.8,45.21 168.8,45.62 168.02,46.4 168.02,47.95 v1(166.54,49.43)
  TOP w0.102: RC245.1 171.98,41.4 171.98,42.14 v2(171.44,42.69) 170.98,43.14 170.65,43.14
  BOTTOM w0.076: v1(166.54,49.43) 166.54,49.72 166.08,50.17 UC1.AT5
PCH_GPIO66: length 13.4
  TOP w0.102: RC176.2 RC181.1 171.39,76.67 v2(171.39,75.12) 171.39,74.12 v1(171.89,73.61)
  BOTTOM w0.076: UC1.D3 167.62,68.2 167.31,68.51 167.31,69.1 167.45,69.24 167.87,69.24 168.08,69.46 168.08,69.9 168.5,70.32 169.88,70.32 170.65,71.1
  BOTTOM w0.102: 170.65,71.1 171.77,72.21 171.77,73.48 v1(171.89,73.61)
PCH_GPIO68: length 12.7
  BOTTOM w0.076: 170.65,69.56 168.86,69.56 168.62,69.32 168.2,69.32 167.81,68.93 UC1.C3
  BOTTOM w0.102: RC164.2 174.92,77.03 v2(174.03,76.14) 173.38,75.49 173.38,72 170.94,69.56 170.65,69.56
PCH_GPIO69: length 15
  TOP w0.076: v1(169.61,69.12) 170.65,69.12
  TOP w0.102: 170.65,69.12 v2(172.28,69.12) 173.96,69.12 176.43,66.65 176.99,66.65 177.49,66.15 178.82,66.15 179.2,65.78 179.2,64.92 RPC6.5
  BOTTOM w0.076: UC1.E2 168.33,67.68 168.63,67.97 168.63,68.52 168.83,68.72 169.21,68.72 v1(169.61,69.12)
PCH_GPIO73: length 13.3
  TOP w0.102: RPC1.5 174.52,41.72 174.52,43.27 v2(174.03,43.77) v1(170.98,46.81)
  BOTTOM w0.076: 170.65,46.71 168.96,46.71 168.5,47.17 168.31,47.17 168.05,47.44 168.05,47.74 167.99,47.8 167.99,48.46 167.81,48.63 167.54,48.63 167.37,48.8 167.37,49.03 167.01,49.39 UC1.AU4
  BOTTOM w0.102: 170.65,46.71 170.88,46.71 v1(170.98,46.81)
PCH_GPIO76: length 12.3
  BOTTOM w0.076: 171.77,62.4 171.36,62.4 171.25,62.51 169.43,62.51 169.18,62.26 UC1.P1
  BOTTOM w0.102: 171.77,62.4 171.98,62.4 173.95,60.43 v2(175.63,60.43) 176.64,59.41 178.14,59.41 178.42,59.13 178.42,58.69 178.64,58.47 RPC17.8
PCH_GPIO80: length 13.4
  BOTTOM w0.076: 171.77,63.85 170.52,63.85 170.33,63.65 169.57,63.65 169.3,63.39 168.87,63.39 168.5,63.01 UC1.N2
  BOTTOM w0.102: RPC16.7 177.89,60.77 v2(176.85,61.81) 176.85,63.25 176.25,63.85 171.77,63.85
PCH_GPIO85: length 25.5
  IN4 w0.086: v1(165.92,63.4) 166.28,63.75 167.39,63.75 167.54,63.6 168.69,63.6 169.12,64.03 171.77,64.03
  IN4 w0.089: v1(186.18,62.56) 185.71,63.03 185.45,63.03 184.67,63.81 184.67,63.98 183.24,65.41 180.63,65.41 180.29,65.07 177.34,65.07 176.68,64.42 173.97,64.42 173.58,64.03 171.77,64.03
  BOTTOM w0.076: UC1.N6 165.7,63.17 v1(165.92,63.4)
  BOTTOM w0.102: 186.18,62.46 186.61,62.04 RPC18.7 ; 186.18,62.46 v1(186.18,62.56) ; 186.18,62.46 186.18,61.89 v2(186.13,61.84)
PCH_GPIO87: length 24.1
  IN4 w0.086: v1(165.28,61.56) 165.13,61.56 164.21,60.65 164.21,59.46 164.48,59.2 166.95,59.2 167.12,59.02 171.28,59.02 171.57,58.73 171.77,58.73
  IN4 w0.089: v1(182.92,57.97) 182.39,58.5 180.66,58.5 180.38,58.78 180.38,59.26 180.17,59.46 176.5,59.46 175.77,58.73 171.77,58.73
  BOTTOM w0.076: v1(165.28,61.56) 165.05,61.79 UC1.R7
  BOTTOM w0.102: RPC9.7 v1(182.92,57.97)
PCH_INTVRMEN: length 10.6
  BOTTOM w0.076: UC1.AV7 164.82,48.75 164.57,48.49 164.57,47.17 ; 168.44,42.95 v2(169.27,42.13) 169.72,41.67 RC1.2
  BOTTOM w0.089: 168.44,42.95 168.12,43.27 167.07,43.27 166.79,43.55 166.79,44.19 164.8,46.18 164.8,46.94 164.57,47.17
PCH_JTAG_JTAGX: length 70.3
  TOP w0.102: v1(112.05,42.23) v2(112.56,41.72) 112.56,36.71 111.49,35.64 RC115.2 ; RC112.2 90.55,23.18 91.26,23.88 91.27,23.88 v1(91.43,24.04)
  IN1 w0.086: v1(126.62,57.37) 126.4,57.15
  IN1 w0.089: 126.4,57.15 126.16,56.91 122.15,56.91 121.95,56.71 121.12,56.71 120.27,55.86 118.82,55.86 v1(118.22,56.45) 117.82,56.05 117.82,55.38 117.06,54.62 117.06,52.48 113.36,48.78 113.36,43.54 v1(112.05,42.23) 111.42,41.6 111.1,41.6 107.51,38.01 107.29,38.01 105.35,36.07 105.35,35.63 104.92,35.2 103.91,35.2 102.79,34.09 100.04,34.09 98.41,32.46 97.49,32.46 97.07,32.04 97.07,31.02 95.71,29.66 95.71,26.6 93.6,24.49 91.87,24.49 v1(91.43,24.04)
  BOTTOM w0.076: 127.62,56.82 127.99,56.82 128.5,56.31 UC1.AE63
  BOTTOM w0.102: v1(126.62,57.37) 127.16,56.82 127.62,56.82 ; RC18.1 v1(118.22,56.45)
PCH_JTAG_TCK: length 66.6
  TOP w0.102: RC119.2 91.35,22.16 92.21,23.03 JXDP1.55 95.17,23.03 v1(95.25,23.1) ; v1(118.21,53.41) v4(118.83,53.41)
  IN1 w0.086: v1(126.58,55.87) 126.49,55.78 126.4,55.78
  IN1 w0.089: v1(95.25,23.1) 96.18,23.1 96.61,23.54 96.61,26.5 98.92,28.81 98.92,29.39 100.8,31.27 101.54,31.27 104.26,34 105.42,34 108.84,37.42 109.2,37.42 115.61,43.82 118.86,43.82 121.14,46.1 121.14,50.48 v1(118.21,53.41) 120.84,53.41 123.06,55.62 126.24,55.62 126.4,55.78
  BOTTOM w0.076: UC1.AE62 130.71,56.02 130.16,56.02 130.06,56.12 126.83,56.12 v1(126.58,55.87)
  BOTTOM w0.102: RC21.1 v1(118.21,53.41)
PCH_JTAG_TDI: length 64.8
  TOP w0.102: JXDP1.56 96.97,23.03 96.6,23.4 96.6,25.97 97.18,26.56 97.18,27.74 97.45,28.01 97.45,29.21 v1(96.94,29.72) ; v1(118.24,54.42) 118.24,54.46 v4(117.77,54.93) ; RC99.1 v1(111.49,40.58)
  IN1 w0.089: v1(96.94,29.72) 97.12,29.72 101.02,33.62 103.04,33.62 103.96,34.55 105.26,34.55 108.76,38.04 109.19,38.04 111.49,40.34 v1(111.49,40.58) 111.61,40.58 113.86,42.83 113.86,48.59 117.56,52.3 117.56,54 117.98,54.42 v1(118.24,54.42) 118.26,54.42 118.63,54.05 120.38,54.05 122.81,56.48 127.66,56.48 v1(128.53,57.35)
  BOTTOM w0.076: UC1.AD61 131.4,57.35 130.88,57.35 130.68,57.15 130.68,56.97 130.48,56.77 129.11,56.77 v1(128.53,57.35)
  BOTTOM w0.102: RC14.1 v1(118.24,54.42)
PCH_JTAG_TDO: length 37.2
  TOP w0.102: RC98.1 RC118.2 111.54,37.66 112.12,38.23 v1(112.12,39.12) ; v1(121.42,52.24) 120.64,53.03 v4(120.64,53.25) RC15.1
  IN1 w0.089: v1(112.12,39.12) 112.12,39.37 112.55,39.81 112.57,39.81 116.15,43.39 119.04,43.39 122.54,46.89 122.54,50.51 121.42,51.62 v1(121.42,52.24) 122.03,52.24 125.02,55.22 128.81,55.22 129.21,55.62 129.52,55.94 130.61,55.94 v1(131.36,56.68)
  BOTTOM w0.076: UC1.AE61 131.66,56.38 v1(131.36,56.68)
PCH_JTAG_TMS: length 69.9
  TOP w0.102: v1(96.24,29.02) 96.75,28.51 96.75,26.52 96.37,26.14 96.37,23.24 97.09,22.53 JXDP1.58 ; UC7.9 104.96,37.64 104.81,37.79 v4(104.81,39.56) 105.07,39.82 107.67,39.82 v1(108.81,38.67)
  IN1 w0.089: v1(96.24,29.02) 96.24,29.63 96.82,30.22 97.31,30.22 100.96,33.87 102.9,33.87 103.89,34.86 104.98,34.86 105.6,35.49 105.6,36.02 107.38,37.79 107.93,37.79 v1(108.81,38.67) 108.81,38.86 111.14,41.19 111.58,41.19 113.61,43.23 113.61,48.73 117.3,52.42 117.3,54.5 118.22,55.42 v1(118.22,55.44) 118.63,55.03 121.01,55.03 122.67,56.7 127.23,56.7 v1(127.88,57.35)
  BOTTOM w0.076: v1(127.88,57.35) 128.63,56.6 130.55,56.6 UC1.AD62
  BOTTOM w0.102: RC16.1 v1(118.22,55.44)
PCH_JTAG_TRST#: length 35.7
  TOP w0.102: v1(102.7,39.5) v4(102.7,38.27) RC109.2
  BOTTOM w0.076: UC1.AU62 130.69,49.89 129.86,49.89 129.34,49.37
  BOTTOM w0.102: 129.34,49.37 127.27,47.3 127.24,47.3 127.21,47.27 125.7,47.27 119.52,41.09 104.15,41.09 102.7,39.64 v1(102.7,39.5)
PCH_OPI_COMP: length 8.5
  BOTTOM w0.203: 161.14,46.97 161.14,47.06 160.74,47.45 160.74,47.88 UC1.AW15
  BOTTOM w0.305: RC178.1 162.04,41.48 162.93,42.37 v2(162.93,44.39) 161.37,45.96 161.37,46.74 161.14,46.97
PCH_PCIE_RCOMP: length 5.9
  BOTTOM w0.203: 153.8,70.67 153.37,70.23 UC1.A27
  BOTTOM w0.381: 153.8,70.67 154.53,71.4 154.53,73.03 154.17,73.4 v2(154.17,74.06) RC149.2
PCH_PCIE_WAKE#: length 183.6
  TOP w0.076: 170.65,45.04 170.65,45.35 168.83,47.17 168.83,52.19 168.16,52.86 167.49,52.86 166.76,53.59 v1(166.76,53.65)
  TOP w0.102: v1(251.36,57.8) 251.41,57.75 UE2.A44 ; RPC1.8 173.02,41.34 172.92,41.44 172.92,42.76 170.65,45.04 ; v1(257.05,89.3) 257.59,89.84 RE274.2
  IN1 w0.086: 170.65,48.03 169.97,48.03 168.58,49.42 168.58,52.64 168.36,52.86 167.55,52.86 166.78,53.63 166.77,53.63 v1(166.76,53.65)
  IN1 w0.089: v1(246.19,46.34) 244.51,46.34 244.06,45.89 242.54,45.89 240.55,43.9 240.55,43.64 239.21,42.3 237.2,42.3 231.1,36.2 230.41,36.2 226.15,31.94 208.39,31.94 206.25,34.08 200.62,34.08 199.91,34.79 196.74,34.79 195.22,36.31 192.73,36.31 189.09,39.94 188,39.94 187.66,40.29 187.66,41.38 185.7,43.33 176.62,43.33 173.87,46.09 173.87,47.88 173.71,48.03 170.65,48.03
  IN3 w0.122: v1(241.47,87.66) 250.82,87.66 251.7,88.53 255.91,88.53 256.67,89.3 v1(257.05,89.3)
  IN4 w0.089: v1(251.36,57.8) 251.35,57.8 250.96,58.19 250.39,58.19 249.83,57.63 249.83,52.29 249.86,52.26 v1(249.86,52.09)
  BOTTOM w0.076: v1(166.76,53.65) 166.71,53.69 166.71,54.01 UC1.AJ5
  BOTTOM w0.102: v1(241.47,87.66) 241.47,87.55 242.28,86.74 244.29,84.73 244.29,78.76 245.65,77.4 245.65,74.35 244.69,73.38 244.69,70.6 244.32,70.23 244.32,64.94 247,62.26 247,61.66 248.69,59.97 248.69,59.02 249.5,58.21 250.95,58.21 v1(251.36,57.8) ; v1(249.86,52.09) 249.89,52.06 249.89,51.77 246.54,48.42 246.54,46.69 v1(246.19,46.34)
PCH_PLTRST#: length 25.7
  TOP w0.102: v1(182.84,55.56) 183.48,56.2 RC89.2 ; RC89.2 RC88.2 RC87.2 183.98,52.8 UC5.1 UC5.2 ; RC89.2 RC219.2
  IN4 w0.086: 172.84,55.77 171.34,55.77 171.28,55.83 167.22,55.83 166.82,55.43 165.72,55.43 v1(165.34,55.81)
  IN4 w0.089: 172.84,55.77 175,55.77 175.04,55.73 175.35,55.73 176.09,56.47 179.03,56.47 179.92,55.58 182.82,55.58 v1(182.84,55.56)
  BOTTOM w0.076: v1(165.34,55.81) 165.05,55.52 UC1.AG7
