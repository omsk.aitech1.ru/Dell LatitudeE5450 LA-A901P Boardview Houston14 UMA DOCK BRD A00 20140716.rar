# Allegro board Houston14_UMA_DOCK_BRD_A00_20140716.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
VIDSOUT: length 47.6
  TOP w0.102: v1(121.3,59.44) 121.23,59.5 RC208.2
  IN2 w0.086: v1(129.77,63.41) 129.15,63.41 128.78,63.04 128.78,62.09 128.61,61.93 126.4,61.93
  IN2 w0.122: 126.4,61.93 124.07,61.93 121.58,59.44 v1(121.3,59.44)
  IN4 w0.089: v1(121.3,59.44) 120.47,60.26 120.47,66.07 119.63,66.91 110.25,66.91 110.24,66.89 108.94,66.89 108.14,67.69 104.86,67.69 103.95,66.78 103.04,66.78 101.82,68 v1(101.82,69.05)
  BOTTOM w0.076: UC1.L63 130.16,63.8 v1(129.77,63.41)
  BOTTOM w0.102: PR529.2 100.5,66.06 100.37,66.18 100.37,66.87 100.49,67 100.67,67 100.8,66.87 100.8,66.69 100.93,66.56 101.14,66.56 101.27,66.69 101.27,68.01 101.41,68.15 101.9,68.15 102.02,68.27 102.02,68.44 101.9,68.56 101.45,68.56 101.33,68.67 101.33,68.77 101.61,69.05 v1(101.82,69.05) 102.11,69.34 PU500.1
VMM2320_AUX: length 25.3
  TOP w0.102: v1(134.55,93.88) 134.76,94.08 134.81,94.08 135.11,93.78 135.11,93.51 133.84,92.24 133.84,91.03 135.25,89.62 135.82,89.62 135.84,89.6 136.4,89.6 136.42,89.62 v3(137.71,89.62) 138.83,89.62 139.77,88.68 142.81,88.68 144.82,90.69 148.55,90.69 149.26,91.4 149.55,91.4 CV110.1
  BOTTOM w0.102: UV7.26 135.14,94.25 134.98,94.08 134.76,94.08 v1(134.55,93.88) 134.36,94.07 133.87,94.07 RV70.2
VMM2320_AUX#: length 25.2
  TOP w0.102: v1(134.55,94.47) 134.73,94.29 134.89,94.29 135.32,93.87 135.32,93.42 134.05,92.15 134.05,91.11 135.34,89.83 v3(136.12,89.83) 137.4,89.83 137.42,89.85 137.99,89.85 138.01,89.83 138.92,89.83 139.85,88.89 142.72,88.89 144.73,90.9 148.46,90.9 149.18,91.61 149.55,91.61 CV111.1
  BOTTOM w0.102: UV7.27 135.21,94.65 134.87,94.31 134.7,94.31 v1(134.55,94.47) 134.36,94.28 133.61,94.28 RV69.2
VMM2320_AUX#_C: length 8.5
  TOP w0.076: UV8.H2 157.43,93.83 157.15,94.11 156.73,94.11 156.23,93.6 156.23,93.55
  TOP w0.102: 156.23,93.55 155.74,93.06 155.74,92.82 155.03,92.12 155.03,91.72 154.8,91.5 v3(154.43,91.5) 153.14,91.5 153.12,91.52 152.57,91.52 152.54,91.5 152.14,91.5 151.94,91.7 151.18,91.7 CV111.2
VMM2320_AUX_C: length 8.4
  TOP w0.076: 156.38,93.41 156.47,93.5 156.79,93.5 156.88,93.59 156.88,93.8 UV8.H1
  TOP w0.102: 156.38,93.41 155.94,92.97 155.94,92.74 155.24,92.03 155.24,91.64 154.89,91.29 154.73,91.29 154.71,91.27 154.15,91.27 154.13,91.29 v3(152.84,91.29) 152.06,91.29 151.85,91.49 150.79,91.49 150.66,91.37 150.66,91.2 CV110.2
VMM2320_HPD: length 19.9
  TOP w0.102: v1(155.88,91.9) 155.88,92.05 156.85,93.02 UV8.J1 ; v1(143.56,97.48) 143.56,96.85 v2(143.01,96.31)
  IN3 w0.122: v1(155.88,91.9) 155.88,93.34 151.38,97.84 143.93,97.84 v1(143.56,97.48)
  BOTTOM w0.102: v1(143.56,97.48) 143.52,97.44 143.52,97.4 143.25,97.12 UV7.48
VMM2320_N0: length 13.6
  TOP w0.102: CV103.1 152.09,92.88 150.05,92.88 148.76,94.17 147.71,94.17 146.76,95.11 146.76,95.69 146.78,95.71 146.78,96.27 146.76,96.29 146.76,97.51 146.23,98.05 144.64,98.05 144.46,97.87 144.46,97.68 144.25,97.46 v1(144.25,97.42)
  BOTTOM w0.102: v1(144.25,97.42) 144.11,97.28 143.99,97.28 143.65,96.94 UV7.49
VMM2320_N0_C: length 5.1
  TOP w0.102: UV8.G2 157.33,94.48 157.04,94.77 156.47,94.77 154.88,93.19 154.88,93.13 154.75,93 154.68,93 154.66,93.02 154.05,93.02 154.03,93 153.69,93 CV103.2
VMM2320_N1: length 12.1
  TOP w0.102: CV105.1 149.59,94.7 149.41,94.7 149.03,95.08 149.03,95.15 149.05,95.17 149.05,95.72 149.03,95.74 149.03,96.03 148.37,96.69 148.37,97.1 146.32,99.15 144.16,99.15 143.97,98.96 143.97,98.68 v1(143.79,98.5)
  BOTTOM w0.102: UV7.46 142.45,97 142.91,97.46 142.91,97.75 143.45,98.29 143.71,98.29 143.79,98.36 v1(143.79,98.5)
VMM2320_N1_C: length 7.5
  TOP w0.102: CV105.2 151.14,94.79 151.65,94.79 151.99,94.44 154.33,94.44 154.35,94.46 154.9,94.46 154.92,94.44 155,94.44 156.01,95.45 157.01,95.45 157.33,95.13 UV8.F2
VMM2320_N2: length 14.6
  TOP w0.102: CV107.1 152.54,96.08 151.96,96.66 v1(151.96,96.67)
  IN1 w0.089: v1(151.96,96.67) 151.96,96.64 151.55,96.24 151.43,96.24 149.66,98.01 146.95,98.01 145.8,99.16 142.79,99.16 142.02,98.39 142.02,97.82 v1(141.88,97.68)
  BOTTOM w0.102: v1(141.88,97.68) 141.65,97.44 UV7.44
VMM2320_N2_C: length 4.4
  TOP w0.102: CV107.2 153.84,95.77 154.52,95.77 154.54,95.79 155.09,95.79 155.11,95.77 155.64,95.77 155.99,96.12 157.17,96.12 UV8.E2
VMM2320_N3: length 13.5
  TOP w0.102: CV109.1 149.67,97.07 149.4,97.07 149.2,97.27 149.2,97.5 v3(147.82,98.88) 146.73,99.97 146.66,99.97 146.21,99.97 146.19,99.99 145.61,99.99 145.59,99.97 143.48,99.97 142.42,98.91 141.04,98.91 140.5,98.36 140.5,97.71 140.51,97.69 140.37,97.55 v1(140.37,97.53)
  BOTTOM w0.102: v1(140.37,97.53) 140.37,97.37 140.45,97.3 UV7.41
VMM2320_N3_C: length 7.4
  TOP w0.102: UV8.D2 157.26,96.43 156.94,96.75 155.84,96.75 155.55,97.04 155.15,97.04 155.13,97.06 154.57,97.06 154.55,97.04 154.23,97.04 154.1,97.18 v3(153.45,97.18) 152.9,97.18 152.57,97.51 151.64,97.51 151.24,97.11 151.1,97.11 CV109.2
VMM2320_P0: length 13.4
  TOP w0.102: CV102.1 152.09,92.67 149.96,92.67 148.68,93.96 147.62,93.96 146.55,95.03 v3(146.55,95.99) 146.55,97.43 146.14,97.84 144.73,97.84 144.67,97.78 144.67,97.67 144.87,97.48 v1(144.87,97.4)
  BOTTOM w0.102: UV7.50 144.05,96.94 144.12,97.02 144.49,97.02 v1(144.87,97.4)
VMM2320_P0_C: length 5
  TOP w0.102: UV8.G1 156.77,94.56 156.55,94.56 155.09,93.1 155.09,93.04 154.84,92.79 v3(154.37,92.79) 153.28,92.79 153.16,92.67 153.16,92.51 CV102.2
VMM2320_P1: length 11.9
  TOP w0.102: CV104.1 149.5,94.49 149.33,94.49 148.82,95 v3(148.82,95.44) 148.82,95.95 148.16,96.61 148.16,97.01 146.23,98.94 144.24,98.94 144.18,98.88 144.18,98.7 v1(144.39,98.49)
  BOTTOM w0.102: v1(144.39,98.49) 143.94,98.05 143.5,98.05 143.12,97.67 143.12,97.38 142.85,97.1 UV7.47
VMM2320_P1_C: length 7.4
  TOP w0.102: CV104.2 150.61,94.3 150.61,94.43 150.76,94.58 151.56,94.58 151.91,94.23 v3(154.62,94.23) 155.08,94.23 156.09,95.24 156.74,95.24 UV8.F1
VMM2320_P2: length 14.6
  TOP w0.102: v1(151.96,96.07) 151.96,95.72 CV106.1
  IN1 w0.089: v1(151.96,96.07) 151.36,96.07 149.59,97.84 146.88,97.84 145.73,98.99 142.86,98.99 142.19,98.32 142.19,97.98 v1(142.48,97.69)
  BOTTOM w0.102: UV7.45 142.05,97.03 142.48,97.46 v1(142.48,97.69)
VMM2320_P2_C: length 4.3
  TOP w0.102: CV106.2 153.26,95.33 153.26,95.42 153.4,95.56 v3(154.81,95.56) 155.73,95.56 156.08,95.91 156.72,95.91 UV8.E1
VMM2320_P3: length 13.6
  TOP w0.102: CV108.1 149.95,96.74 149.82,96.87 149.31,96.87 149,97.18 149,97.41 147.89,98.52 147.84,98.52 147.46,98.9 147.46,98.95 146.65,99.76 146.57,99.76 146.57,99.76 146.06,99.76 146.06,99.76 v3(145.88,99.76) 143.56,99.76 142.5,98.7 141.13,98.7 140.7,98.28 140.7,97.79 140.72,97.78 v1(140.96,97.54)
  BOTTOM w0.102: UV7.42 140.85,97.43 v1(140.96,97.54)
VMM2320_P3_C: length 7.3
  TOP w0.102: CV108.2 150.66,96.54 150.66,96.79 150.74,96.87 151.3,96.87 151.73,97.3 152.49,97.3 152.82,96.97 153.15,96.97 153.17,96.95 153.74,96.95 153.76,96.97 154,96.97 154.14,96.83 v3(154.85,96.83) 155.46,96.83 155.76,96.54 156.74,96.54 UV8.D1
VMM2320_VGA_DET: length 4.1
  TOP w0.102: UV8.M3 v2(158.15,88.46) 158.15,88.03 RV88.2
VMM2320_VGA_IREF: length 4
  TOP w0.076: 159.61,90.49 159.45,90.65 UV8.M5
  TOP w0.102: RV89.1 159.61,87.58 v2(159.61,89.47) 159.61,90.49
VMM2320_VGA_NC: length 3.9
  TOP w0.102: T108.1 159.94,88.83 159.94,90.71 159.77,90.88 159.77,91.56 UV8.L5
VMM_DPB_CTRLCLK: length 41.9
  TOP w0.102: RPV1.1 169,90.22 168.05,91.18 v1(167.84,91.18) 167.37,91.65 165.99,91.65 165.46,92.18 165,92.18 UV8.K13
  IN2 w0.122: v1(174.93,98.57) 174.93,99.14 175.93,100.14 192.9,100.14 v1(194.54,101.78)
  BOTTOM w0.102: v1(174.93,98.57) 174.51,98.15 173.97,98.15 172.35,96.54 v2(171.87,96.54) 169.96,96.54 169.55,96.12 169.55,92.03 168.69,91.18 v1(167.84,91.18) ; v1(194.54,101.78) 194.54,101.75 194.77,101.53 194.77,101.12 194.66,101.02 UV11.12
VMM_DPB_CTRLDAT: length 42
  TOP w0.102: UV8.L14 165.24,91.94 165.02,91.94 164.93,91.85 164.93,91.68 165.08,91.54 165.69,91.54 166.07,91.16 167.11,91.16 v1(167.69,90.58) 167.82,90.58 168.67,89.72 RPV1.2
  IN2 w0.122: v1(191.68,101.83) 191.95,101.83 192.11,101.67 192.11,100.94 191.83,100.66 175.26,100.66 174.32,99.72 v1(174.32,98.6)
  BOTTOM w0.102: v1(167.69,90.58) 167.35,90.92 167.35,92.09 167.78,92.52 167.78,93.5 168.9,94.62 168.9,96.4 v2(169.56,97.06) 172.07,97.06 173.86,98.85 174.08,98.85 v1(174.32,98.6) ; UV11.9 192.16,102.97 191.68,102.49 v1(191.68,101.83)
VMM_DPC_CTRLCLK: length 29.8
  TOP w0.102: UV8.B12 164.33,98.06 164.33,98.42 164.37,98.46 164.37,98.5 164.53,98.66 164.57,98.66 164.71,98.8 164.86,98.8 v1(165.3,99.24) 165.37,99.24 165.82,99.7 166.62,99.7 168.12,98.2 170.3,98.2 171.66,99.56 173.19,99.56 175.5,101.87 v1(176.82,101.87)
  IN2 w0.122: v1(165.3,99.24) 165.23,99.24 165.11,99.35 164.35,99.35 161.98,101.72 160.27,101.72 159.34,100.8 158.04,100.8 157.64,101.2 157.64,101.57 v1(157.51,101.7)
  BOTTOM w0.102: v1(157.51,101.7) 157.26,101.95 RPV2.2 ; UV12.12 177.94,101.02 177.09,101.87 v1(176.82,101.87)
VMM_DPC_CTRLDAT: length 29.4
  TOP w0.102: UV8.A12 164,98.52 164.06,98.59 164.06,98.63 164.41,98.97 164.45,98.97 164.66,99.18 164.66,99.25 v1(165.32,99.91) 165.43,100.03 166.73,100.03 168.25,98.5 170.18,98.5 171.54,99.86 v3(172.33,99.86) 173.06,99.86 175.37,102.17 176.42,102.17 v1(176.85,102.61)
  IN2 w0.122: v1(165.32,99.91) 165.08,99.68 164.48,99.68 162.12,102.05 160.13,102.05 159.21,101.12 158.18,101.12 157.96,101.34 157.96,101.58 v1(158.15,101.77)
  BOTTOM w0.102: v1(158.15,101.77) 158.14,101.77 157.76,102.15 RPV2.1 ; UV12.9 177.93,102.97 177.32,102.35 177.1,102.35 v1(176.85,102.61)
VMM_GPIO4: length 5.4
  TOP w0.076: UV8.B14 165.38,97.73 165.54,97.89 166.15,97.89
  TOP w0.102: 166.15,97.89 167.11,97.89 167.84,97.16 RV518.2 168.5,97.08 v2(169.71,95.87)
VMM_GPIO5: length 6.4
  TOP w0.076: v1(164.97,97.41) 164.65,97.73 UV8.B13
  BOTTOM w0.102: v1(164.97,97.41) 164,98.38 162.7,98.38 161.53,99.55 161.53,99.98 v2(161.38,100.13) RV519.2
VMM_GPIO6: length 4
  TOP w0.102: RV83.1 153.78,98.36 154.47,97.68 155.51,97.68 156.11,97.08 UV8.C1
VMM_GPIO7: length 7
  TOP w0.076: UV8.M12 164.24,91 164.24,90.49
  TOP w0.102: RPV1.4 168.58,88.72 167.86,89.45 164.73,89.45 v2(164.5,89.68) 164.24,89.94 164.24,90.49
VMM_GPIO8: length 6.2
  TOP w0.102: UV8.M13 164.65,90.24 165.1,89.79 v2(166.24,89.79) 168.08,89.79 168.65,89.22 RPV1.3
VMM_GPIO9: length 4.6
  TOP w0.076: 157.8,90.49 157.8,91.51 158.15,91.86 UV8.L3
  TOP w0.102: RV73.1 157.8,87.42 v2(157.8,89.73) 157.8,90.49
VMM_SPI_CLK: length 8.9
  TOP w0.076: v1(157.77,98.77) 157.77,99.13
  TOP w0.102: 157.77,99.13 157.77,99.63 v2(158.48,100.35) ; UV8.B3 158.15,97.76 157.82,98.08 157.82,98.72 v1(157.77,98.77)
  BOTTOM w0.102: v1(157.77,98.77) 157,98.77 154.47,96.24 UV9.6
VMM_SPI_CS#: length 15.8
  TOP w0.102: v1(159.27,101.81) 159.27,100.45 158.64,99.81 158.64,99.2 158.8,99.04 UV8.A4
  BOTTOM w0.102: RV86.2 159.04,102.5 159.27,102.28 v1(159.27,101.81) 159.27,101.73 158.63,101.09 157.52,101.09 v2(157.14,100.7) 156.95,100.52 156.95,99.41 156.26,98.72 156.26,98.72 155.75,98.21 152.68,98.21 151.93,98.96 UV9.1
VMM_SPI_DIN: length 9.8
  TOP w0.102: UV8.B4 v1(158.48,98.06)
  IN4 w0.089: v1(158.48,98.06) 157.74,98.06 156.21,99.58 154.29,99.58 152.96,100.92 v1(152.62,100.92)
  BOTTOM w0.102: v2(152.12,101.54) 152.12,101.41 v1(152.62,100.92) 153.05,100.92 153.2,100.76 UV9.2
VMM_SPI_DO: length 5.9
  TOP w0.102: v1(158.38,98.78) 158.15,98.55 UV8.A3
  BOTTOM w0.102: UV9.5 155.74,96.71 157.14,98.11 v2(157.39,98.11) 157.71,98.11 v1(158.38,98.78)
VMM_SPI_HOLD: length 4.3
  BOTTOM w0.102: UV9.7 153.2,93.84 153.62,93.42 154.14,93.42 154.93,92.64 RV87.2 154.85,92.45 v2(154.85,91.51)
VMM_SPI_WP#: length 6.2
  TOP w0.102: UV8.B1 156.32,97.73 155.89,98.16 155.44,98.16 154.97,98.63 v1(154.67,98.63) 154.67,99.01 v2(154.34,99.35) RV517.2
  BOTTOM w0.102: v1(154.67,98.63) 154.58,98.63 154.47,98.75 UV9.3
VR_HOT#: length 2.8
  BOTTOM w0.102: PU500.30 104.01,68.2 104.13,68.08 104.13,66.26 PR534.2
VREF: length 72.2
  TOP w0.102: v3(106.21,67.17) v2(106.21,66.36)
  IN2 w0.254: v3(106.21,67.17) 106.02,67.36 104.19,67.36 103.75,66.92 101.88,66.92 100.98,67.83 v3(100.98,74.41)
  IN4 w0.254: v3(132.61,89.99) 132.38,89.99 132.05,89.66 132.05,87.66 132.32,87.39 132.32,83.89 132.93,83.28 132.93,77.13 131.18,75.38 109.51,75.38 v3(108.24,76.65) 107.72,76.13 107.62,76.13 106.01,74.51 101.08,74.51 v3(100.98,74.41)
  BOTTOM w0.203: PU500.27 105.21,67.87 105.55,67.53
  BOTTOM w0.254: 105.55,67.53 105.91,67.17 v3(106.21,67.17) 106.46,67.17 107.59,66.04 PC507.2 108.36,66.04 PR521.2 ; PR500.2 v3(108.24,76.65) ; v3(132.61,89.99) 132.35,89.99 131.95,90.39 131.91,90.39 PH500.1 ; v3(100.98,74.41) 100.98,75.3 PR504.2 PR503.2 PR502.2
VSET_5085: length 6.7
  TOP w0.102: v2(266.74,67.38) 265.77,67.38 RE77.1 CE38.1 264.71,66.79 263.22,65.31 261.67,65.31 261.6,65.24 UE2.A17
VSYNC_2320: length 21.5
  TOP w0.102: v1(178.45,91.52) 178.49,91.56 UV16.7 ; UV8.L9 162.34,91.59 162.34,91.15 163.58,89.92 v1(163.58,89.91)
  BOTTOM w0.102: v1(178.45,91.52) 177.81,92.15 177.09,92.15 176.83,91.9 176.83,90.85 174.63,88.65 169.39,88.65 169.32,88.57 164.69,88.57 163.58,89.69 v1(163.58,89.91)
VSYNC_CONN: length 5.9
  TOP w0.102: 266.23,113.76 266.28,113.71 CV58.1 266.28,111.32 RV37.2 266.71,111.27 266.74,111.23 LV20.2 ; 266.23,113.76 v2(266.23,113.76) ; 266.23,113.76 JCRT1.14
VSYNC_CRT: length 103.2
  TOP w0.102: UV16.18 179.69,96 179.92,96.23 180.14,96.23 180.29,96.38 180.89,96.38 181.76,95.51 v1(182.09,95.51) ; v1(266.28,97.63) 266.28,108.41 267.25,109.37 LV20.1
  IN1 w0.089: v1(266.28,97.63) 265.91,97.25 265.13,97.25 264.92,97.46 258.32,97.46 257.39,96.54 250.63,96.54 250.18,96.99 244.49,96.99 243.77,96.27 240.61,96.27 239.97,96.92 230.72,96.92 229.83,96.03 198.65,96.03 197.52,94.9 187.22,94.9 187.09,94.76 182.84,94.76 v1(182.09,95.51)
VSYNC_DOCK: length 27
  TOP w0.102: v1(180.62,95.44) 180.62,95.89 180.51,96 180.23,96 180.09,95.87 UV16.17
  IN4 w0.089: v1(163.58,108.92) 163.69,108.8 167.08,108.8 167.42,108.46 168.15,108.46 171.81,104.8 174.17,104.8 175.97,103 175.97,102.07 178.27,99.77 178.27,99.35 180.43,97.2 180.43,95.63 v1(180.62,95.44)
  BOTTOM w0.102: JDOCK1.67 163.4,109.09 v1(163.58,108.92)
WIGIG_32KHZ: length 3.9
  TOP w0.102: RZ56.2 RZ57.2 281.69,47.61 v1(282.35,46.95)
  BOTTOM w0.102: v1(282.35,46.95) 282.1,47.2 JNGFF1.42
WIGIG_32KHZ_R: length 3.7
  TOP w0.102: UZ11.4 283.36,49.48 283.16,49.28 283.16,48.61 RZ57.1 282.78,48.05 283.72,47.11 v2(283.72,46.95)
WIGIG_AUX: length 209.7
  TOP w0.102: RV72.2 135.23,94.99 134.91,95.3 134.78,95.3 v1(134.56,95.08)
  IN1 w0.089: v1(269.3,107.4) 268.26,107.4 268.22,107.45 262.58,107.45 261.12,108.91 247.09,108.91 246.75,108.56 243.12,108.56 242.81,108.26 239.56,108.26 238.2,106.9 226.33,106.9 225.95,106.52 223.94,106.52 222.53,105.11 221.4,105.11 220.38,104.08 204.48,104.08 201.6,106.96 198.16,106.96 197.48,106.28 192.19,106.28 191.67,105.76 182.19,105.76 181.55,105.12 180.63,105.12 180.35,105.4 157.14,105.4 156.69,105.85 145.89,105.85 145.39,105.35 142.14,105.35 140.69,103.9 140.69,103.61 140.55,103.47 v1(140.55,103.46)
  BOTTOM w0.102: UV7.28 135.28,95.05 135.19,95.14 134.61,95.14 v1(134.56,95.08) 134.37,95.27 134.09,95.27 133.79,95.57 133.79,96.44 134.28,96.93 134.28,97.21 134.51,97.43 134.51,99.23 138.27,102.98 140.58,102.98 140.74,103.14 140.74,103.26 v1(140.55,103.46) ; v1(269.3,107.4) 269.38,107.33 269.77,107.33 270,107.1 270,105.63 269.46,105.08 269.46,84.69 270.16,83.98 270.16,83.73 270.61,83.28 270.61,77.85 271.75,76.71 271.75,71.11 273.19,69.67 273.19,65.89 273.67,65.41 273.67,61.04 273.58,60.95 273.58,54.42 274.2,53.8 275.33,53.8 276.1,53.03 276.1,52.63 CV149.1
WIGIG_AUX#: length 209.6
  TOP w0.102: RV71.2 134.89,95.51 134.72,95.51 v1(134.56,95.67)
  IN1 w0.089: v1(269.3,106.82) 268.89,107.23 268.19,107.23 268.14,107.28 262.51,107.28 261.05,108.73 247.16,108.73 246.82,108.39 243.19,108.39 242.88,108.09 239.63,108.09 238.27,106.73 226.4,106.73 226.02,106.35 224.02,106.35 222.61,104.94 221.47,104.94 220.45,103.91 204.41,103.91 201.53,106.79 198.23,106.79 197.55,106.11 192.26,106.11 191.74,105.59 182.26,105.59 181.62,104.95 180.56,104.95 180.28,105.23 157.07,105.23 156.62,105.68 145.96,105.68 145.46,105.18 142.21,105.18 140.86,103.83 140.86,103.73 141.13,103.46 v1(141.13,103.46)
  BOTTOM w0.102: CV150.1 275.62,52.1 275.77,52.1 275.89,52.22 275.89,52.95 275.24,53.6 274.12,53.6 273.38,54.34 273.38,61.04 273.46,61.13 273.46,65.32 272.99,65.8 272.99,69.58 271.55,71.02 271.55,76.62 270.4,77.76 270.4,83.19 269.96,83.64 269.96,83.89 269.25,84.6 269.25,105.17 269.79,105.71 269.79,107.02 269.69,107.12 269.6,107.12 269.3,106.83 v1(269.3,106.82) ; v1(141.13,103.46) 140.95,103.28 140.95,103.06 140.67,102.77 138.35,102.77 134.72,99.14 134.72,97.35 134.49,97.12 134.49,96.84 134,96.35 134,95.66 134.18,95.48 134.37,95.48 v1(134.56,95.67) 134.78,95.45 UV7.29
WIGIG_AUX#_C: length 3.7
  BOTTOM w0.102: JNGFF1.12 274.6,49.36 274.75,49.5 274.75,49.73 275.11,50.1 275.11,50.12 275.83,50.84 275.83,51.01 275.41,51.42 CV150.2
WIGIG_AUX_C: length 3.6
  BOTTOM w0.102: CV149.2 276.03,51.07 276.03,50.76 275.64,50.36 275.64,50.33 v3(275.48,50.17) 274.95,49.65 274.95,49.5 275.1,49.36 JNGFF1.14
WIGIG_HPD: length 217.8
  TOP w0.102: v1(277.38,97.41) 277.93,97.96 v2(277.93,98.35)
  IN2 w0.122: v1(276.85,43.17) 276.85,45.75 276.18,46.42 276.18,56.57 278.35,58.74 278.35,63.13 279.96,64.75 279.96,68.68 275.82,72.81 275.82,86.34 277.26,87.78 277.26,88.31 278.17,89.22 278.7,89.22 279.26,89.78 279.26,95.54 v1(277.38,97.41)
  IN3 w0.122: v1(277.38,97.41) 276.73,98.07 265.41,98.07 264.75,97.41 258.43,97.41 257.09,96.07 254.14,96.07 253.47,95.39 248.65,95.39 247.98,96.07 244.63,96.07 241.45,92.89 241.45,92.65 240.12,91.31 225.05,91.31 223.93,92.43 207.35,92.43 195.34,104.45 191.3,104.45 189.93,103.07 187.65,103.07 187.24,102.66 183.01,102.66 182.15,103.51 164.19,103.51 164,103.32 161.44,103.32 160.97,102.85 154.86,102.85 154.45,103.26 142.28,103.26 139.25,100.22 v1(139.25,97.59)
  BOTTOM w0.102: JNGFF1.23 277.35,42.49 276.85,42.99 v1(276.85,43.17) ; UV7.38 v1(139.25,97.59)
WIGIG_LANE_N0: length 213.1
  IN1 w0.089: v1(270.53,107.89) 270.78,107.65 270.78,107.53 270.69,107.44 270.23,107.44 269.54,108.13 263.1,108.13 260.81,110.42 252.08,110.42 251.89,110.23 251.89,110.04 251.77,109.91 251.58,109.91 251.45,110.04 251.45,110.23 251.26,110.42 244.01,110.42 242.57,108.98 239.38,108.98 237.95,107.55 225.87,107.55 225.49,107.17 223.65,107.17 222.29,105.81 221.02,105.81 220.09,104.89 204.65,104.89 201.78,107.76 197.45,107.76 197.26,107.57 197.26,107.06 197.17,106.97 196.9,106.97 196.81,107.06 196.81,107.57 196.63,107.76 196.22,107.76 196.03,107.57 196.03,107.06 195.94,106.97 195.67,106.97 195.58,107.06 195.58,107.57 195.4,107.76 194.99,107.76 194.8,107.57 194.8,107.06 194.71,106.97 194.44,106.97 194.36,107.06 194.36,107.6 194.13,107.83 193.67,107.83 193.44,107.6 193.44,107.15 193.34,107.04 192.04,107.04 191.44,106.44 178.92,106.44 178.53,106.05 157.42,106.05 156.97,106.5 154.27,106.5 154.18,106.59 154.18,106.81 153.99,107 153.58,107 153.39,106.81 153.39,106.59 153.31,106.5 153.04,106.5 152.95,106.59 152.95,106.81 152.76,107 152.35,107 152.17,106.81 152.17,106.59 152.08,106.5 151.73,106.5 151.64,106.59 151.64,106.86 151.45,107.05 151.04,107.05 150.85,106.86 150.85,106.59 150.76,106.5 145.5,106.5 145.03,106.03 141.76,106.03 139.75,104.01 139.75,101.86 140.19,101.42 140.19,99.22 v1(139.93,98.96)
  BOTTOM w0.102: UV7.39 139.65,97.2 139.75,97.3 139.75,98.06 140.1,98.41 140.1,98.79 v1(139.93,98.96) ; CV156.1 279.84,52.75 279.84,52.87 279.75,52.96 278.84,52.96 278.42,53.39 278.42,54.12 278.14,54.4 278.14,56.15 277.79,56.49 277.79,67.43 273.2,72.03 273.2,72.51 273.2,72.51 273.2,72.68 273.2,72.68 273.2,77.36 273.19,77.37 273.19,77.38 272.84,77.73 272.84,81.42 272.13,82.14 272.13,83.86 271.96,84.03 271.96,105.42 270.72,106.66 270.72,107.7 v1(270.53,107.89)
WIGIG_LANE_N0_C: length 4.6
  BOTTOM w0.102: CV156.2 279.82,51.04 279.82,50.8 279.56,50.54 279.48,50.54 279.46,50.56 278.86,50.56 278.84,50.54 278.6,50.54 277.75,49.68 277.75,49.5 277.6,49.36 JNGFF1.24
WIGIG_LANE_N1: length 213.6
  IN1 w0.089: v1(270.75,104.21) 271.09,103.87 271.09,103.74 271.01,103.67 269.98,103.67 269.89,103.76 269.89,105.19 269.67,105.42 269.33,105.42 269.11,105.19 269.11,103.76 269.02,103.67 268.75,103.67 268.66,103.76 268.66,104.44 268.47,104.63 268.07,104.63 267.88,104.44 267.88,103.8 267.75,103.67 266.38,103.67 266.2,103.85 266.2,104.16 266.33,104.28 267.19,104.28 267.42,104.51 267.42,104.94 267.19,105.17 266.33,105.17 266.2,105.3 266.2,105.73 266.33,105.86 268.15,105.86 268.38,106.08 268.38,106.54 268.15,106.76 262.08,106.76 260.58,108.26 247.4,108.26 247.06,107.92 243.39,107.92 243.02,107.55 240.39,107.55 239.87,107.55 238.54,106.23 237.33,106.23 236.77,105.67 232.21,105.67 232,105.87 225.35,105.87 222.92,103.44 204.15,103.44 202.51,105.08 182.52,105.08 181.9,104.46 180.22,104.46 179.95,104.74 160.16,104.74 159.49,104.07 156.93,104.07 156.78,104.22 154.92,104.22 153.94,105.2 146.93,105.2 146.3,104.57 143.4,104.57 142.11,103.27 142.11,102.13 141.42,101.45 141.42,100.62 v1(141.2,100.4)
  BOTTOM w0.102: UV7.36 138.45,97.2 138.54,97.29 138.54,98.57 139.99,100.02 141.13,100.02 141.2,100.08 v1(141.2,100.4) ; CV152.1 277.79,52.72 277.79,52.83 277.57,53.06 277.57,53.79 276.79,54.57 276.21,54.57 275.94,54.84 275.94,57.31 276.03,57.4 276.03,63.82 276.78,64.57 276.78,67.29 272.37,71.7 272.37,75.98 272.37,75.98 272.37,77.05 271.23,78.19 271.23,83.6 271.06,83.77 271.06,86.75 271.06,86.75 271.06,86.83 271.06,86.83 271.06,102.84 271.1,102.89 271.1,103.85 v1(270.75,104.21)
WIGIG_LANE_N1_C: length 4.2
  BOTTOM w0.102: JNGFF1.18 276.1,49.36 276.25,49.5 276.25,49.76 276.83,50.34 277.2,50.34 277.2,50.34 277.2,50.37 277.62,50.79 277.65,50.79 277.84,50.99 277.84,51.06 277.48,51.42 CV152.2
WIGIG_LANE_N2: length 205.1
  IN1 w0.089: v1(265.49,104.62) 265.29,104.83 264.99,104.83 264.82,105 264.82,105.81 264.69,105.94 264.39,105.94 264.3,105.85 264.3,105.1 264.07,104.87 263.74,104.87 263.51,105.1 263.51,105.85 263.42,105.94 263.16,105.94 263.07,105.85 263.07,105.05 262.84,104.82 262.51,104.82 262.28,105.05 262.28,105.85 262.2,105.94 261.61,105.94 260.1,107.45 247.77,107.45 247.41,107.09 243.74,107.09 243.35,106.7 240.27,106.7 238.98,105.41 237.68,105.41 237.1,104.84 225.47,104.84 223.27,102.63 203.76,102.63 202.18,104.21 183.12,104.21 182.55,103.65 179.8,103.65 179.54,103.91 161.88,103.91 161.06,103.08 156.49,103.08 156.18,103.4 154.53,103.4 153.54,104.38 147.56,104.38 146.84,103.67 143.68,103.67 143.07,103.05 143.07,101.37 143.59,100.85 143.59,100.61 v1(143.8,100.4)
  BOTTOM w0.102: UV7.34 137.69,96.58 137.69,98.88 140.08,101.28 143.15,101.28 143.63,100.8 143.63,100.57 v1(143.8,100.4) ; v1(265.49,104.62) 265.68,104.81 266.16,104.81 266.45,104.52 266.45,103.38 264.91,101.85 264.91,85.64 265.49,85.06 265.49,79.94 266.05,79.37 266.82,79.37 267.13,79.06 267.43,79.06 267.8,78.69 267.8,75.25 268.39,74.66 269.65,74.66 270.27,74.04 270.27,72.12 270.47,71.92 270.47,70.75 270.47,70.57 271.08,69.96 271.45,69.96 271.92,69.49 271.92,65.7 272.64,64.98 272.64,63.01 272.1,62.47 272.1,60.77 272.37,60.5 272.37,53.74 273.22,52.89 273.66,52.89 273.74,52.82 273.74,52.72 CV147.1
WIGIG_LANE_N2_C: length 12.5
  BOTTOM w0.102: CV147.2 273.74,51.02 273.74,50.93 273.39,50.59 273.36,50.59 272.97,50.2 272.97,50.17 272.74,49.94 272.74,47.74 276,44.49 276,41.95 275.85,41.81 JNGFF1.17
WIGIG_LANE_N3: length 205.3
  IN1 w0.089: v1(144.18,102.81) 144.07,102.69 144.07,102.38 144.26,102.19 146.2,102.19 147.04,103.02 147.05,103.02 147.9,103.88 153.16,103.88 154.13,102.91 155.94,102.91 156.25,102.61 160.24,102.61 160.5,102.34 165.39,102.34 165.48,102.43 165.48,102.61 165.7,102.84 166.04,102.84 166.26,102.61 166.26,102.44 166.39,102.31 166.65,102.31 166.77,102.44 166.77,103.23 166.96,103.42 167.37,103.42 167.56,103.23 167.56,102.76 167.65,102.67 167.91,102.67 168,102.76 168,103.23 168.19,103.42 179.34,103.42 179.57,103.18 202.24,103.18 203.28,102.15 223.6,102.15 225.06,103.61 236.6,103.61 237.91,104.92 241.57,104.92 241.69,105.04 249.49,105.04 251.31,106.85 255.37,106.85 256.46,105.76 258.24,105.76 259.34,106.86 259.66,106.86 259.89,106.63 259.89,106.3 259.45,105.86 259.45,105.68 259.67,105.46 259.85,105.46 260.14,105.75 260.48,106.09 260.8,106.09 261.03,105.86 261.03,105.53 259.95,104.46 259.95,104.28 260.09,104.14 260.27,104.14 261.26,105.14 261.53,105.14 261.82,104.85 261.82,104.58 261.6,104.37 261.6,104.19 261.74,104.05 261.92,104.05 262.14,104.27 262.4,104.27 263,103.67 263.92,103.67 264.04,103.79 264.04,103.93 v1(263.87,104.1)
  BOTTOM w0.102: CV145.1 271.79,52.78 271.79,53.14 271.53,53.4 271.53,60.09 271.28,60.34 271.28,62.83 271.8,63.35 271.8,64.6 271.09,65.31 271.09,68.8 269.41,70.48 269.41,72.46 268.67,73.2 268.13,73.2 266.91,74.43 266.91,76.66 264.78,78.79 264.78,79.38 264.64,79.52 264.64,84.71 264.05,85.3 264.05,103.92 v1(263.87,104.1) ; v1(144.18,102.81) 144.01,102.99 144.01,103.51 143.76,103.75 142.84,103.75 141.25,102.16 138.73,102.16 136.12,99.55 136.12,97.96 136.54,97.53 136.54,97.29 136.45,97.2 UV7.31
WIGIG_LANE_N3_C: length 12.4
  BOTTOM w0.102: JNGFF1.11 274.35,41.81 274.5,41.95 274.5,42.13 274.38,42.25 274.38,43.6 274.06,43.92 274.06,44.24 274.13,44.31 274.13,44.49 273.95,44.67 273.77,44.67 273.7,44.6 273.38,44.6 271.71,46.27 v3(271.71,50.08) 271.71,50.55 271.7,50.56 271.7,51.13 CV145.2
WIGIG_LANE_P0: length 213.1
  IN1 w0.089: v1(140.53,98.97) 140.53,99 140.36,99.16 140.36,101.49 139.92,101.93 139.92,103.94 141.83,105.86 145.1,105.86 145.58,106.33 150.83,106.33 151.02,106.52 151.02,106.79 151.11,106.88 151.38,106.88 151.47,106.79 151.47,106.52 151.65,106.33 152.15,106.33 152.34,106.52 152.34,106.74 152.42,106.83 152.69,106.83 152.78,106.74 152.78,106.52 152.97,106.33 153.38,106.33 153.57,106.52 153.57,106.74 153.65,106.83 153.92,106.83 154.01,106.74 154.01,106.52 154.2,106.33 156.9,106.33 157.35,105.88 178.6,105.88 178.99,106.27 191.51,106.27 192.11,106.87 193.41,106.87 193.61,107.08 193.61,107.53 193.74,107.66 194.06,107.66 194.19,107.53 194.19,106.99 194.37,106.8 194.78,106.8 194.97,106.99 194.97,107.5 195.06,107.59 195.33,107.59 195.41,107.5 195.41,106.99 195.6,106.8 196.01,106.8 196.2,106.99 196.2,107.5 196.29,107.59 196.56,107.59 196.64,107.5 196.64,106.99 196.83,106.8 197.24,106.8 197.43,106.99 197.43,107.5 197.52,107.59 201.71,107.59 204.58,104.72 220.16,104.72 221.09,105.64 222.36,105.64 223.72,106.99 225.56,106.99 225.95,107.38 238.02,107.38 239.45,108.81 242.64,108.81 244.08,110.25 251.19,110.25 251.28,110.16 251.28,109.96 251.51,109.74 251.84,109.74 252.06,109.96 252.06,110.16 252.15,110.25 260.74,110.25 263.03,107.96 269.47,107.96 270.16,107.27 270.76,107.27 270.95,107.46 270.95,107.72 v1(271.12,107.89)
  BOTTOM w0.102: v1(140.53,98.97) 140.31,98.76 140.31,98.33 139.96,97.98 139.96,97.13 140.05,97.05 UV7.40 ; CV157.1 280.05,52.74 280.05,52.96 279.84,53.17 278.93,53.17 278.63,53.47 278.63,54.21 278.35,54.49 278.35,56.24 278,56.58 278,67.52 273.41,72.12 273.41,77.45 273.4,77.46 273.4,77.47 273.05,77.82 273.05,81.51 272.34,82.22 272.34,83.94 272.17,84.11 272.17,105.51 270.93,106.75 270.93,107.7 v1(271.12,107.89)
WIGIG_LANE_P0_C: length 4.6
  BOTTOM w0.102: JNGFF1.26 278.1,49.36 277.95,49.5 277.95,49.6 278.69,50.33 v3(279.16,50.33) 279.64,50.33 280.03,50.72 280.03,51 CV157.2
WIGIG_LANE_P1: length 213.7
  IN1 w0.089: v1(141.9,100.4) 141.59,100.7 141.59,101.37 142.28,102.06 142.28,103.2 143.47,104.4 146.37,104.4 147,105.03 153.87,105.03 154.85,104.05 156.71,104.05 156.86,103.9 159.56,103.9 160.23,104.57 179.88,104.57 180.15,104.29 181.98,104.29 182.6,104.91 202.44,104.91 204.08,103.27 222.99,103.27 225.43,105.7 231.93,105.7 232.14,105.5 236.84,105.5 237.4,106.06 238.62,106.06 239.94,107.38 240.32,107.38 240.32,107.38 243.09,107.38 243.46,107.75 247.13,107.75 247.47,108.09 260.51,108.09 262.01,106.59 268.08,106.59 268.21,106.47 268.21,106.15 268.08,106.03 266.26,106.03 266.03,105.8 266.03,105.23 266.26,105 267.12,105 267.25,104.87 267.25,104.58 267.12,104.45 266.26,104.45 266.03,104.23 266.03,103.78 266.31,103.5 267.82,103.5 268.05,103.73 268.05,104.37 268.14,104.45 268.4,104.45 268.49,104.37 268.49,103.69 268.68,103.5 269.09,103.5 269.28,103.69 269.28,105.12 269.41,105.25 269.6,105.25 269.72,105.12 269.72,103.69 269.91,103.5 271.09,103.5 271.26,103.67 271.26,104.13 v1(271.33,104.21)
  BOTTOM w0.102: UV7.37 138.85,97.2 138.75,97.29 138.75,98.48 140.08,99.81 141.22,99.81 141.81,100.4 v1(141.9,100.4) ; v1(271.33,104.21) 271.31,104.18 271.31,102.8 271.26,102.76 271.26,86.83 271.26,86.83 271.26,86.66 271.26,83.86 271.44,83.69 271.44,78.28 272.58,77.13 272.58,75.89 272.58,71.78 276.99,67.38 276.99,64.48 276.24,63.73 276.24,57.32 276.15,57.23 276.15,54.93 276.3,54.78 276.87,54.78 277.77,53.88 277.77,53.14 278,52.92 278,52.77 CV153.1
WIGIG_LANE_P1_C: length 4.1
  BOTTOM w0.102: CV153.2 278.07,51.07 278.07,50.92 v3(277.57,50.42) 277.28,50.13 276.92,50.13 276.45,49.67 276.45,49.5 276.6,49.36 JNGFF1.20
WIGIG_LANE_P2: length 205.2
  IN1 w0.089: v1(143.21,100.39) 143.42,100.6 143.42,100.78 142.9,101.3 142.9,103.12 143.61,103.84 146.77,103.84 147.49,104.56 153.61,104.56 154.6,103.57 156.25,103.57 156.57,103.25 160.99,103.25 161.81,104.08 179.61,104.08 179.87,103.82 182.48,103.82 183.05,104.38 202.25,104.38 203.83,102.8 223.2,102.8 225.4,105.01 237.03,105.01 237.6,105.58 238.91,105.58 240.2,106.87 243.28,106.87 243.67,107.26 247.34,107.26 247.7,107.62 260.17,107.62 261.68,106.11 262.27,106.11 262.45,105.92 262.45,105.12 262.58,104.99 262.77,104.99 262.9,105.12 262.9,105.92 263.09,106.11 263.5,106.11 263.68,105.92 263.68,105.17 263.81,105.04 264,105.04 264.13,105.17 264.13,105.92 264.32,106.11 264.76,106.11 264.99,105.88 264.99,105.07 265.06,105 265.29,105 v1(265.49,105.21)
  BOTTOM w0.102: CV148.1 274.36,52.34 273.95,52.75 273.95,52.9 273.75,53.1 273.31,53.1 272.58,53.83 272.58,60.59 272.31,60.86 272.31,62.39 272.85,62.93 272.85,65.06 272.13,65.78 272.13,69.58 271.54,70.17 271.17,70.17 270.68,70.66 270.68,72.01 270.48,72.21 270.48,74.13 269.74,74.87 268.48,74.87 268.01,75.34 268.01,78.78 267.52,79.27 267.22,79.27 266.91,79.58 266.14,79.58 265.7,80.03 265.7,85.14 265.12,85.72 265.12,101.76 266.65,103.3 266.65,104.61 266.25,105.02 265.68,105.02 v1(265.49,105.21) ; UV7.35 138.05,97.21 137.9,97.36 137.9,98.8 140.17,101.07 143.06,101.07 143.42,100.71 143.42,100.6 v1(143.21,100.39)
WIGIG_LANE_P2_C: length 12.5
  BOTTOM w0.102: JNGFF1.19 276.35,41.81 276.2,41.95 276.2,44.57 272.95,47.83 272.95,49.85 v3(273.33,50.23) 273.94,50.84 273.94,51 CV148.2
WIGIG_LANE_P3: length 205.3
  IN1 w0.089: v1(264.45,104.1) 264.21,103.87 264.21,103.72 263.99,103.5 262.93,103.5 262.33,104.1 262.21,104.1 261.99,103.88 261.67,103.88 261.43,104.12 261.43,104.44 261.65,104.65 261.65,104.78 261.46,104.97 261.34,104.97 260.34,103.97 260.02,103.97 259.78,104.21 259.78,104.53 260.86,105.61 260.86,105.79 260.73,105.92 260.55,105.92 260.26,105.63 259.92,105.29 259.6,105.29 259.28,105.61 259.28,105.93 259.72,106.38 259.72,106.56 259.59,106.69 259.41,106.69 258.31,105.59 256.39,105.59 255.3,106.68 251.38,106.68 249.56,104.87 241.76,104.87 241.64,104.75 237.98,104.75 236.67,103.44 225.13,103.44 223.67,101.98 203.21,101.98 202.17,103.01 179.5,103.01 179.27,103.25 168.26,103.25 168.17,103.16 168.17,102.69 167.99,102.5 167.58,102.5 167.39,102.69 167.39,103.16 167.3,103.25 167.03,103.25 166.94,103.16 166.94,102.37 166.72,102.14 166.32,102.14 166.09,102.37 166.09,102.54 165.96,102.67 165.77,102.67 165.65,102.54 165.65,102.36 165.46,102.17 160.43,102.17 160.17,102.44 156.18,102.44 155.87,102.74 154.06,102.74 153.09,103.71 147.98,103.71 147.12,102.85 147.11,102.85 146.27,102.02 144.19,102.02 143.9,102.31 143.9,102.46 v1(143.55,102.81)
  BOTTOM w0.102: v1(143.55,102.81) 143.8,103.06 143.8,103.42 143.67,103.55 142.93,103.55 141.34,101.95 138.82,101.95 136.33,99.46 136.33,98.04 136.75,97.62 136.75,97.29 136.85,97.2 UV7.32 ; CV146.1 272,52.67 272,53.23 271.74,53.48 271.74,60.18 271.49,60.43 271.49,62.74 272.01,63.26 272.01,64.68 271.3,65.39 271.3,68.89 269.62,70.56 269.62,72.54 268.75,73.41 268.22,73.41 267.12,74.51 267.12,76.75 264.99,78.88 264.99,79.46 264.85,79.61 264.85,84.8 264.26,85.38 264.26,103.92 v1(264.45,104.1)
WIGIG_LANE_P3_C: length 12.5
  BOTTOM w0.102: JNGFF1.13 274.85,41.81 274.7,41.95 274.7,42.22 274.59,42.33 274.59,43.69 274.27,44.01 274.27,44.15 274.34,44.23 274.34,44.58 274.04,44.88 273.69,44.88 273.61,44.81 273.47,44.81 271.92,46.36 271.92,49.78 271.94,49.8 271.94,50.36 271.92,50.38 271.92,50.64 271.91,50.65 271.91,51.01 CV146.2
WIGIGCLK_REQ#: length 152.1
  TOP w0.102: v1(207.95,39.74) v2(207.95,37.4) 207.95,35.35 208.84,34.46 211.05,34.46 211.33,34.74 211.33,35.19 214.7,38.56 220.76,38.56 221.72,39.51 224.79,39.51 225.98,40.71 236.29,40.71 237.65,42.06 240.12,42.06 244.9,46.84 249.42,46.84 251.67,44.59 262.35,44.59 262.81,44.12 268.45,44.12 270.29,45.96 285.17,45.96 v1(285.83,46.62)
  IN1 w0.089: v1(182.32,63.58) 182.71,63.97 187.66,63.97 188.75,62.88 190.87,62.88 195.29,58.46 197.24,58.46 199.42,56.29 199.42,52.77 200.55,51.64 200.55,48.03 v1(205.46,43.12)
  IN4 w0.086: v1(166.42,61.52) 166.45,61.55 168.12,61.55 168.22,61.45 168.63,61.45 169.44,62.26 171.77,62.26
  IN4 w0.089: v1(182.32,63.58) 182.21,63.46 180.6,63.46 179.65,62.51 176.25,62.51 175.86,62.91 174.54,62.91 174.09,62.46 172.38,62.46 172.17,62.26 171.77,62.26
  BOTTOM w0.076: UC1.U5 166.35,61.45 v1(166.42,61.52)
  BOTTOM w0.102: v1(285.83,46.62) 286.6,47.4 JNGFF1.60 ; v1(207.95,39.74) 205.46,42.23 v1(205.46,43.12) ; RPC4.5 182.74,63.07 182.35,63.46 182.35,63.55 v1(182.32,63.58)
WIRELESS_LED#: length 125.3
  TOP w0.102: v1(307.35,86.46) v2(307.35,87.29) ; QZ11.6 278.56,50.42 278.23,50.08 275.74,50.08 275.01,50.81 QZ2.6 275.01,51.5 273.71,52.8 QZ2.3 273.71,54.27 v1(274.36,54.92) ; UE1.A47 v1(257.67,73.26)
  IN1 w0.089: v1(301.38,72.88) 300.47,71.96 294.46,71.96 293.05,73.37 284,73.37 281.7,71.07 275,71.07 271.25,74.82 265.68,74.82 265.35,74.49 258.43,74.49 257.67,73.73 v1(257.67,73.26)
  IN2 w0.122: v1(298.7,54.28) 297.97,55.02 297.97,60.04 298.14,60.21 298.14,62.24 299.83,63.93 299.83,64.15 300.99,65.3 300.99,68.86 301.8,69.67 301.8,72.46 v1(301.38,72.88) 301.38,78.06 302.35,79.02 302.35,82.26 305.89,85.8 306.69,85.8 v1(307.35,86.46)
  IN3 w0.122: v1(298.7,54.28) 298.36,53.94 289.63,53.94 287.85,55.73 282.64,55.73 282.23,56.13 276.57,56.13 275.73,55.3 274.74,55.3 v1(274.36,54.92)
  BOTTOM w0.102: RZ31.2 307.35,86.96 v1(307.35,86.46) 308.84,86.46 309.01,86.64 QZ7.1
WLAN_DISBL#: length 31.8
  TOP w0.102: UE1.B68 258.46,83.44 257.76,82.74 v1(257.76,82.26) ; v1(284.44,82.03) 284.33,81.92 UL2.4
  IN1 w0.089: v1(257.76,82.26) 258.55,81.47 262.6,81.47 264.62,79.45 267.11,79.45 267.35,79.21 272,79.21 274,81.22 282.74,81.22 283.6,82.08 284.39,82.08 v1(284.44,82.03)
WLAN_LED: length 57.1
  TOP w0.102: v1(303.63,46.61) 303.81,46.43 303.81,44.45 299.07,39.72 296.75,39.72 296.08,40.38 JLED1.6 ; v1(307.76,83.72) v2(307.76,83.12)
  IN2 w0.122: v1(303.63,46.61) 303.43,46.82 303.42,46.82 303.17,47.06 303.17,47.64 303.29,47.75 303.29,52.54 303.52,52.77 303.52,57.97 302.46,59.02 302.21,59.02 301.94,59.29 301.94,60.86 301.69,61.11 301.69,62.73 303.8,64.84 303.8,67.5 309.18,72.89 309.18,82.34 307.8,83.72 v1(307.76,83.72)
  BOTTOM w0.102: v1(307.76,83.72) 307.29,84.19 QZ9.3
WLAN_LED#: length 12
  TOP w0.102: v2(271.44,49.98) 271.44,50.1 v1(270.8,50.74) ; RZ14.1 275.65,52.85 275.41,53.09 QZ2.1 275.01,54.18 v1(275.08,54.26)
  IN2 w0.122: v1(270.8,50.74) 271.08,51.02 272.42,51.02 275.08,53.68 v1(275.08,54.26)
  BOTTOM w0.102: JNGFF1.6 271.1,50.44 v1(270.8,50.74)
WLAN_LED_Q#: length 4.8
  BOTTOM w0.102: v2(305.35,87.01) 306.68,85.68 QZ9.2 308.94,85.68 309.01,85.6 QZ7.6
WLAN_WIGIG60GHZ_DIS#: length 91.2
  TOP w0.102: UE1.A1 258.17,85.16 258.81,85.8 v1(258.81,86.17) 258.81,86.45 258.48,86.78 RE8.2 ; v1(281.41,55.06) 282.77,55.06 283.51,54.31 283.51,53.85 284.28,53.09 DZ1.1 ; v2(259.88,99.38) 259.88,99.13 259.42,98.67 v1(259.42,98.49)
  IN1 w0.089: v1(281.41,55.06) 281.3,55.17 281.3,55.54 280.72,56.12 276.29,56.12 v1(275.04,54.87)
  IN2 w0.122: v1(275.04,54.87) 275.76,55.58 275.76,56.63 276.8,57.68 276.8,59.69 277.79,60.68 277.79,63.32 279.46,65 279.46,68.47 275.32,72.61 275.32,89.51 275.46,89.65 275.46,96.75 275.06,97.16 264.85,97.16 264.07,97.93 259.98,97.93 v1(259.42,98.49)
  BOTTOM w0.102: v1(258.81,86.17) 258.48,86.5 258.48,88.65 258.29,88.84 258.29,97.28 259.42,98.41 v1(259.42,98.49)
WLAN_WIGIG60GHZ_DIS#_R: length 5
  TOP w0.102: v2(284.9,50.82) 285.03,50.94 DZ1.2 284.57,51.69 v1(284.38,51.5)
  BOTTOM w0.102: JNGFF1.48 283.6,50.72 v1(284.38,51.5)
WLANCLK_REQ#: length 175.1
  TOP w0.102: v1(230.58,75.76) 229.62,76.72 v2(229.62,79.06) 229.62,80.25 227.42,82.45 221.96,82.45 220.69,83.72 213.88,83.72 v1(213.07,82.91)
  IN2 w0.086: 171.77,63.02 171.56,62.82 171.08,62.82 v1(170.76,63.13)
  IN2 w0.122: v1(230.58,75.76) 230.58,73.83 235.32,69.09 236.73,69.09 238.04,67.78 245.67,67.78 246.42,68.53 250.66,68.53 250.88,68.76 251.62,68.76 252.02,68.36 260.48,68.36 260.68,68.55 265.38,68.55 265.49,68.44 270.94,68.44 272.78,66.6 v1(273.69,66.6) ; v1(213.07,82.91) 213.07,82.9 211.95,84.02 201,84.02 198.09,81.12 198.09,76.61 193.59,72.1 186.22,72.1 184.94,70.82 183.83,70.82 180.34,67.33 175.42,67.33 174,65.91 174,64.63 173.19,63.82 172.57,63.82 171.77,63.02
  IN4 w0.089: v1(273.69,66.6) 273.69,65.61 276,63.3 276,49.4 275.98,49.38 275.98,41.75 276.96,40.77 281.67,40.77 283.12,42.22 v1(283.12,42.33)
  BOTTOM w0.076: 171.77,63.36 171.7,63.36 171.5,63.57 171.2,63.57 v1(170.76,63.13)
  BOTTOM w0.089: v1(170.76,63.13) 170.42,63.48 169.64,63.48 169.27,63.11 169.08,63.11 UC1.N1
  BOTTOM w0.102: 171.77,63.36 172.26,63.36 173.7,61.93 176.04,61.93 177.7,60.27 RPC16.6 ; JNGFF1.45 282.85,42.06 v1(283.12,42.33)
WWAN_LED#: length 48.9
  TOP w0.102: v1(279.73,53.6) 279.97,53.36 RZ37.1 279.27,52.86 279.05,53.09 QZ11.1 ; v1(288.05,67.12) v2(288.71,67.12)
  IN1 w0.089: v1(279.73,53.6) 279.97,53.6 280.48,54.1 281.33,54.1 281.94,54.71 286.99,54.71 v1(287.5,54.21)
  IN2 w0.122: v1(287.5,54.21) 287.29,54.42 287.29,57.05 287.77,57.53 287.77,66.84 v1(288.05,67.12)
  IN4 w0.089: v1(288.05,67.12) 287.22,67.12 284.96,69.38 284.96,76.69 283.41,78.23 283.41,80.07 282.03,81.45 282.03,85.31 282.51,85.79 282.84,85.79 v1(283.25,86.2)
  BOTTOM w0.102: v1(283.25,86.2) 283.6,85.85 JNGFF2.10
WWAN_PWR_EN: length 9.7
  BOTTOM w0.102: JNGFF2.6 285.23,84.85 285.81,84.27 285.81,82.77 284.59,81.55 RZ43.2 284.59,77.46 v2(285.15,76.9)
WWAN_RADIO_DIS#: length 35.4
  TOP w0.102: UE1.A53 v1(261.81,77.69) 262.37,77.69 RE10.2 ; v2(288.84,85.03) DZ5.1 287.86,85.03 v1(287.29,84.46)
  IN1 w0.089: v1(287.29,84.46) 287.69,84.05 287.69,82.13 287.43,81.87 285.76,81.87 285.52,81.62 283.65,81.62 282.87,80.84 273.93,80.84 270.3,77.21 262.21,77.21 261.81,77.62 v1(261.81,77.69)
WWAN_RADIO_DIS#_R: length 3.8
  TOP w0.102: v1(285.64,85.05) 285.66,85.03 DZ5.2 286.49,85.51 v2(287.34,86.36)
  BOTTOM w0.102: JNGFF2.8 285.34,85.35 v1(285.64,85.05)
WWAN_WAKE#: length 56.5
  TOP w0.102: UE1.B43 254.42,75.25 254.23,75.44 254.23,76.14 254.61,76.52 256.77,76.52 v1(257.15,76.14) ; RE276.2 259.94,84.74 260.74,83.94 v2(261.79,83.94) v1(263.51,83.94)
  IN1 w0.089: v1(256.88,83.29) 257.53,83.94 v1(263.51,83.94) 265.39,83.94 266.61,85.16 269.15,85.16 269.88,84.43 279.07,84.43 281.32,86.68 287.18,86.68 289.19,88.69 v1(290.44,88.69)
  IN2 w0.122: v1(256.88,83.29) 256.88,82.04 256.58,81.73 256.58,79.09 256.88,78.78 256.88,77.68 257.15,77.41 v1(257.15,76.14)
  BOTTOM w0.102: JNGFF2.15 290.92,89.1 290.51,88.69 v1(290.44,88.69)
XDP_DBRESET#: length 149.4
  TOP w0.102: v1(194.78,33.56) 193.26,32.03 v1(193.26,28.64) ; v1(192.96,44.5) 192.27,45.2 192.27,47.74 193.04,48.52 v2(193.04,49.55) 193.04,50.24 v1(192.66,50.62) ; UC4.1 177.24,58.85 177.44,58.65 177.44,58.4 RC122.2 RC77.1 176.77,56.61 177.18,56.2 v1(177.18,56.07) ; CC21.1 101.88,25.03 JXDP1.48 98.01,25.03 v1(97.8,24.82)
  IN1 w0.089: v1(192.66,50.62) 192.66,52.36 191.61,53.41 185.08,53.41 185.08,53.41 184.77,53.72 183.92,53.72 183.6,53.41 181.46,53.41 179.24,55.64 177.66,55.64 177.23,56.07 v1(177.18,56.07)
  BOTTOM w0.102: v1(194.78,33.56) 194.78,40.58 193.46,41.9 193.46,42.9 192.96,43.4 v1(192.96,44.5) ; v1(97.8,24.82) 98.45,25.47 108.78,25.47 111.96,28.64 v1(193.26,28.64)
XDP_OBS0_R: length 66.6
  TOP w0.102: JXDP1.21 95.09,31.53 95.45,31.89 95.9,31.89 v1(96.38,31.41)
  IN4 w0.089: v1(96.38,31.41) 96.22,31.57 96.22,33.09 97.84,34.71 104.61,34.71 106,36.1 109.03,36.1 111.61,38.67 111.61,39.36 112.56,40.31 112.56,49.72 115.46,52.62 115.46,54.44 115.85,54.84 118.68,54.84 120.28,56.44 121.48,56.44 122.81,57.77 122.81,60.27 121.96,61.12 121.96,63.71 123.57,65.32 126.73,65.32 v1(127.13,64.92)
  BOTTOM w0.076: UC1.J60 132.01,64.97 131.53,64.97 131.5,65.01 130.71,65.01 130.55,64.84 129.57,64.84 129.27,65.14 129.27,65.14 129.08,65.34 127.54,65.34 127.45,65.24
  BOTTOM w0.102: 127.45,65.24 v1(127.13,64.92)
XDP_OBS1_R: length 67.9
  TOP w0.102: JXDP1.23 95.36,31.03 v1(95.77,31.43)
  IN4 w0.086: 127.45,65.72 128.34,65.72 129,65.06 129.93,65.06 130.11,65.24 131.6,65.24 132.01,65.65 v1(132.01,65.68)
  IN4 w0.089: v1(95.77,31.43) 95.77,31.61 94.74,32.64 94.74,33.45 96.39,35.11 104.36,35.11 105.77,36.52 105.91,36.52 106.73,37.34 108.89,37.34 111.93,40.38 111.93,40.9 111.54,41.28 111.54,49.79 114.85,53.09 114.85,54.49 115.7,55.34 116.39,55.34 116.95,55.9 119.18,55.9 120.22,56.94 121.42,56.94 122.39,57.9 122.39,60.13 121.56,60.96 121.56,63.87 123.41,65.72 123.73,65.72 123.73,65.72 127.45,65.72
  BOTTOM w0.076: UC1.H60 132.31,65.98 v1(132.01,65.68)
XDP_OBS2_R: length 11.4
  TOP w0.102: T10.1 124.12,63.44 124.12,65.22 124.71,65.81 128.28,65.81 v1(128.83,66.36)
  BOTTOM w0.076: v1(128.83,66.36) 129.23,65.96 130.03,65.96 130.23,65.76 130.48,65.76 130.7,65.98 130.7,66.16 130.88,66.34 131.4,66.34 UC1.H61
XDP_OBS3_R: length 10.6
  TOP w0.076: 127.45,66.59 v1(127.62,66.42)
  TOP w0.102: 127.45,66.59 127.21,66.83 124.1,66.83 123.1,65.83 T11.1
  BOTTOM w0.076: UC1.H62 130.56,65.6 130.55,65.6 130.55,65.59 130.16,65.59 129.96,65.8 128.89,65.8 128.65,66.04 128,66.04
  BOTTOM w0.102: 128,66.04 v1(127.62,66.42)
XDP_OBS4_R: length 11.1
  TOP w0.076: v1(133.37,64.9) 131.01,64.9 130.21,64.1 128.71,64.1 127.8,63.19 126.4,63.19 126.37,63.15
  TOP w0.102: T12.1 124.75,62.04 125.26,62.04 126.37,63.15
  BOTTOM w0.076: v1(133.37,64.9) 133.06,64.59 UC1.K59
XDP_OBS5_R: length 10.9
  TOP w0.076: 127.45,67.24 128.47,67.24 v1(129.39,66.32)
  TOP w0.102: 127.45,67.24 123.86,67.24 121.82,65.19 T13.1
  BOTTOM w0.076: UC1.H63 130.26,66.15 129.55,66.15 v1(129.39,66.32)
XDP_OBS6_R: length 8.6
  TOP w0.102: v1(132.01,64.18) 131.88,64.18 131.51,64.54 131.2,64.54 130.48,63.82 129.07,63.82 128.56,63.31 128.56,62.61 127.48,61.53 T14.1
  BOTTOM w0.076: v1(132.01,64.18) 132.31,64.48 UC1.K60
XDP_OBS7_R: length 8.1
  TOP w0.076: v1(131.36,65.68) 130.64,64.96 129.22,64.96 127.88,63.62 126.37,63.62
  TOP w0.102: T15.1 125.82,63.62 126.37,63.62
  BOTTOM w0.076: v1(131.36,65.68) 131.66,65.37 UC1.J61
XDP_RST#_R: length 3.4
  TOP w0.102: RC106.2 102.39,25.53 v2(101.46,25.53) JXDP1.46
XTAL24_IN: length 12.2
  BOTTOM w0.076: 156.88,74.93 156.88,74.3 155.68,73.09 155.68,71.69 154.47,70.49 154.47,70.44 UC1.A25
  BOTTOM w0.102: 156.88,74.93 v2(156.88,76.01) 156.88,76.71 RC63.2 157.19,77.22 156.81,77.6 CC8.2 156.81,79.26 157.6,80.06 YC2.3
XTAL24_OUT: length 9.8
  BOTTOM w0.076: UC1.B25 154.27,69.71 153.97,70 153.97,70.37 154.25,70.65 154.4,70.65 155.51,71.76 155.51,73.02 155.51,73.16 156.27,73.92 v2(156.27,74.81) 156.27,74.93
  BOTTOM w0.102: 156.27,74.93 RC63.1 156.27,77.29 155.94,77.62 RC65.1
XTAL24_OUT_R: length 5.5
  BOTTOM w0.102: RC65.2 155.03,78.16 155.84,78.98 155.84,79.21 CC11.2 156.49,79.86 156.49,81.36 YC2.1
XTALI: length 8.7
  TOP w0.102: YL1.1 269.01,80.98 v2(270.66,80.98) 272.36,82.68 CL14.2 272.52,82.73 RL11.2 273.65,82.73 274.1,83.19 274.1,83.8 274.55,84.24 274.81,84.24 275.08,84.52 UL1.10
XTALO: length 3.8
  TOP w0.102: RL10.2 272.52,83.64 RL11.1 v2(274.45,84.56) 274.8,84.56 275.16,84.92 UL1.9
XTALO_R: length 5.7
  TOP w0.102: RL10.1 271.49,83.7 CL13.2 270.14,82.82 269.56,82.24 267.91,82.24 267.06,83.08 YL1.3
Z2805: length 3.6
  TOP w0.127: v2(306.64,101.89) 306.64,100.89 v1(306.51,100.75)
  TOP w0.508: RL18.1 306.11,100.35 v1(306.51,100.75)
  BOTTOM w0.508: v1(306.51,100.75) 306.85,100.41 TL1.22
Z2806: length 3.6
  TOP w0.127: v1(299.23,100.87) 299.69,100.87 v2(300.01,100.55)
  TOP w0.508: v1(299.23,100.87) 299.03,100.87 298.49,100.34 RL16.1
  BOTTOM w0.508: TL1.16 v1(299.23,100.87)
Z2807: length 3.7
  TOP w0.127: v2(304.95,101.69) 305.47,101.17 v1(305.47,100.98)
  TOP w0.508: RL17.1 304.84,100.34 v1(305.47,100.98)
  BOTTOM w0.508: v1(305.47,100.98) 305.58,100.87 TL1.21
Z2808: length 3.5
  TOP w0.127: v1(297.62,100.9) 297.62,101.58 v2(297.48,101.72)
  TOP w0.508: v1(297.62,100.9) 297.22,100.5 RL15.1
  BOTTOM w0.508: v1(297.62,100.9) 297.96,100.57 TL1.15
N15115: length 4
  TOP w0.076: v1(167.31,56.67) 167.65,57.01 170.55,57.01 T16.1
  BOTTOM w0.076: UC1.AD4 167.03,57.01 167.31,56.73 v1(167.31,56.67)
N19253: length 9.2
  BOTTOM w0.076: UC1.AV63 129.82,48.9
  BOTTOM w0.102: T28.1 124.07,44.17 126.21,46.31 127.23,46.31 129.82,48.9
N19255: length 13.2
  BOTTOM w0.076: UC1.AU63 129.84,49.56
  BOTTOM w0.102: 129.84,49.56 127.23,46.95 125.81,46.95 121.03,42.18 T29.1
N19263: length 6.6
  BOTTOM w0.076: UC1.C63 129.87,69.41 128.47,69.41 127.84,70.04 127.45,70.04
  BOTTOM w0.102: 127.45,70.04 127.14,70.04 T30.1
N19267: length 5.6
  BOTTOM w0.076: 127.45,69.71 127.71,69.45 127.97,69.45 128.26,69.15 129.46,69.15 130.03,68.59 130.74,68.59 UC1.C62
  BOTTOM w0.102: 127.45,69.71 T31.1
N19275: length 7.5
  IN2 w0.086: v1(138.1,71.19) 139.23,72.32 140.11,72.32 140.41,72.62 140.41,73.39
  IN2 w0.122: v1(140.41,75.59) 140.41,73.39
  BOTTOM w0.076: v1(138.1,71.19) 138,71.08 138,70.74 138.1,70.64 UC1.A51
  BOTTOM w0.102: T33.1 140.92,75.59 v1(140.41,75.59)
N19277: length 9
  IN2 w0.086: 140.7,73.39 140.7,72.53 140.28,72.11 139.32,72.11 138.68,71.48 v1(138.68,71.16)
  IN2 w0.122: v1(142.04,75.25) 141.19,75.25 140.7,74.77 140.7,73.39
  BOTTOM w0.076: UC1.B51 138.44,69.93 138.44,70.97 138.63,71.16 v1(138.68,71.16)
  BOTTOM w0.102: T34.1 142.1,75.31 v1(142.04,75.25)
N19281: length 12.6
  TOP w0.076: v1(131.31,63.43) 130.94,63.06 130.37,63.06 130.17,62.86 130.17,61.39 128.89,60.11 126.64,60.11 126.4,60.35
  TOP w0.102: T35.1 122.49,60.35 126.4,60.35
  BOTTOM w0.076: v1(131.31,63.43) 131.88,63.43 132.22,63.76 UC1.L60
N21871: length 1.4
  TOP w0.076: v1(131.98,62.7) 131.98,62.16 T74.1
  BOTTOM w0.076: v1(131.98,62.7) 132.31,62.37 UC1.P60
N21873: length 1.7
  TOP w0.076: v1(131.36,62.68) 131.72,63.05 131.72,63.15 T75.1
  BOTTOM w0.076: UC1.P61 131.66,62.38 v1(131.36,62.68)
N21875: length 1.3
  TOP w0.076: v1(133.37,63.4) 133.37,63.28 T76.1
  BOTTOM w0.076: v1(133.37,63.4) 133.06,63.09 UC1.N59
N21877: length 3.1
  TOP w0.076: T77.1 132.79,64.33 v1(132.65,64.19)
  BOTTOM w0.076: UC1.N61 131.89,63.09 132.22,63.43 132.44,63.43 132.65,63.64 v1(132.65,64.19)
N29827: length 8.5
  TOP w0.102: RD15.2 150.46,10.48 150.46,8.06 v1(151.04,7.48) 151.42,7.1 v2(151.42,7.05)
  BOTTOM w0.102: JDIMM1.197 150.16,10.21 150.49,9.89 150.49,8.03 v1(151.04,7.48)
N29829: length 4.8
  TOP w0.102: RD16.2 151.43,10.52 151.43,9.71 v1(150.97,9.25) 151.14,9.08 v2(151.55,9.08)
  BOTTOM w0.102: v1(150.97,9.25) 151.47,9.75 151.47,10.16 151.36,10.28 JDIMM1.201
N33048: length 2.2
  TOP w0.102: CD36.2 RD21.1 210.6,4.18 v2(210.21,4.57)
N33050: length 2.2
  TOP w0.102: v2(164.5,2.73) 164.58,2.66 RD25.1 CD54.2
N33054: length 10
  TOP w0.102: v1(226.92,14.15) 226.27,14.8 RD28.1 v2(221.48,15.99)
  BOTTOM w0.102: v1(226.92,14.15) 226.16,13.39 JDIMM2.197
N33058: length 8
  TOP w0.102: v1(226.92,13.57) 226.7,13.78 v2(222.53,13.78) RD27.1
  BOTTOM w0.102: JDIMM2.201 227.36,13.13 v1(226.92,13.57)
N40459: length 4
  TOP w0.102: v2(87.19,92.27) 87.46,92.27 87.92,92.73 QV2.1 88.06,93.1 88.71,92.45 RV5.2
N42068: length 3.1
  TOP w0.102: RV19.2 82.4,102.24 QV4.2 81.28,103 v2(80.86,103.42)
N43975: length 3.6
  TOP w0.102: v2(279.97,57.83) 279.25,58.55 QN1.6 QN1.5 278.88,59.76 278.83,59.81 RN2.2
N46665: length 2.4
  TOP w0.203: UA1.35 23.38,93.01 23.32,92.95 23.13,92.95 22.63,92.46 22.63,92.42
  TOP w0.254: CA29.1 22.42,92.2 22.63,92.42
N46669: length 3.2
  TOP w0.203: UA1.36 23.34,92.61 22.59,91.86 22.59,91.28
  TOP w0.254: CA29.2 22.12,90.81 22.59,91.28
N46677: length 2.2
  TOP w0.203: CA25.1 22.02,94.49 22.17,94.34 22.6,94.34 22.8,94.54 22.83,94.54 22.9,94.61 UA1.31
N46697: length 3
  TOP w0.102: v2(35.19,97.91) 35.9,98.62 RA12.1 34.63,98.87 CA27.1
N46705: length 3
  TOP w0.102: CA28.1 34.63,99.89 RA13.1 35.92,99.9 35.92,100.33 v2(36.49,100.9)
N46713: length 51.9
  TOP w0.102: QA2.5 QA2.6 14.18,94.49 14.9,95.21 v1(14.9,95.32) v2(14.9,95.87)
  IN3 w0.122: v1(32.78,90.92) 32.78,87.37 35.55,84.6 35.55,81.96 32,78.41 23.05,78.41 22.14,79.33 22.14,84.39 21.3,85.23 19.52,85.23 18.76,85.99 18.76,88.36 20.64,90.24 20.64,91.91 17.75,94.8 15.42,94.8 v1(14.9,95.32)
  BOTTOM w0.102: RA21.2 32.47,91.23 v1(32.78,90.92)
N46735: length 4.5
  TOP w0.102: v2(38.21,95.57) 37.9,95.89 36.8,95.89 CA33.1 35.5,94.97 35.42,95.05 34.86,95.05 34.75,94.94 RA17.2
N70739: length 6.6
  BOTTOM w0.102: JDEG1.1 284.02,37.15 284.33,36.85 v2(286.89,36.85) 287.62,36.12 287.62,35.92 288.71,34.83 RE71.2
N70745: length 9.6
  TOP w0.102: v1(257.85,56.15) 258.35,55.65 UE2.B61 ; RE64.1 258.56,49.24 v1(258.56,49.35)
  BOTTOM w0.102: v1(258.56,49.35) 258.56,49.45 258.2,49.81 258.2,50.71 v2(257.57,51.35) 257.57,55.27 257.45,55.4 257.45,55.73 257.68,55.97 257.68,55.98 v1(257.85,56.15)
N70747: length 2
  TOP w0.102: v2(255.18,69.29) 255.05,69.17 CE34.1 RE66.2
N70757: length 3.5
  TOP w0.102: UE2.A59 v2(259.1,52.73) 259.1,51.59 RE58.1 RE57.1
N73962: length 1.9
  TOP w0.102: CZ45.1 216.24,92.05 UZ9.12
N73964: length 2
  TOP w0.102: UZ9.10 217.04,91.83 CZ46.1
N75571: length 5
  TOP w0.102: RZ24.2 253.04,90.05 QZ3.1 254.15,89.33 v2(254.04,89.22) DZ4.2 254.04,87.84 254.88,87 DZ3.2
N75591: length 3.7
  TOP w0.102: QZ4.1 249.34,92.18 249.34,91 249.59,90.74 v2(249.85,90.74) 250.79,90.74 RZ27.1
N75595: length 3.2
  TOP w0.102: v2(256.55,89) 255.94,88.4 DZ3.1 255.31,89.38 255.45,89.52 QZ3.3
