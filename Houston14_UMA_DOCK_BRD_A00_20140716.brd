# Allegro board Houston14_UMA_DOCK_BRD_A00_20140716.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCH_PLTRST#_EC: length 371.7
  TOP w0.102: UE1.B22 v1(250.52,81.44) ; v1(190.14,66.49) 189.74,66.89 UZ1.16 ; v1(193.9,28.65) 193.81,28.75 193.81,31.66 195.44,33.29 v1(195.44,33.57) ; v1(252.77,93.5) 254.08,94.81 259.37,94.81 259.99,95.43 273.1,95.43 273.67,94.86 282.59,94.86 v1(283.34,95.61) ; v1(197.41,63.1) 197.72,63.1 198.41,62.4 198.41,57.28 196.96,55.83 196.96,52.36 193.52,48.92 193.52,44.06 v1(193.5,44.03) 193.17,43.7 190.4,43.7 189.85,44.25 189.85,45.7 189.27,46.28 185.62,46.28 184.9,47.01 184.9,48.47 185.85,49.42 185.85,50.38 185.64,50.6 185.64,51.01 185.38,51.26 185.38,51.39 185.48,51.49 UC5.4 186.64,51.49 186.65,51.5 RC304.1 ; UE2.B30 255.85,63.51 v1(255.78,63.44) ; RC106.1 104.05,25.21 105.27,26.43 v1(105.27,26.66)
  IN1 w0.089: v1(282.83,47.35) 282.74,47.44 281.48,47.44 280.89,46.84 271.86,46.84 271.33,47.37 269.02,47.37 268.81,47.58 267.86,47.58 v1(267.36,47.08) ; v1(190.14,66.49) 190.54,66.88 193.47,66.88 194.3,67.71 197.82,67.71 199.53,69.42 v1(199.53,69.5) 199.81,69.78 199.81,73.9 205.42,79.52 243.57,79.52 245.86,81.8 250.16,81.8 v1(250.52,81.44) ; v1(255.78,63.44) 256.26,62.96 256.26,62.49 256.32,62.42 257.26,62.42 257.35,62.51 257.35,63.82 257.98,64.44 262.72,64.44 v1(263.11,64.82)
  IN2 w0.122: v1(250.52,81.44) 251.06,81.98 255.18,81.98 v1(255.56,82.36)
  IN4 w0.089: v1(269.63,36.65) 267.03,39.25 267.03,43.58 267.73,44.27 267.73,46.45 267.36,46.81 v1(267.36,47.08) 267.61,47.34 267.61,52.73 267.37,52.98 267.37,59.66 267.14,59.89 267.14,60.1 266.23,61.01 261.16,61.01 260.67,61.51 260.67,63.42 261.41,64.16 262.45,64.16 v1(263.11,64.82)
  BOTTOM w0.102: JNGFF1.58 286.1,47.61 285.37,46.88 283.3,46.88 v1(282.83,47.35) 282.6,47.58 JNGFF1.44 ; v1(250.52,81.44) 250.52,81.55 250.1,81.97 250.1,83.57 251.66,85.13 251.66,86.66 252.82,87.81 252.82,93.45 v1(252.77,93.5) ; v1(255.78,63.44) 254.79,64.43 254.79,65.09 254.72,65.15 254.72,69.42 254.03,70.12 254.03,71.41 254.29,71.68 254.29,74.26 255.07,75.04 255.07,76.38 255.96,77.27 255.96,81.47 255.56,81.87 v1(255.56,82.36) ; v1(283.34,95.61) 283.34,95.6 283.59,95.85 JNGFF2.42 ; v1(105.27,26.66) 105.41,26.52 109.15,26.52 111.77,29.14 193.42,29.14 v1(193.9,28.65) ; v1(195.44,33.57) 195.44,40.82 193.94,42.32 193.94,43.59 v1(193.5,44.03) ; JLPDE1.8 v1(269.63,36.65) ; v1(199.53,69.5) 199.28,69.24 199.28,67.35 198.73,66.8 197.85,66.8 197.65,66.6 197.65,63.85 197.41,63.61 v1(197.41,63.1)
PCH_RSMRST#: length 32.8
  TOP w0.102: v1(250.44,52.25) 249.72,52.97 248.2,52.97 247.58,53.59 UZ6.1 ; RE88.1 243.26,71.01 243.46,71.21 244.81,71.21 245.72,70.3 245.72,66.91 244.53,65.71 244.53,65.19 244.09,64.76 v1(244.09,63.95) ; v1(250.76,57.72) 250.76,57.73 251.24,57.25 UE2.A45
  IN4 w0.089: v1(250.76,57.72) 250.65,57.61 250.65,55.97 250.37,55.69 250.37,52.77 250.44,52.69 v1(250.44,52.25)
  BOTTOM w0.102: v1(244.09,63.95) 244.63,63.95 246.42,62.16 246.42,60.25 248.95,57.72 v1(250.76,57.72)
PCH_RSMRST#_Q: length 103.1
  TOP w0.102: v1(244.56,52.83) 245.01,52.39 UZ6.4 ; v1(184.24,41.72) 184.76,42.24 RC91.2
  IN1 w0.089: v1(241.11,43.7) 241.11,43.53 239.06,41.49 237.33,41.49 231.53,35.69 230.56,35.69 226.3,31.42 207.76,31.42 205.7,33.48 200.41,33.48 199.59,34.29 196.57,34.29 195.5,35.36 192.7,35.36 188.62,39.44 187.16,39.44 185.04,41.56 184.4,41.56 v1(184.24,41.72)
  IN4 w0.086: 170.65,45.07 169.41,45.07 168.37,46.11 167.09,46.11 v1(166.56,45.57)
  IN4 w0.089: 170.65,45.07 175.3,45.07 176.83,43.54 180.82,43.54 181.86,42.5 181.86,42.15 182.55,41.47 183.36,41.47 183.69,41.8 184.16,41.8 v1(184.24,41.72)
  BOTTOM w0.076: UC1.AW6 165.32,47.96 165.32,46.42 166.16,45.57 v1(166.56,45.57)
  BOTTOM w0.102: v1(244.56,52.83) 243.01,51.29 243.01,49.72 242.72,49.43 242.72,48.83 241.38,47.49 241.38,43.97 v1(241.11,43.7)
PCH_RTCRST#: length 134.3
  TOP w0.076: v1(165.24,49.29) 165.33,49.29 166.74,47.88 166.74,46.8 167.2,46.34 167.2,45.05 167.39,44.86 168.44,44.86 169.17,44.12 169.17,43.5 169.79,42.89 170.19,42.89 170.56,42.52 170.65,42.52
  TOP w0.102: v1(208.21,34.05) 208.11,33.96 v4(204,33.96) 203.23,33.96 v1(200.6,31.33) ; v1(171.48,41.94) 170.89,42.52 170.65,42.52
  IN1 w0.089: v1(199.66,27.97) 199.49,28.13 188.47,28.13 178.02,38.59 176.8,38.59 176.44,38.23 174.66,38.23 174.32,38.57 174.32,39.19 171.69,41.82 171.59,41.82 v1(171.48,41.94)
  BOTTOM w0.076: v1(165.24,49.29) 165.12,49.29 164.86,49.56 UC1.AU7
  BOTTOM w0.102: v1(171.48,41.94) 172,41.94 RC8.2 ; JAPS1.9 230.19,78.01 230.62,77.59 CMOS1.2 231.1,77.05 231.28,76.88 CC4.2 231.71,76.32 232.99,75.03 232.99,72.27 238.19,67.07 238.19,60.94 238.61,60.52 238.61,59.43 238.61,58.44 238.18,58.01 238.18,56.59 236.47,54.89 236.47,49.34 234.85,47.72 233.14,47.72 230.04,44.61 230.04,44.39 229.16,43.52 229.16,42.95 226.85,40.64 226.85,36.41 225.25,34.81 215.89,34.81 214.77,35.93 214.75,35.93 214.69,35.99 214.29,35.99 213.88,35.58 213.88,34.55 212.92,33.59 208.66,33.59 v1(208.21,34.05) ; v1(200.6,31.33) 199.66,30.39 v1(199.66,27.97)
PCH_RTCX1: length 23.8
  BOTTOM w0.076: 166.74,47.26 166.74,47.88 UC1.AW5
  BOTTOM w0.102: 166.74,47.26 167.49,46.51 168.16,46.51 170.41,44.26 174.73,44.26 176.56,42.43 v2(180.8,42.43) 181.26,42.43 182.65,43.82 184.56,43.82 185.31,44.57 RC4.2 186.37,44.57 RC7.1
PCH_RTCX1_R: length 4.9
  BOTTOM w0.102: v2(184.76,46.64) 184.76,46.15 184.44,45.84 CC1.2 RC4.1 185.75,45.48 185.97,45.26 YC1.1
PCH_RTCX2: length 25.1
  BOTTOM w0.076: 166.54,47.17 166.54,47.47 UC1.AY5
  BOTTOM w0.102: 166.54,47.17 167.39,46.32 167.97,46.32 170.54,43.75 174.5,43.75 176.31,41.94 181.45,41.94 v2(182.18,42.67) 182.85,43.33 185.34,43.33 CC2.2 186.37,43.45 RC7.2 187.27,42.76 YC1.2
PCH_SMB_ALERT#: length 23
  TOP w0.102: v1(186.31,49.85) 186.31,49.3 v2(186.04,49.03)
  IN4 w0.089: v1(172.35,50.38) 173.36,51.39 174.23,51.39 174.61,51.77 176.1,51.77 176.48,51.39 181.14,51.39 182.38,50.14 186.02,50.14 v1(186.31,49.85)
  BOTTOM w0.076: 171.55,51.21 171.55,51.42 170.78,52.19 169.21,52.19 169.17,52.23 168.79,52.23 UC1.AN2
  BOTTOM w0.102: v1(172.35,50.38) 172.35,50.41 171.55,51.21 ; v1(186.31,49.85) 186.82,50.36 RPC19.2
PCH_SPI_CLK: length 64.7
  TOP w0.102: RZ26.1 183.93,64.33 183.29,64.98 v1(183.29,65.84)
  IN2 w0.086: v1(168.03,58.14) 168.85,58.96 169.05,58.96 170.4,60.3 171.77,60.3
  IN2 w0.122: 171.77,60.3 171.8,60.3 174.59,63.1 174.76,63.1 175.03,62.83 175.21,62.83 175.38,62.99 175.38,63.17 175.11,63.44 175.11,63.61 175.5,64 176.67,64 176.78,64.12 176.78,65.46 176.91,65.59 177.13,65.59 177.26,65.46 177.26,64.28 177.39,64.15 177.62,64.15 177.75,64.28 177.75,65.48 177.88,65.6 178.13,65.6 178.25,65.48 178.25,64.47 178.38,64.34 178.85,64.34 178.97,64.47 178.97,65.41 179.1,65.53 179.36,65.53 179.49,65.41 179.49,64.53 179.61,64.41 179.85,64.41 179.97,64.53 179.97,65.48 180.1,65.6 180.85,65.6 182.33,67.08 182.96,67.08 183.29,66.75 v1(183.29,65.84) 183.51,65.84 185.29,67.61 187.59,67.61 187.88,67.91 194.98,67.91 195.87,68.8 v1(195.87,69.12)
  BOTTOM w0.076: v1(168.03,58.14) 167.98,58.14 167.68,58.44 UC1.AA3
  BOTTOM w0.102: JSPI1.13 206.61,82.29 RC227.2 206.83,81.92 205.99,81.08 205.99,80.53 205.08,79.62 204.66,79.62 196.85,71.81 196.85,70 195.96,69.12 v1(195.87,69.12)
PCH_SPI_CS0#: length 61.3
  IN2 w0.086: 171.77,61.31 170.99,60.53 170.38,60.53 169,59.16 167.68,59.16 166.84,58.32 165.26,58.32 164.86,58.71 v1(164.67,58.71)
  IN2 w0.122: v1(197,68.28) 196.81,68.47 196.81,70.17 196.41,70.57 193.6,70.57 191.99,68.96 187.72,68.96 187.55,69.13 183.66,69.13 180.64,66.11 175.74,66.11 175.33,65.69 175.33,64.54 172.38,61.6 172.06,61.6 171.77,61.31
  BOTTOM w0.076: v1(164.67,58.71) 164.67,58.76 UC1.Y7
  BOTTOM w0.102: JSPI1.11 207.61,82.89 207.8,82.7 RC228.2 207.33,80.57 207.18,80.57 205.3,78.69 204.95,78.69 197.6,71.34 197.6,68.87 v1(197,68.28)
PCH_SPI_CS1#: length 70.2
  IN2 w0.122: v1(196.02,63.92) 195.86,63.92 195.84,63.94 195.42,63.94 194.89,63.41 194.2,63.41 193.76,62.98 185.18,62.98 182.7,60.5 176.68,60.5 174.27,58.09 173.7,58.09 173.33,57.72 v1(173.29,57.72)
  BOTTOM w0.076: 171.77,58.87 169.37,58.87 169.29,58.8 168.58,58.8 168.5,58.88 167.38,58.88 UC1.Y4
  BOTTOM w0.102: JSPI1.19 203.61,83.28 202.55,82.22 RC224.2 202.07,80.52 200.24,80.52 199.75,80.03 199.75,79.88 200.03,79.6 200.03,79.46 199.89,79.31 199.74,79.31 199.46,79.59 199.32,79.59 199.17,79.45 199.17,79.31 199.45,79.03 199.45,78.88 199.31,78.74 199.17,78.74 198.89,79.02 198.74,79.02 198.6,78.88 198.6,78.73 198.88,78.45 198.88,78.31 198.74,78.16 198.59,78.16 198.31,78.44 198.17,78.44 198.02,78.3 198.02,78.16 198.74,77.44 198.74,77.27 198.62,77.15 198.45,77.15 197.74,77.87 197.59,77.87 197.45,77.73 197.45,77.58 198.17,76.86 198.17,76.69 198.05,76.58 197.88,76.58 197.16,77.29 197.02,77.29 196.87,77.15 196.87,77.01 197.59,76.29 197.59,76.12 197.47,76 197.3,76 196.59,76.72 196.44,76.72 196.3,76.58 196.3,76.43 197.02,75.71 197.02,75.54 196.9,75.43 196.73,75.43 196.49,75.67 196.32,75.67 196.2,75.55 196.2,75.38 196.44,75.14 196.44,74.97 194.47,73 193.31,71.83 193.31,68.04 193.83,67.52 194.22,67.13 194.22,64.98 195.25,63.95 195.94,63.95 195.96,63.92 v1(196.02,63.92) ; v1(173.29,57.72) 173.29,57.89 172.59,58.59 172.14,58.59 171.86,58.87 171.77,58.87
PCH_SPI_CS2#: length 27.1
  TOP w0.102: v1(182.4,62.55) 182.4,62.6 182.85,63.06 183.07,63.06 183.32,63.31 RZ17.1
  IN2 w0.086: v1(170.56,57.71) 170.56,57.79 171.12,58.35 171.12,58.47 170.6,59 170.6,59.12 170.72,59.24 170.84,59.24 171.37,58.72 171.49,58.72 171.77,58.99
  IN2 w0.122: v1(182.4,62.55) 181.98,62.97 181.5,62.97 181.38,63.09 181.38,63.74 181.25,63.87 181.02,63.87 180.89,63.74 180.89,62.43 180.76,62.31 179.91,62.31 179.79,62.18 179.79,61.28 179.66,61.15 179.43,61.15 179.3,61.28 179.3,62.18 179.18,62.31 177.51,62.31 177.38,62.43 177.38,63.08 177.26,63.2 177.01,63.2 176.89,63.08 176.89,62.56 176.77,62.44 176.48,62.44 175.76,61.71 174.33,61.71 173.68,61.07 173.68,60.87 173.91,60.65 173.91,60.47 173.73,60.3 173.55,60.3 173.35,60.5 173.18,60.5 173.01,60.33 173.01,60.16 173.22,59.94 173.22,59.78 172.43,58.99 171.77,58.99
  BOTTOM w0.076: v1(170.56,57.71) 170.54,57.74 170.47,57.74 170.15,58.05 169.85,58.05 169.76,57.96 169.19,57.96 169.1,58.05 168.87,58.05 168.77,57.95 168.52,57.95 UC1.AC2
PCH_SPI_CS2#_R: length 3.4
  TOP w0.102: RZ17.2 185.22,62.99 v2(186.52,62.99) UZ1.22
PCH_SPI_DIN: length 76
  TOP w0.102: v1(182.37,58.99) 182.37,58.45 182.5,58.32 182.65,58.32 182.78,58.45 182.78,59.38 182.91,59.5 183.2,59.5 183.32,59.63 183.32,60.66 183.45,60.78 183.86,60.78 183.98,60.66 RZ30.1
  IN2 w0.086: 171.77,57.2 168.31,57.2 v1(167.37,58.14)
  IN2 w0.122: 171.77,57.2 172.17,57.2 172.3,57.08 172.3,56.82 172.42,56.7 172.66,56.7 172.78,56.82 172.78,57.18 172.91,57.31 173.14,57.31 173.27,57.18 173.27,56.72 173.4,56.59 173.63,56.59 173.76,56.72 173.76,57.13 173.89,57.26 174.15,57.26 174.28,57.13 174.28,56.76 174.4,56.63 175.49,56.63 175.62,56.76 175.62,57 175.49,57.13 175.03,57.13 174.55,57.6 174.55,58.02 174.87,58.34 175.05,58.34 175.43,57.96 175.61,57.96 175.78,58.14 175.78,58.32 175.41,58.7 175.41,58.87 175.57,59.04 175.75,59.04 176.13,58.66 176.3,58.66 176.47,58.83 176.47,59 176.09,59.38 176.09,59.56 176.26,59.73 176.44,59.73 176.82,59.35 176.99,59.35 177.16,59.52 177.16,59.69 176.95,59.9 176.95,60.08 177.13,60.25 177.51,60.25 177.63,60.13 177.63,60.02 177.75,59.89 177.99,59.89 178.11,60.02 178.11,60.13 178.24,60.25 178.48,60.25 178.6,60.13 178.6,59.84 178.73,59.71 178.96,59.71 179.09,59.84 179.09,60.13 179.21,60.25 179.46,60.25 179.58,60.13 179.58,59.74 179.71,59.61 179.94,59.61 180.07,59.74 180.07,60.13 180.19,60.25 180.43,60.25 180.55,60.13 180.55,59.6 180.68,59.47 182.25,59.47 182.37,59.35 v1(182.37,58.99) 182.68,58.99 183.08,59.39 183.17,59.39 185.37,61.58 187.12,61.58 187.89,60.81 193.02,60.81 194.61,62.41 195.31,62.41 196.44,63.54 196.44,65.21 v1(195.83,65.81)
  BOTTOM w0.076: v1(167.37,58.14) 167.03,58.48 UC1.AA4
  BOTTOM w0.102: v1(195.83,65.81) 195.31,66.33 195.31,72.16 v2(200.31,77.16) 202.44,79.29 202.87,79.29 204.2,80.62 204.5,80.62 RC226.2 204.98,81.56 205.22,81.8 205.22,82.65 205.61,83.05 JSPI1.15
PCH_SPI_DO: length 67.9
  TOP w0.102: RZ29.1 183.36,62.3 v1(183.07,62.59)
  IN2 w0.122: v1(172.67,57.65) 172.67,57.71 173.03,58.07 173.03,58.24 172.62,58.65 172.62,58.82 172.79,58.99 172.97,58.99 173.62,58.34 173.8,58.34 173.96,58.5 173.96,58.68 173.31,59.34 173.31,59.51 173.48,59.68 173.66,59.68 174.49,58.85 174.67,58.85 174.84,59.01 174.84,59.19 174,60.03 174,60.2 174.17,60.37 174.35,60.37 175.18,59.53 175.36,59.53 175.56,59.73 175.56,59.91 175.18,60.29 175.18,60.47 175.34,60.64 175.52,60.64 175.89,60.27 176.09,60.27 176.55,60.72 176.55,61.97 176.67,62.09 176.91,62.09 177.03,61.97 177.03,61.22 177.51,60.75 182.47,60.75 183.45,61.73 183.45,62.21 v1(183.07,62.59) 183.52,63.03 184.61,63.03 185.44,63.86 185.78,63.86 186.24,63.4 193.84,63.4 194.09,63.66 194.19,63.66 195.17,64.65 v1(195.17,65.2)
  BOTTOM w0.076: 171.76,58.52 170.09,58.52 169.73,58.16 169.37,58.16 169.32,58.21 168.87,58.21 168.57,58.52 UC1.AA2
  BOTTOM w0.102: v1(195.17,65.2) 194.68,65.7 194.68,67.32 193.78,68.22 193.78,70.73 194.25,71.2 v2(194.25,71.57) 194.25,72.02 199.42,77.19 199.42,77.96 201.42,79.96 202.64,79.96 203.23,80.55 203.23,81.17 RC225.2 204.61,82.55 JSPI1.17 ; v1(172.67,57.65) 172.67,57.95 172.26,58.36 171.92,58.36 171.76,58.52
PCH_SPI_DO2: length 58.2
  IN2 w0.086: v1(165.47,59.58) 165.89,60 167.17,60 167.19,60.02 168.01,60.02 168.74,60.75 168.74,61.63 169.21,62.09 171.77,62.09
  IN2 w0.122: v1(198.23,70.32) 197.74,70.82 193.41,70.82 192.58,69.99 187.65,69.99 187.03,69.38 183.56,69.38 180.54,66.35 175.55,66.35 175.03,65.84 175.03,65.15 174.98,65.1 174.98,64.54 173.39,62.96 173.18,62.96 172.31,62.09 171.77,62.09
  BOTTOM w0.076: UC1.Y6 165.47,59.36 v1(165.47,59.58)
  BOTTOM w0.102: v1(198.23,70.32) 198.23,71.11 203.24,76.11 203.56,76.11 207.49,80.05 207.95,80.05 208.78,80.88 208.78,81.63 RC229.2 209.22,82.37 208.61,82.98 JSPI1.9
PCH_SPI_DO3: length 62.1
  IN2 w0.086: 172.84,55.67 170.62,55.67 v1(170.08,56.2)
  IN2 w0.122: 172.84,55.67 175.29,55.67 175.87,56.25 175.87,57.87 177.64,59.64 178.44,59.64 178.73,59.36 179.98,59.36 180.85,58.49 183.36,58.49 185.39,60.52 193.08,60.52 194.72,62.16 195.41,62.16 196.86,63.61 196.86,63.87 v1(197.21,64.21)
  BOTTOM w0.076: UC1.AF1 170,56.27 170.07,56.2 v1(170.08,56.2)
  BOTTOM w0.102: v1(197.21,64.21) 196.46,64.96 196.46,66.78 196.89,67.21 198.56,67.21 198.87,67.52 198.87,71.1 202.74,74.97 203.12,74.97 v2(203.38,75.23) 207.73,79.58 208.18,79.58 209.03,80.43 210.02,80.43 210.38,80.79 RC230.2 210.38,81.13 210.01,81.5 210.01,82.74 209.61,83.14 JSPI1.7
PCI_CLK_LPC_0: length 13.3
  TOP w0.076: v1(160.35,51.58) 160.35,51.56 160.82,51.09 160.82,49.19 161.79,48.22 161.79,45.25 v2(163.22,43.82) 163.75,43.28 RC74.1 RC72.1
  BOTTOM w0.076: UC1.AN15 160.61,51.83 v1(160.35,51.58)
PCI_CLK_LPC_1: length 11.9
  TOP w0.076: v1(160.35,50.9) 160.36,50.9 160.64,50.62 160.64,49.67 160.29,49.32 160.29,47.95 160.83,47.4 160.83,44.83 161.12,44.54 v2(161.12,42.32) RC67.1 RC70.1
  BOTTOM w0.076: v1(160.35,50.9) 160.63,51.18 UC1.AP15
PCIE_PRX_GLANTX_N3: length 134.5
  TOP w0.102: v1(280.51,92.73) 280.69,92.54 280.69,92.46 CL2.2
  IN1 w0.086: 170.53,73.22 170.52,73.2 170.52,73.2 170.48,73.17 170.48,73.16 168.75,71.43 164.46,71.43 162.41,69.38 162.41,66.86 162.55,66.71 v1(163.04,66.71)
  IN1 w0.089: v1(280.51,92.73) 280.73,92.51 280.73,92.02 279.79,91.09 268.06,91.09 265.68,88.71 251.88,88.71 251.4,88.23 248.92,88.23 248.26,87.57 243.75,87.57 243.24,87.06 237.46,87.06 234.81,84.41 233.2,84.41 232.9,84.11 230.29,84.11 221.13,84.11 220.71,84.53 200.18,84.53 197.32,81.68 182.19,81.68 180.96,80.44 176.48,80.44 174.6,78.55 174.6,77.28 170.89,73.57 170.89,73.57 170.65,73.33 170.53,73.22
  BOTTOM w0.076: UC1.G11 162.61,66.32 163,66.71 v1(163.04,66.71)
PCIE_PRX_GLANTX_N3_C: length 2.5
  TOP w0.102: CL2.1 280.59,90.66 280.59,90.58 280.17,90.16 280.17,89.68 280.08,89.58 UL1.39
PCIE_PRX_GLANTX_P3: length 134.5
  TOP w0.102: v1(281.09,92.73) 280.9,92.54 280.9,92.28 CL1.2
  IN1 w0.086: v1(163.02,67.43) 163.03,67.41 163.03,67.19 162.89,67.05 162.85,67.05 162.69,66.88 162.62,66.88 162.58,66.92 162.58,69.31 164.53,71.26 168.82,71.26 170.63,73.08 170.65,73.1
  IN1 w0.089: v1(281.09,92.73) 280.9,92.54 280.9,91.95 279.86,90.92 268.13,90.92 265.76,88.54 251.95,88.54 251.47,88.06 248.99,88.06 248.33,87.4 247.28,87.4 243.82,87.4 243.31,86.89 243.17,86.89 237.54,86.89 234.88,84.24 234.74,84.24 233.27,84.24 232.97,83.94 230.36,83.94 221.06,83.94 220.64,84.36 200.25,84.36 197.39,81.51 182.27,81.51 181.03,80.27 176.56,80.27 174.77,78.48 174.77,77.21 170.96,73.4 170.96,73.4 170.77,73.21 170.65,73.1
  BOTTOM w0.076: v1(163.02,67.43) 162.57,66.98 UC1.F11
PCIE_PRX_GLANTX_P3_C: length 2.5
  TOP w0.102: CL1.1 280.8,90.63 280.8,90.49 280.38,90.08 280.38,89.66 280.48,89.57 UL1.38
PCIE_PRX_MMITX_N1: length 195.1
  TOP w0.102: v1(300.47,63.4) 300.81,63.06 CR27.1
  IN4 w0.086: 153.16,73.2 153.14,73.2 153.14,73.2 153.09,73.2 152.99,73.1 152.99,73.1 151.96,72.07 151.96,70.16 152.66,69.47 156.58,69.47 157.7,68.35 158.46,68.35 158.66,68.15 158.66,66.83 158.8,66.69 159.14,66.69 v1(159.26,66.58)
  IN4 w0.089: 153.16,73.2 155.48,73.2 156.53,74.25 159.92,74.25 160.39,73.78 165.01,73.78 165.03,73.76 167.45,73.76 169.21,73.76 171.48,76.03 171.48,77.73 176.46,82.71 177.22,82.71 179.56,85.05 188.13,85.05 191.34,88.25 193.61,88.25 195.26,89.9 196.41,89.9 198.25,91.73 226.49,91.73 228.18,90.05 241.82,90.05 242.93,88.93 247.81,88.93 248.86,89.98 250.71,89.98 252.34,91.61 269.43,91.61 269.92,91.13 272.18,91.13 274.79,88.52 274.79,87.25 279.59,82.45 279.59,80.5 281.34,78.74 281.34,77.69 282.92,76.11 282.92,68.01 285,65.93 290.12,65.93 293.57,62.48 300.75,62.48 301.26,62.98 301.26,63.55 301,63.8 300.87,63.8 v1(300.47,63.4)
  BOTTOM w0.076: v1(159.26,66.58) 159.52,66.58 159.71,66.39 UC1.G17
PCIE_PRX_MMITX_N1_C: length 5.6
  TOP w0.102: UR1.8 306.11,63.22 305.98,63.35 305.32,63.35 304.31,64.36 303.53,64.36 v3(303.25,64.08) 302.65,63.48 302.42,63.48 CR27.2
PCIE_PRX_MMITX_P1: length 195.1
  TOP w0.102: CR26.1 300.56,64.07 v1(300.47,63.99)
  IN4 w0.086: v1(159.27,67.34) 159.27,67.18 158.94,66.86 158.87,66.86 158.83,66.9 158.83,68.22 158.53,68.52 157.77,68.52 156.65,69.64 152.73,69.64 152.13,70.23 152.13,72 153.16,73.03
  IN4 w0.089: 153.16,73.03 155.55,73.03 156.6,74.08 159.85,74.08 160.32,73.61 164.94,73.61 164.96,73.59 167.38,73.59 167.38,73.59 168.58,73.59 169.28,73.59 171.65,75.96 171.65,77.66 176.53,82.54 177.29,82.54 179.63,84.88 188.2,84.88 191.41,88.08 193.68,88.08 195.33,89.73 196.48,89.73 198.32,91.56 226.42,91.56 228.11,89.88 241.75,89.88 242.86,88.76 247.88,88.76 248.93,89.81 250.78,89.81 252.41,91.44 269.36,91.44 269.85,90.96 272.11,90.96 274.62,88.45 274.62,87.18 279.42,82.38 279.42,80.42 281.17,78.67 281.17,77.62 282.75,76.04 282.75,67.94 284.93,65.76 290.05,65.76 293.5,62.31 300.82,62.31 301.43,62.91 301.43,63.62 301.06,63.99 v1(300.47,63.99)
  BOTTOM w0.076: v1(159.27,67.34) 159.65,66.97 UC1.F17
PCIE_PRX_MMITX_P1_C: length 5.7
  TOP w0.102: CR26.2 301.99,63.86 302.16,63.69 302.56,63.69 302.89,64.02 302.89,64.05 303.28,64.44 303.31,64.44 303.44,64.57 304.39,64.57 305.4,63.56 306.05,63.56 306.11,63.62 UR1.7
PCIE_PRX_SATATX_N6_L0: length 142
  IN1 w0.086: 170.65,70.19 170.63,70.19 170.63,70.19 170.58,70.19 170.58,70.18 168.06,70.18 167.02,69.14 166,69.14 165.28,68.42 165.28,66.98 165.52,66.74 165.87,66.74 v1(165.95,66.66)
  IN1 w0.089: v1(290.34,94.19) 290.12,93.97 289.46,93.97 288.96,93.47 288.96,91.26 287.11,89.41 272.3,89.41 270.9,88.01 266,88.01 265.43,87.44 249.04,87.44 248.02,86.43 243.51,86.43 243.51,86.42 242.98,86.42 237.94,86.42 234.96,83.43 220.47,83.43 220.08,83.82 200.9,83.82 197.7,80.62 182.21,80.62 178.16,76.58 177.42,76.58 171.04,70.19 170.65,70.19
  BOTTOM w0.076: v1(165.95,66.66) 165.95,66.7 166.21,66.97 UC1.F5
  BOTTOM w0.102: v1(290.34,94.19) 290.55,93.98 290.97,93.98 291.08,94.1 JNGFF2.35
PCIE_PRX_SATATX_N6_L1: length 141.1
  IN1 w0.086: v1(164.96,65.26) 164.96,65.49 165.03,65.56 165.35,65.56 165.37,65.54 165.46,65.45 165.46,65.08 165.76,64.77 166.33,64.77 166.78,65.22 166.78,65.99 167.22,66.42 167.71,66.42 170.57,69.28 170.65,69.28
  IN1 w0.089: 170.65,69.28 171.28,69.28 177.39,75.38 178.48,75.38 182.79,79.69 199.63,79.69 201.22,81.28 203.8,81.28 204.16,81.64 209.29,81.64 209.81,82.15 214.62,82.15 215.08,82.61 230.85,82.61 231.7,81.77 235.35,81.77 235.35,81.76 235.5,81.76 239.22,85.49 253.46,85.49 253.91,85.94 253.91,86.13 254.41,86.63 265.71,86.63 265.91,86.43 269.72,86.43 270.4,87.11 271.36,87.11 272.79,88.54 280.75,88.54 281.1,88.19 287.04,88.19 289.62,90.78 290.14,90.78 v1(290.36,90.56)
  BOTTOM w0.076: v1(164.96,65.26) 165.2,65.01 UC1.J6
  BOTTOM w0.102: v1(290.36,90.56) 290.54,90.75 290.94,90.75 291.08,90.6 JNGFF2.21
PCIE_PRX_SATATX_P6_L0: length 141.9
  IN1 w0.086: 170.65,70.02 168.13,70.02 167.09,68.98 166.07,68.98 165.98,68.89 165.98,68.67 165.78,68.47 165.56,68.47 165.44,68.35 165.44,67.86 165.62,67.68 165.62,67.48 165.44,67.3 165.44,67.05 165.59,66.91 165.66,66.91 165.95,67.2 v1(165.95,67.27)
  IN1 w0.089: v1(290.34,93.61) 290.34,93.63 290.17,93.8 289.53,93.8 289.13,93.4 289.13,91.19 287.18,89.24 272.37,89.24 270.97,87.84 266.07,87.84 265.5,87.27 249.11,87.27 248.1,86.26 243.58,86.26 243.58,86.25 242.91,86.25 242.91,86.25 238.01,86.25 235.03,83.26 220.4,83.26 220.01,83.65 200.97,83.65 197.77,80.45 182.28,80.45 178.23,76.41 177.5,76.41 171.11,70.02 170.65,70.02
  BOTTOM w0.076: v1(165.95,67.27) 166.29,67.62 UC1.E5
  BOTTOM w0.102: v1(290.34,93.61) 290.51,93.77 290.91,93.77 291.08,93.6 JNGFF2.33
PCIE_PRX_SATATX_P6_L1: length 141.1
  IN1 w0.086: v1(165,66.03) 165,65.85 165.11,65.73 165.42,65.73 165.44,65.7 165.62,65.52 165.62,65.15 165.83,64.94 166.26,64.94 166.61,65.29 166.61,66.06 167.15,66.59 167.64,66.59 170.5,69.45 170.58,69.45 170.58,69.45 170.63,69.45 170.63,69.45 170.65,69.45
  IN1 w0.089: 170.65,69.45 171.21,69.45 177.32,75.55 178.41,75.55 182.72,79.86 199.56,79.86 201.15,81.45 203.73,81.45 204.09,81.81 209.22,81.81 209.74,82.32 214.55,82.32 215.01,82.78 230.92,82.78 231.77,81.94 235.42,81.94 239.15,85.66 253.39,85.66 253.74,86.01 253.74,86.2 254.34,86.8 265.78,86.8 265.98,86.6 269.64,86.6 270.33,87.28 271.29,87.28 272.72,88.71 280.82,88.71 281.17,88.36 286.97,88.36 289.55,90.95 290.16,90.95 v1(290.36,91.14)
  BOTTOM w0.076: v1(165,66.03) 165.36,65.66 UC1.H6
  BOTTOM w0.102: v1(290.36,91.14) 290.54,90.95 290.94,90.95 291.08,91.1 JNGFF2.23
PCIE_PRX_WIGIGTX_N5: length 174.6
  IN4 w0.086: 170.65,70.3 170.63,70.3 170.63,70.3 170.58,70.3 170.58,70.29 169.99,70.29 169.85,70.16 165.41,70.16 163.39,68.13 163.39,67.03 163.63,66.79 163.82,66.79 v1(164,66.6)
  IN4 w0.089: v1(283.26,43.68) 283.12,43.82 283.12,44.15 282.94,44.33 282.19,44.33 281.82,43.95 281.82,42.95 280.76,41.89 278.29,41.89 277.79,42.39 277.79,45.58 278.23,46.02 278.23,50.84 278.36,50.97 278.36,67.94 271.26,75.05 266.53,75.05 264.76,76.82 264.51,76.82 263.86,77.47 263.86,78.61 261.94,80.53 261.8,80.53 260.75,81.58 260.64,81.58 259.91,82.31 259.91,83.21 258.3,84.82 249.38,84.82 249.08,85.12 248.74,85.12 248.38,85.48 244.99,85.48 244.51,85.96 235.86,85.96 235.86,85.96 235.4,85.96 235.4,85.96 234.55,85.96 234.04,86.47 227.25,86.47 222.07,86.47 220.6,87.94 198.67,87.94 192.51,81.77 192.5,81.77 192.42,81.69 183.06,81.69 179.52,78.15 179.02,78.15 171.17,70.3 170.65,70.3
  BOTTOM w0.076: v1(164,66.6) 163.64,66.97 UC1.F10
  BOTTOM w0.102: v1(283.26,43.68) 283.03,43.45 283.03,43.27 283.09,43.22 284.54,43.22 284.56,43.24 285.8,43.24 286.2,42.83 286.2,42.82 286.2,41.95 286.35,41.81 JNGFF1.59
PCIE_PRX_WIGIGTX_P5: length 174.6
  IN4 w0.086: 170.65,70.13 170.06,70.13 169.92,69.99 165.48,69.99 163.55,68.06 163.55,67.1 163.69,66.97 164.01,66.97 164.12,67.08 164.12,67.25 v1(163.99,67.38)
  IN4 w0.089: v1(282.46,43.6) 282.47,43.59 282.69,43.59 282.85,43.75 282.85,43.86 282.95,43.95 282.95,44.08 282.87,44.16 282.26,44.16 281.99,43.88 281.99,42.88 280.84,41.72 278.22,41.72 277.62,42.32 277.62,45.65 278.06,46.09 278.06,50.91 278.19,51.04 278.19,67.87 271.19,74.88 266.46,74.88 264.69,76.65 264.44,76.65 263.69,77.4 263.69,78.54 261.87,80.36 261.73,80.36 260.68,81.41 260.56,81.41 259.74,82.24 259.74,83.14 258.23,84.65 249.31,84.65 249.01,84.95 248.67,84.95 248.31,85.31 244.92,85.31 244.44,85.79 235.93,85.79 234.62,85.79 234.48,85.79 233.97,86.3 227.32,86.3 222,86.3 220.53,87.77 198.75,87.77 192.58,81.6 192.57,81.6 192.49,81.52 183.13,81.52 179.59,77.98 179.09,77.98 171.24,70.13 170.65,70.13
  BOTTOM w0.076: v1(163.99,67.38) 163.66,67.38 163.52,67.52 UC1.E10
  BOTTOM w0.102: JNGFF1.57 285.85,41.81 286,41.95 286,42.74 285.71,43.03 284.65,43.03 284.63,43.01 283,43.01 282.82,43.19 282.82,43.42 282.64,43.6 v1(282.46,43.6)
PCIE_PRX_WLANTX_N4: length 169
  IN4 w0.086: 170.65,71.9 169.43,70.68 164.09,70.68 161.63,68.22 161.63,67.14 161.79,66.98 161.96,66.98 162.09,67.11 162.09,67.35 v1(162.05,67.39)
  IN4 w0.089: 170.65,71.9 170.72,71.97 171.13,71.97 173.72,74.57 173.72,75.92 176.02,78.22 178.08,78.22 179.58,79.72 180.3,79.72 182.82,82.24 192.04,82.24 192.11,82.24 192.31,82.24 198.56,88.49 220.8,88.49 221.94,87.35 222.08,87.35 222.08,87.35 233.51,87.35 233.9,86.96 235.07,86.96 235.6,86.43 244.71,86.43 244.78,86.43 244.91,86.3 248.22,86.3 248.93,85.59 249.34,85.59 249.59,85.33 258.74,85.33 262.39,81.68 262.39,81.29 264.7,78.98 264.7,77.78 266.1,76.39 269.13,76.39 269.87,75.64 271.36,75.64 278.89,68.11 278.89,57.64 280.39,56.14 280.39,50.49 280.72,50.16 280.72,48.65 280.29,48.21 280.29,46.95 279.34,46.01 279.34,43.6 279.73,43.22 280.13,43.22 280.34,43.42 280.34,43.58 v1(280.56,43.8)
  BOTTOM w0.076: UC1.F13 161.63,66.97 162.05,67.38 v1(162.05,67.39)
  BOTTOM w0.102: JNGFF1.35 280.35,41.81 280.19,41.97 280.19,42.42 280.39,42.63 280.39,43.61 280.56,43.78 v1(280.56,43.8)
PCIE_PRX_WLANTX_P4: length 169
  IN4 w0.086: 170.65,72.14 170.65,72.14 170.48,71.97 170.48,71.97 169.36,70.85 164.02,70.85 161.47,68.29 161.47,67.07 161.72,66.81 161.89,66.81 v1(162.09,66.61)
  IN4 w0.089: 170.65,72.14 171.06,72.14 173.55,74.64 173.55,75.99 175.95,78.39 178.01,78.39 179.51,79.89 180.23,79.89 182.75,82.41 191.96,82.41 191.96,82.41 192.18,82.41 192.18,82.41 192.24,82.41 198.49,88.66 220.87,88.66 222.01,87.52 233.58,87.52 233.97,87.13 234.99,87.13 235,87.13 235.14,87.13 235.67,86.6 244.64,86.6 244.64,86.6 244.85,86.6 244.98,86.47 248.29,86.47 249,85.76 249.41,85.76 249.66,85.5 258.81,85.5 262.56,81.75 262.56,81.36 264.87,79.05 264.87,77.85 266.17,76.56 269.2,76.56 269.94,75.81 271.43,75.81 279.06,68.19 279.06,57.71 280.56,56.21 280.56,50.56 280.89,50.23 280.89,48.57 280.46,48.14 280.46,46.88 279.51,45.94 279.51,43.67 279.8,43.39 280.06,43.39 280.17,43.49 280.17,43.6 v1(279.97,43.8)
  BOTTOM w0.076: v1(162.09,66.61) 161.79,66.32 UC1.G13
  BOTTOM w0.102: v1(279.97,43.8) 280.19,43.58 280.19,42.71 279.98,42.51 279.98,41.94 279.85,41.81 JNGFF1.33
PCIE_PTX_GLANRX_N3: length 146.5
  TOP w0.102: CL6.1 278.54,92.34 278.54,92.45 278.44,92.55 278.44,92.73 v1(278.26,92.91)
  IN4 w0.086: v1(151.6,71.26) 151.43,71.44 151.19,71.44 151.01,71.61 151.01,72.34 151.05,72.37 151.05,73.32 151.05,73.32 151.05,73.37 151.05,73.37 151.05,73.39
  IN4 w0.089: v1(278.26,92.91) 278.26,92.43 278.12,92.3 277.74,92.3 277.34,92.7 267.68,92.7 267.29,92.31 251.85,92.31 250.27,90.74 248.7,90.74 247.55,89.59 243.24,89.59 242.09,90.74 229.03,90.74 227.36,92.41 197.98,92.41 196.25,90.68 194.39,90.68 192.76,89.05 189.46,89.05 186.13,85.71 179.31,85.71 176.98,83.38 176.18,83.38 170.51,77.71 170.51,76.83 170.21,76.54 170.21,75.68 168.94,74.4 168.24,74.4 165.43,74.4 165.41,74.42 165.27,74.42 160.76,74.42 160.19,74.99 152.37,74.99 151.05,73.67 151.05,73.39
  BOTTOM w0.076: UC1.C29 151.54,68.93 151.49,68.99 151.49,69.42 151.47,69.43 151.47,70.68 151.35,70.79 151.35,71.19 151.43,71.26 v1(151.6,71.26)
PCIE_PTX_GLANRX_N3_C: length 2.5
  TOP w0.102: CL6.2 278.23,91.05 278.93,90.35 278.93,89.55 278.88,89.5 UL1.42
PCIE_PTX_GLANRX_P3: length 146.6
  TOP w0.102: v1(278.84,92.91) 278.65,92.73 278.65,92.64 278.75,92.54 278.75,92.4 CL5.1
  IN4 w0.086: 151.22,73.39 151.22,72.31 151.18,72.27 151.18,71.68 151.26,71.61 151.48,71.61 151.6,71.72 v1(151.6,71.85)
  IN4 w0.089: v1(278.84,92.91) 278.82,92.91 278.43,92.52 278.43,92.36 278.19,92.13 277.67,92.13 277.27,92.53 267.75,92.53 267.36,92.14 251.92,92.14 250.34,90.57 248.77,90.57 247.62,89.42 243.17,89.42 242.02,90.57 228.96,90.57 227.28,92.24 198.05,92.24 196.32,90.51 194.46,90.51 192.83,88.88 189.53,88.88 186.2,85.54 179.38,85.54 177.05,83.21 176.25,83.21 170.68,77.64 170.68,76.76 170.38,76.47 170.38,75.61 169.01,74.23 168.31,74.23 165.36,74.23 165.34,74.25 160.69,74.25 160.12,74.82 152.44,74.82 151.22,73.6 151.22,73.39
  BOTTOM w0.076: v1(151.6,71.85) 151.17,71.42 151.17,70.72 151.28,70.6 151.28,69.34 UC1.B30
PCIE_PTX_GLANRX_P3_C: length 2.5
  TOP w0.102: CL5.2 279.11,91.05 278.87,90.81 278.87,90.71 279.14,90.44 279.14,89.58 279.28,89.45 UL1.41
PCIE_PTX_MMIRX_N1: length 198.5
  TOP w0.102: v1(300.42,65.9) 300.62,66.11 CR25.1
  IN4 w0.089: v1(149.85,72.01) 149.85,72.19 150,72.34 150.15,72.34 150.58,72.77 150.58,74.44 150.75,74.61 150.75,75.01 152.15,76.41 164.12,76.41 165.66,74.87 167.91,74.87 168.05,74.87 168.71,75.53 168.71,75.67 168.71,75.67 168.71,76.28 169.11,76.69 169.23,76.69 169.93,77.38 169.93,77.87 176.05,83.99 176.87,83.99 179.17,86.28 185.38,86.28 189.33,90.23 193.26,90.23 194.25,91.22 196.11,91.22 197.81,92.92 227.88,92.92 229.51,91.29 242.65,91.29 243.73,90.21 247.5,90.21 250.14,92.85 253.75,92.85 254.5,93.6 255.62,93.6 256.31,92.9 266.27,92.9 266.94,93.57 266.95,93.57 267.48,94.1 278.02,94.1 278.67,93.46 279.23,93.46 279.39,93.29 279.39,91.63 279,91.23 279,87.43 279.43,87 279.43,85.46 280.3,84.59 280.3,82.22 280.65,81.87 280.65,80.59 281.91,79.33 281.91,77.87 283.4,76.39 283.4,68.41 285.37,66.44 295.31,66.44 296.58,65.17 297.71,65.17 298.89,66.36 300.88,66.36 301.18,66.06 301.18,65.76 300.93,65.51 300.81,65.51 v1(300.42,65.9)
  BOTTOM w0.076: UC1.C30 151.2,68.78 150.76,69.23 150.58,69.23 150.42,69.39 150.37,69.45 150.34,69.56 150.34,69.61 150.39,69.75 150.42,69.82 150.42,69.99 150.4,70.07 150.38,70.12 150.34,70.21 150.34,70.43 149.88,70.89 149.88,71.31 149.49,71.7 149.49,71.98 149.57,72.06 149.8,72.06 v1(149.85,72.01)
PCIE_PTX_MMIRX_N1_C: length 5.5
  TOP w0.102: UR1.5 306.02,64.42 305.87,64.27 305.62,64.27 v3(304.97,64.92) 304.27,65.62 303.73,65.62 303.71,65.64 303.15,65.64 303.13,65.62 302.48,65.62 CR25.2
PCIE_PTX_MMIRX_P1: length 198.5
  TOP w0.102: v1(300.42,65.32) 300.65,65.09 CR24.1
  IN4 w0.089: v1(300.42,65.32) 300.44,65.34 301,65.34 301.35,65.69 301.35,66.13 300.95,66.53 298.82,66.53 297.64,65.34 296.65,65.34 295.38,66.61 285.44,66.61 283.57,68.48 283.57,76.46 282.08,77.94 282.08,79.4 280.82,80.66 280.82,81.94 280.47,82.29 280.47,84.66 279.6,85.53 279.6,87.07 279.17,87.51 279.17,91.16 279.57,91.56 279.57,93.36 279.3,93.63 278.74,93.63 278.09,94.27 267.41,94.27 266.88,93.74 266.87,93.74 266.2,93.07 256.38,93.07 255.69,93.77 254.43,93.77 253.68,93.02 250.07,93.02 247.43,90.38 243.8,90.38 242.72,91.46 229.59,91.46 227.95,93.09 197.74,93.09 196.04,91.39 194.18,91.39 193.19,90.4 189.25,90.4 185.31,86.45 179.1,86.45 176.8,84.16 175.98,84.16 169.76,77.94 169.76,77.45 169.16,76.86 169.04,76.86 168.54,76.35 168.54,75.6 167.98,75.04 165.73,75.04 164.19,76.58 164.05,76.58 152.08,76.58 150.58,75.08 150.58,74.68 150.41,74.51 150.41,72.84 150.24,72.67 v1(149.85,72.67)
  BOTTOM w0.076: UC1.C31 150.62,68.93 150.28,69.27 150.22,69.36 150.21,69.36 150.2,69.4 150.15,69.58 150.15,69.62 150.22,69.81 150.24,69.85 150.24,69.96 150.22,70.01 150.2,70.06 150.18,70.13 150.15,70.15 150.15,70.36 149.7,70.81 149.7,71.23 149.3,71.63 149.3,72.12 v1(149.85,72.67)
PCIE_PTX_MMIRX_P1_C: length 5.4
  TOP w0.102: CR24.2 302.32,65.42 v3(303.43,65.42) 304.18,65.42 304.61,64.99 304.61,64.96 305,64.57 305.03,64.57 305.53,64.06 305.97,64.06 306.02,64.02 UR1.6
PCIE_PTX_SATARX_N6_L0: length 146.9
  TOP w0.102: CZ58.1 287.87,95.32 287.46,95.32 v1(287.17,95.02)
  IN1 w0.086: 160.32,69.73 160.34,69.75 160.37,69.78 160.37,69.92 160.37,69.93 160.37,72.45 161,73.08 162.36,73.08 162.51,73.22 162.51,73.22 162.54,73.26 162.56,73.27
  IN1 w0.089: 162.56,73.27 162.8,73.52 164.4,73.52 165.21,74.33 169.78,74.33 171.94,76.49 171.94,77.64 177.8,83.51 197,83.51 200.65,87.16 222.18,87.16 224.12,85.22 226.23,85.22 230.65,89.63 236.21,89.63 237.06,88.78 247.88,88.78 247.89,88.79 247.91,88.79 248.68,89.56 249.49,89.56 249.78,89.84 251.22,89.84 252.49,91.11 265.71,91.11 268.97,94.37 285.35,94.37 285.85,94.87 286,94.87 286.24,95.1 286.24,95.26 286.39,95.41 286.78,95.41 v1(287.17,95.02) ; 160.32,69.73 160.04,69.45 160.04,68.99 160.34,68.68 160.45,68.68 160.57,68.8 160.57,69.09 v1(160.55,69.1)
  BOTTOM w0.076: v1(160.55,69.1) 160.19,68.73 159.92,68.73 159.62,69.04 UC1.C17
PCIE_PTX_SATARX_N6_L0_C: length 3.4
  TOP w0.102: CZ58.2 289.36,95.38 289.53,95.38 289.8,95.11 v1(289.81,95.11)
  BOTTOM w0.102: JNGFF2.39 291.28,95.1 291.08,95.3 290.75,95.3 290.68,95.23 289.92,95.23 v1(289.81,95.11)
PCIE_PTX_SATARX_N6_L1: length 142.4
  TOP w0.102: v1(287.34,91.99) 287.51,92.16 287.9,92.16 287.97,92.09 CZ32.1
  IN1 w0.086: 161.87,71.38 160.8,71.38 v1(160.79,71.38)
  IN1 w0.089: v1(287.34,91.99) 287.34,92.01 286.94,92.4 285.11,92.4 284,93.51 282.25,93.51 282.13,93.39 280.45,93.39 279.34,92.27 267.99,92.27 266.08,90.35 255.63,90.35 255.04,89.76 252.26,89.76 251.2,88.7 248.73,88.7 248.16,88.14 237.79,88.14 234.58,84.93 233.03,84.93 232.68,84.58 223.77,84.58 223.23,85.11 199.79,85.11 197.42,82.74 177.95,82.74 174.12,78.91 174.12,77.68 170.12,73.68 165.48,73.68 164.69,72.9 163.4,72.9 161.87,71.38
  BOTTOM w0.076: UC1.B14 160.56,69.46 160.31,69.46 160.2,69.57 160.2,69.67 160.57,70.04 160.57,70.53 160.56,70.54 160.31,70.78 160.31,71.73 160.4,71.82 160.51,71.82 160.79,71.53 v1(160.79,71.38)
PCIE_PTX_SATARX_N6_L1_C: length 3.5
  TOP w0.102: CZ32.2 289.29,92.16 289.65,92.16 v1(289.84,91.98)
  BOTTOM w0.102: v1(289.84,91.98) 290.09,92.23 291.04,92.23 291.17,92.1 JNGFF2.27
PCIE_PTX_SATARX_P6_L0: length 146.9
  TOP w0.102: CZ59.1 287.66,95.61 v1(287.17,95.61)
  IN1 w0.086: 162.44,73.39 162.42,73.38 162.29,73.25 160.93,73.25 160.2,72.52 160.2,69.86
  IN1 w0.089: 160.2,69.86 159.87,69.52 159.87,68.92 160.17,68.61 v1(160.17,68.11) ; v1(287.17,95.61) 286.35,95.61 285.28,94.54 268.9,94.54 265.64,91.28 252.42,91.28 251.15,90.02 249.71,90.02 249.42,89.73 248.61,89.73 247.83,88.95 237.13,88.95 236.28,89.8 230.58,89.8 226.16,85.39 224.19,85.39 222.25,87.33 200.58,87.33 196.93,83.68 177.73,83.68 171.77,77.71 171.77,76.56 169.71,74.5 165.14,74.5 164.33,73.69 162.73,73.69 162.44,73.39
  BOTTOM w0.076: v1(160.17,68.11) 160.01,67.95 159.5,67.95 159.36,68.09 159.36,68.3 159.51,68.45 UC1.D17
PCIE_PTX_SATARX_P6_L0_C: length 3.4
  TOP w0.102: v1(289.81,95.69) 289.73,95.62 289.41,95.62 289.04,95.99 CZ59.2
  BOTTOM w0.102: v1(289.81,95.69) 290.06,95.44 290.6,95.44 290.66,95.51 291.11,95.51 291.2,95.6 JNGFF2.41
PCIE_PTX_SATARX_P6_L1: length 142.4
  TOP w0.102: v1(287.34,92.57) 287.54,92.37 287.85,92.37 287.97,92.5 CZ33.1
  IN1 w0.086: v1(160.79,72.03) 161.28,71.54 161.8,71.54 162.01,71.75
  IN1 w0.089: 162.01,71.75 163.33,73.07 164.62,73.07 165.41,73.85 170.05,73.85 173.95,77.75 173.95,78.98 177.88,82.91 197.35,82.91 199.72,85.28 223.3,85.28 223.84,84.75 232.61,84.75 232.96,85.1 234.51,85.1 237.72,88.31 248.09,88.31 248.66,88.87 251.13,88.87 252.19,89.93 254.97,89.93 255.56,90.52 266.01,90.52 267.92,92.44 279.27,92.44 280.38,93.56 282.06,93.56 282.18,93.68 284.07,93.68 285.18,92.57 v1(287.34,92.57)
  BOTTOM w0.076: UC1.C15 160.05,69.45 160.01,69.48 160.01,69.75 160.38,70.11 160.38,70.45 160.13,70.71 160.13,71.8 160.32,72 160.76,72 v1(160.79,72.03)
PCIE_PTX_SATARX_P6_L1_C: length 3.5
  TOP w0.102: v1(289.84,92.56) 289.65,92.37 289.29,92.37 CZ33.2
  BOTTOM w0.102: v1(289.84,92.56) 289.96,92.44 291.08,92.44 291.24,92.6 JNGFF2.29
PCIE_PTX_WIGIGRX_N5: length 164.8
  TOP w0.102: CZ22.1 287.56,52.41 287.56,52.57 v1(287.82,52.83)
  IN4 w0.089: v1(287.82,52.83) 287.74,52.91 287.74,53.28 287.1,53.92 287.1,59.59 283.63,63.06 283.63,65.71 271.44,77.9 268.64,77.9 265.13,81.42 265.13,81.73 259.35,87.5 251.48,87.5 250.75,88.23 237.24,88.23 237.14,88.32 235.98,88.32 235.47,88.84 225.08,88.84 223.43,90.5 198.35,90.5 192.95,85.09 190.96,85.09 190.14,84.28 181.8,84.28 178.8,81.28 176.96,81.28 172.14,76.46 172.14,75.79 169.74,73.38 157.74,73.38 v1(157.72,73.41)
  BOTTOM w0.076: v1(157.72,73.41) 157.72,73.27 157.4,72.95 157.29,72.95 156.81,72.47 156.81,71.15 156.15,70.49 156.15,70.14 155.83,69.81 155.83,69.44 156.01,69.26 156.01,69.15 UC1.C23
PCIE_PTX_WIGIGRX_N5_C: length 11.8
  TOP w0.102: CZ22.2 287.33,50.62 287.33,49.83 287.35,49.81 287.35,49.25 287.33,49.23 v3(287.33,48.16) 287.33,47.12 286.7,46.49 286.7,44.88 284.79,42.97 284.79,42.6 v1(284.96,42.42)
  BOTTOM w0.102: JNGFF1.53 284.85,41.71 284.77,41.79 284.77,42.29 284.9,42.42 v1(284.96,42.42)
PCIE_PTX_WIGIGRX_P5: length 164.8
  TOP w0.102: CZ21.1 287.35,52.57 287.35,52.67 v1(287.19,52.83)
  IN4 w0.089: v1(287.19,52.83) 287.5,53.15 287.5,53.28 286.93,53.85 286.93,59.51 283.46,62.99 283.46,65.64 271.37,77.73 268.57,77.73 264.96,81.35 264.96,81.66 259.28,87.33 251.41,87.33 250.68,88.06 237.17,88.06 237.07,88.15 236.06,88.15 236.05,88.15 235.91,88.15 235.4,88.67 225.15,88.67 225.01,88.67 223.36,90.32 198.42,90.32 193.02,84.92 191.03,84.92 190.22,84.11 181.87,84.11 178.87,81.11 177.03,81.11 172.31,76.39 172.31,75.72 169.81,73.21 158.17,73.21 v1(157.72,72.76)
  BOTTOM w0.076: v1(157.72,72.76) 157.37,72.76 157,72.39 157,71.07 156.34,70.41 156.34,70.06 156.01,69.74 156.01,69.52 156.2,69.33 156.2,68.56 UC1.C22
PCIE_PTX_WIGIGRX_P5_C: length 11.7
  TOP w0.102: v1(284.35,42.38) 284.58,42.61 284.58,43.05 286.49,44.97 286.49,46.58 287.12,47.21 287.12,47.86 287.1,47.88 287.1,48.44 287.12,48.46 v3(287.12,49.53) 287.12,50.92 CZ21.2
  BOTTOM w0.102: JNGFF1.51 284.35,41.66 284.52,41.83 284.52,42.25 284.39,42.38 v1(284.35,42.38)
PCIE_PTX_WLANRX_N4: length 167.5
  IN4 w0.086: 159.97,72.54 159.95,72.54 159.95,72.54 159.9,72.54 159.9,72.54 159.67,72.54 159.54,72.67 158.56,72.67 157.64,71.75 153.07,71.75 v1(152.86,71.54)
  IN4 w0.089: v1(282.56,53.61) 282.38,53.79 282.13,53.79 281.82,54.1 281.82,56.66 280.53,57.95 280.53,67.38 270.85,77.05 266.5,77.05 265.36,78.19 265.36,79.24 263.04,81.57 263.04,82.01 260.04,85.01 260.04,85.56 258.91,86.69 251.05,86.69 250.32,87.42 242.31,87.42 241.97,87.07 236.09,87.07 235.13,88.03 224.51,88.03 222.85,89.68 198.71,89.68 192.39,83.37 182.13,83.37 179.12,80.35 177.18,80.35 172.97,76.14 172.97,75.34 169.01,71.38 162.61,71.38 161.44,72.54 159.97,72.54
  BOTTOM w0.076: UC1.B29 151.76,69.69 152.24,70.17 152.24,71.41 152.4,71.58 152.82,71.58 v1(152.86,71.54)
  BOTTOM w0.102: v1(282.56,53.61) 282.3,53.87 282.06,53.87 281.93,53.74 281.93,52.43 282.02,52.34 CZ14.1
PCIE_PTX_WLANRX_N4_C: length 15.3
  IN4 w0.089: v1(279.06,42.39) 278.88,42.56 278.88,42.81 278.91,42.83 279.2,42.83 279.63,42.4 280.5,42.4 281.35,43.25 281.35,46.74 283.21,48.61 283.21,49.94 282.88,50.27 282.16,50.27 282.01,50.41 282.01,50.59 v1(282.22,50.79)
  BOTTOM w0.102: JNGFF1.29 278.85,41.81 278.78,41.88 278.78,42.11 v1(279.06,42.39) ; CZ14.2 282.02,51.08 282.02,50.99 v1(282.22,50.79)
PCIE_PTX_WLANRX_P4: length 167.5
  IN4 w0.086: 159.97,72.71 159.74,72.71 159.61,72.84 158.49,72.84 157.57,71.92 153.06,71.92 v1(152.86,72.13)
  IN4 w0.089: 159.97,72.71 161.37,72.71 161.51,72.71 162.68,71.55 168.94,71.55 172.8,75.41 172.8,76.21 177.11,80.52 179.04,80.52 182.06,83.54 192.32,83.54 198.64,89.86 222.92,89.86 224.58,88.2 235.21,88.2 236.16,87.24 241.89,87.24 242.24,87.59 250.39,87.59 251.12,86.86 258.98,86.86 260.21,85.63 260.21,85.08 263.21,82.08 263.21,81.64 265.53,79.31 265.53,78.26 266.57,77.22 270.92,77.22 280.7,67.45 280.7,58.02 281.99,56.73 281.99,54.17 282.19,53.96 282.33,53.96 v1(282.56,54.19)
  BOTTOM w0.076: v1(152.86,72.13) 152.86,72.05 152.57,71.76 152.33,71.76 152.05,71.49 152.05,71.46 152.05,71.46 152.05,70.24 151.96,70.14 151.85,70.14 UC1.A29
  BOTTOM w0.102: v1(282.56,54.19) 282.45,54.08 281.97,54.08 281.72,53.82 281.72,52.59 CZ13.1
PCIE_PTX_WLANRX_P4_C: length 15.3
  IN4 w0.089: v1(281.64,50.79) 281.84,50.59 281.84,50.34 282.08,50.1 282.81,50.1 283.04,49.87 283.04,48.68 281.18,46.81 281.18,43.32 280.43,42.57 279.7,42.57 279.27,43 278.84,43 278.71,42.88 278.71,42.63 v1(278.47,42.39)
  BOTTOM w0.102: CZ13.2 281.81,51.08 281.81,50.97 v1(281.64,50.79) ; v1(278.47,42.39) 278.57,42.28 278.57,42.03 278.35,41.81 JNGFF1.27
PCIE_WAKE#: length 116.9
  TOP w0.102: v1(279.95,55.04) 279.46,54.56 277.27,54.56 276.72,55.11 v1(276.72,55.43) ; v1(281.55,93.97) 281.29,94.22 273.41,94.22 272.86,94.77 261.42,94.77 v2(260.54,93.89) RE274.1 RE275.1
  IN2 w0.122: v1(276.72,55.43) 276.62,55.53 276.62,56.43 278.59,58.4 278.59,63.03 280.23,64.66 280.23,68.76 276.07,72.92 276.07,86 277.38,87.32 277.87,87.32 280.1,89.54 280.1,92.12 280,92.22 280,93.03 280.1,93.13 280.1,93.14 280.92,93.97 v1(281.55,93.97)
  IN4 w0.089: v1(276.72,55.43) 277.59,54.56 277.59,48.69 276.45,47.55 276.45,43.34 276.45,43.34 276.45,43 276.45,43 276.45,42.15 277.35,41.25 281.39,41.25 282.97,42.83 283.3,42.83 v1(283.73,42.4)
  BOTTOM w0.102: v1(281.55,93.97) 281.55,96.66 281.73,96.85 JNGFF2.46 ; JNGFF1.62 287.1,49.76 286.14,50.71 286.14,51.48 282.79,54.83 281.94,54.83 281.76,54.65 280.73,54.65 280.34,55.04 v1(279.95,55.04) ; v1(283.73,42.4) 283.73,42.15 283.35,41.77 JNGFF1.47
PCIE_WAKE#_R: length 36.1
  TOP w0.102: RE35.2 250.14,62.8 250.94,63.6 v1(251.1,63.6) ; RE275.2 256.58,89.84 v1(255.97,89.23) ; UE1.B10 v1(253.92,83.37)
  IN2 w0.122: v1(255.97,89.23) 256.62,88.59 257.72,88.59 258.36,87.95 258.36,85.79 257.47,84.9 255.46,84.9 v1(253.92,83.37)
  IN4 w0.089: v1(251.65,72.13) 251.52,72 251.52,69.02 251.99,68.55 251.99,64.81 251.3,64.13 251.3,63.8 v1(251.1,63.6)
  BOTTOM w0.102: 252.18,73.57 253.68,75.07 254.04,75.07 254.24,75.28 254.24,76.13 254.85,76.74 254.85,81.92 253.92,82.85 v1(253.92,83.37) ; 252.18,73.57 v2(252.18,73.55) ; 252.18,73.57 251.65,73.05 251.65,72.74 251.68,72.71 251.68,72.16 v1(251.65,72.13)
PE_REXT: length 3
  TOP w0.102: UR1.4 305.88,64.82 304.34,66.36 RR2.2
PECI_EC: length 193.5
  TOP w0.102: v1(244.69,55.17) 244.84,55.02 RE60.2
  IN2 w0.086: 126.4,58.61 129.69,58.61 130.16,59.08 130.16,61.08 130.69,61.6 v1(130.69,62.68)
  IN2 w0.122: 126.4,58.61 124.35,58.61 123.34,57.61 123.34,52 124.1,51.23 124.1,44.34 119.71,39.94 118.6,39.94 113.42,34.77 113.42,30.64 v1(113.44,30.62)
  BOTTOM w0.076: v1(130.69,62.68) 131.01,63 UC1.N62
  BOTTOM w0.102: v1(113.44,30.62) 113.58,30.76 196.71,30.76 199.12,33.17 206.39,33.17 208.2,31.36 220.88,31.36 221.84,32.32 222.21,32.32 222.53,32.64 225.78,32.64 229.92,36.78 229.92,39.23 232.12,41.43 232.12,43.26 232.87,44.01 232.96,44.01 234.4,45.46 234.49,45.46 234.58,45.54 235.88,45.54 238.32,47.98 238.32,50.46 239.37,51.51 239.37,53.69 241.38,55.69 244.17,55.69 v1(244.69,55.17)
PECI_EC_R: length 10.8
  TOP w0.102: RE60.1 246.99,55.68 247.85,55.68 247.94,55.59 248.14,55.59 248.24,55.69 248.24,56.2 248.36,56.31 248.53,56.31 248.65,56.2 248.65,55.69 248.75,55.59 248.95,55.59 249.05,55.69 249.05,56.3 249.17,56.42 249.34,56.42 249.46,56.3 249.46,55.69 249.56,55.59 249.76,55.59 249.96,55.79 v2(250.28,55.79) 250.58,55.79 250.71,55.67 250.71,54.82 250.84,54.69 251.16,54.69 251.28,54.82 251.28,55.46 251.41,55.59 251.79,55.59 251.95,55.75 UE2.A48
PGOOD_3V_5V: length 6.3
  TOP w0.102: v2(220,69.71) 219.44,69.15 219.44,68.16 219.54,68.06 219.54,67.88 PR108.2
  TOP w0.203: 218.97,66.19 218.82,66.04 PU100.7
  TOP w0.254: PR107.1 PR108.2 220,67.22 218.97,66.19
PLTRST_LAN#: length 178.5
  TOP w0.102: v1(185.51,56.17) 185.48,56.2 RC89.1 ; v1(281.39,88.81) 281.98,88.81 282.3,88.5 282.3,88.23 282.18,88.12 UL1.36
  IN1 w0.089: v1(185.51,56.17) 185.58,56.1 185.68,56.1 186.01,55.76 186.65,55.76 186.79,55.63 188.91,55.63 189.25,55.97 192.27,55.97 192.86,55.37 193.7,55.37 194.08,55 194.38,55 194.93,54.45 194.94,54.45 195.47,53.92 195.47,53.23 194.88,52.64 194.88,47.34 196.89,45.34 196.89,40.98 197.82,40.05 200.1,40.05 202.2,37.95 214.83,37.95 216.6,36.18 226.71,36.18 230.38,39.86 230.38,40.25 235.67,45.54 237.71,45.54 239.77,47.6 240.99,47.6 242.81,49.43 243.33,49.43 243.93,48.83 249.61,48.83 250.54,47.91 254.86,47.91 255.32,48.36 257.68,48.36 258.26,48.95 260.13,48.95 260.7,49.52 262.04,49.52 262.52,50 266.49,50 268.1,48.39 272.26,48.39 272.38,48.27 277.34,48.27 277.55,48.06 279.41,48.06 280.2,48.85 288.15,48.85 289.43,50.13 v1(291.81,50.13)
  BOTTOM w0.102: v1(291.81,50.13) 291.81,55.41 290.04,57.18 290.04,60.41 287.02,63.43 287.02,68.14 285.56,69.6 285.56,72.77 283.25,75.08 283.25,76.2 279.28,80.17 279.28,83.1 279.39,83.2 279.39,85.87 281.62,88.1 281.62,88.59 v1(281.39,88.81)
PLTRST_MMI#: length 160.5
  TOP w0.102: RC88.1 185.08,55.36 v1(186.49,55.36) ; v1(309.32,49.51) 309.32,54.87 307.81,56.38 307.81,58.54 308.1,58.83 308.1,59.97 308.26,60.14 UR1.15
  IN1 w0.089: v1(186.49,55.36) 186.49,55.26 186.74,55.01 191.59,55.01 191.8,54.8 193.64,54.8 193.83,54.61 194.22,54.61 194.77,54.05 194.78,54.05 195.07,53.76 195.07,53.39 194.49,52.81 194.49,47.18 196.49,45.17 196.49,40.82 198.37,38.95 199.83,38.95 201.36,37.41 214.81,37.41 216.94,35.28 226.39,35.28 230.8,39.69 230.8,40.07 235.81,45.08 237.93,45.08 239.98,47.13 241.07,47.13 242.31,48.37 247.97,48.37 248.83,47.51 255.02,47.51 255.48,47.97 257.99,47.97 258.46,48.44 260.29,48.44 260.74,48.89 266.92,48.89 267.83,47.98 271.83,47.98 271.94,47.88 277.17,47.88 277.38,47.67 279.57,47.67 280.36,48.45 288.38,48.45 288.99,49.06 288.99,49.06 289.3,49.37 294.77,49.37 294.92,49.22 296.98,49.22 297.42,48.77 302.06,48.77 302.79,49.51 v1(309.32,49.51)
PLTRST_USH#: length 82.7
  TOP w0.102: JUSH1.6 v1(236.22,14.8) ; RC87.1 185.2,54.47 185.64,54.47 v1(186.14,53.96)
  IN4 w0.089: v1(186.14,53.96) 187.67,53.96 188.17,53.47 190.73,53.47 191.2,53.94 193.5,53.94 194.27,53.16 197.13,53.16 200.32,49.98 200.32,46.38 202.78,43.92 202.8,43.92 207.63,39.09 v1(211.73,39.09) ; v1(234.73,14.77) 234.73,15.6 232.83,17.5 232.83,28.06 226.92,33.96 211.12,33.96 v1(210.16,34.92)
  BOTTOM w0.102: v1(210.16,34.92) 210.16,36.9 211.73,38.47 v1(211.73,39.09) ; v1(234.73,14.77) 234.76,14.75 CZ68.1 236.17,14.75 v1(236.22,14.8)
PLTRST_VMM2320#: length 88.2
  TOP w0.076: 166.15,98.35 165.96,98.35 165.7,98.08 164.95,98.08 UV8.A13
  TOP w0.102: RC219.1 184.9,56.84 185.08,56.66 185.72,56.66 186.11,56.28 186.11,56.24 v1(186.11,56.23) ; v1(173.89,96.95) 171.23,96.95 170.47,97.72 167.94,97.72 167.31,98.35 166.15,98.35
  IN1 w0.089: v1(193.22,55.96) 192.61,56.57 189.56,56.57 189.19,56.94 187.11,56.94 186.4,56.23 v1(186.11,56.23)
  IN2 w0.122: v1(173.89,96.95) 174.65,96.95 175.97,98.27 180.61,98.27 180.88,98 182.39,98 184.28,96.12 193.24,96.12 v1(193.99,96.87)
  BOTTOM w0.102: v1(193.22,55.96) 193.29,55.96 196.02,58.69 196.02,60.95 195.67,61.31 195.67,62.16 193.24,64.59 193.24,66.74 192.34,67.64 192.34,70.19 190.94,71.58 190.94,81.86 194.27,85.19 194.27,92.57 195.36,93.67 195.36,95.2 193.99,96.57 v1(193.99,96.87)
PM_APWROK: length 111.4
  TOP w0.102: UE2.A9 263.94,59.75 v1(264.13,59.95) ; v1(191.8,47.88) 191.52,48.16 RC26.1
  IN1 w0.089: v1(191.8,47.88) 192.21,47.46 192.21,41.37 192.89,40.69 192.89,39.86 193.7,39.04 195.39,39.04 198.23,36.2 200.49,36.2 200.72,35.97 212.65,35.97 215.21,33.4 225.84,33.4 231.79,39.35 231.79,39.73 234.46,42.41 235.22,42.41 236.95,44.14 239.46,44.14 242.75,47.43 247.58,47.43 248.53,46.48 258.72,46.48 258.97,46.74 259.43,46.74 259.52,46.65 266.69,46.65 v1(267.32,46.01)
  IN4 w0.089: v1(264.13,59.95) 264.57,60.38 266.19,60.38 266.55,60.03 266.55,59.61 266.9,59.26 266.9,52.78 267.14,52.54 267.14,47.53 266.89,47.28 266.89,46.45 v1(267.32,46.01)
PM_APWROK_L: length 3.8
  TOP w0.102: UC6.2 189.66,48.58 189.73,48.52 RC26.2 RC27.2 190.6,49.56 190.03,50.13 v2(190.03,50.43)
PM_APWROK_R: length 34.8
  TOP w0.102: v1(186.94,59.9) 187.05,59.79 187.05,59.04 187.67,58.42 v4(187.67,53.43) 188.82,52.28 188.82,50.09 187.96,49.23 UC6.4
  IN1 w0.086: 171.77,60.37 170.31,60.37 168.62,58.68 v1(166.56,58.68)
  IN1 w0.089: 171.77,60.37 181.45,60.37 181.53,60.45 181.86,60.45 181.97,60.33 182.69,60.33 182.79,60.43 184.01,60.43 184.09,60.51 186.35,60.51 186.94,59.92 v1(186.94,59.9)
  BOTTOM w0.076: UC1.AB5 166.59,58.42 166.59,58.65 v1(166.56,58.68)
PM_LANPHY_ENABLE: length 160.7
  TOP w0.102: v1(241.26,94.99) 241.25,94.99 240.86,94.59 240.86,90.77 239.8,89.72 239.8,77.71 236.96,74.87 236.96,73.66 237.81,72.81 237.81,59.08 237.59,58.87 237.59,54.42 237.38,54.2 237.38,52.1 v1(237.91,51.56) ; v1(263.26,93.58) v2(264.96,93.58) 266.98,93.58 RL7.1
  IN2 w0.122: v1(237.91,51.56) 236.77,51.56 230.35,45.15 229.45,45.15 225.84,41.54 201,41.54 200.11,42.43 194.91,42.43 194.73,42.26 192.64,42.26 189.66,45.23 189.66,47.82 187.44,50.04 187.44,50.26 v1(186.92,50.78)
  IN4 w0.086: 171.77,53.2 171.71,53.25 170.26,53.25 169.94,52.94 166.88,52.94 166.72,52.77 166.21,52.77 165.88,53.11 v1(165.66,53.11)
  IN4 w0.089: v1(186.92,50.78) 186.92,50.8 186,51.72 181.9,51.72 181.46,52.16 176.96,52.16 176.68,52.44 174.26,52.44 173.76,52.94 172.03,52.94 171.77,53.2 ; v1(241.26,94.99) 241.53,95.26 248.52,95.26 249.1,94.68 256.39,94.68 256.72,94.36 262.86,94.36 263.26,93.96 v1(263.26,93.58)
  BOTTOM w0.076: UC1.AM7 165.35,52.81 v1(165.66,53.11)
  BOTTOM w0.102: v1(186.92,50.78) 186.66,50.78 186.09,50.21 RC92.1
PM_TEST_RST: length 8.1
  TOP w0.076: v1(166.55,57.73) 169.5,57.73 170.03,58.26 v2(171.41,58.26) 171.77,58.61
  TOP w0.102: RC300.2 CC100.2 171.77,58.61
  BOTTOM w0.076: v1(166.55,57.73) UC1.AC4
POA_WAKE#: length 19.7
  TOP w0.102: UE2.B68 261.91,54.9 263.68,53.14 v1(265.79,53.14) ; v1(265.3,45.85) v2(265.3,46.5) ; RPE5.3 265.64,58.24 265.25,57.85 265.25,56.8 v1(265.33,56.72)
  IN4 w0.089: v1(265.79,53.14) 265.79,55.13 265.86,55.21 265.86,56.19 v1(265.33,56.72)
  BOTTOM w0.102: v1(265.79,53.14) 265.79,52.15 266.45,51.49 266.45,48.02 265.3,46.87 v1(265.3,45.85)
POWER_SW#_MB: length 187.5
  TOP w0.102: RE33.2 267.59,55.07 v4(267.98,55.07) v1(268.7,55.07) 268.87,54.9 268.87,54.88 CE10.1 ; v1(323.61,95.11) 325.63,95.11 326.68,94.06 SW3.2 SW3.4
  IN1 w0.089: v1(268.7,55.07) 269.35,54.42 273.35,54.42 274.14,53.64 275.34,53.64 276.11,54.42 277.72,54.42 278.94,53.2 284.55,53.2 285.74,52 291.92,52 293.26,50.66 301.08,50.66 301.32,50.9 303.32,50.9 303.61,50.62 308.55,50.62 v1(308.84,50.9)
  IN2 w0.122: v1(268.39,69.28) 268.11,69 266.66,69 266.25,69.42 257.71,69.42 257.15,68.86 252.22,68.86 251.83,69.26 250.62,69.26 250.39,69.04 246.17,69.04 245.53,68.39 238.14,68.39 236.83,69.7 v1(236.36,69.7)
  IN4 w0.089: v1(308.84,50.9) 309.28,51.35 309.28,59.96 310.18,60.86 314.44,60.86 315.1,61.52 315.1,63.21 314.5,63.81 313.91,63.81 313.28,64.43 313.28,66.66 314.35,67.73 314.35,71.29 312.67,72.96 310.9,72.96 310.48,73.38 307.75,73.38 305.69,75.44 305.69,85.05 306.12,85.49 307.68,85.49 311.24,89.04 311.24,94.53 311.82,95.11 v1(323.61,95.11)
  BOTTOM w0.102: v1(236.36,69.7) 236.26,69.7 233.48,72.48 233.48,76.81 232.63,77.66 231.61,77.66 231.19,78.08 JAPS1.11 ; v1(268.39,69.28) 268.52,69.28 270.18,67.62 270.18,57.16 268.76,55.74 268.76,55.13 v1(268.7,55.07)
