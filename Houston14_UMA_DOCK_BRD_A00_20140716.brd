# Allegro board Houston14_UMA_DOCK_BRD_A00_20140716.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DPB_LANE_N0: length 36.5
  TOP w0.102: v1(149.74,112.08) 149.43,112.38 149.43,112.84 149.81,113.22 150.28,113.22 150.5,113.44 v3(150.5,114.11) 150.5,114.85 150.04,115.31 147.72,115.31 147.43,115.59 147.43,116.03 147.41,116.06 147.41,116.25 C296.1 ; v1(166.62,96.18) 166.43,96.37 166.22,96.37 165.74,95.89 165.41,95.89 UV8.E14
  IN4 w0.089: v1(166.62,96.18) 166.62,96.2 167.28,96.87 167.28,97.59 166.1,98.77 165.15,98.77 163.41,100.51 162.84,100.51 161.64,101.71 160.43,101.71 158.08,104.07 156.01,104.07 151.14,108.93 151.14,109.63 149.37,111.4 149.37,111.71 v1(149.74,112.08)
DPB_LANE_N0_C: length 1.7
  TOP w0.102: C296.2 147.46,118.02 147.46,118.58 R261.2
DPB_LANE_N1: length 35.3
  TOP w0.102: UV8.F14 165.42,95.25 165.91,95.25 166.18,95.52 167.07,95.52 167.36,95.81 167.36,96.25 167.45,96.34 167.63,96.34 v1(167.82,96.15) ; v1(149.66,115.99) 149.47,116.18 149.47,116.28 C303.1
  IN4 w0.089: v1(149.66,115.99) 149.64,115.99 149.32,115.67 149.32,115.53 150.73,114.12 150.73,111.53 152.82,109.44 152.82,108.31 155.84,105.29 157.77,105.29 160.71,102.35 161.99,102.35 163.15,101.2 164.97,101.2 166.55,99.62 166.55,99.3 168.25,97.6 168.25,96.59 v1(167.82,96.15)
DPB_LANE_N1_C: length 1.7
  TOP w0.102: R256.2 149.49,118.58 149.49,118.02 C303.2
DPB_LANE_N2: length 36.7
  TOP w0.102: UV8.G14 165.39,94.57 165.83,94.57 165.92,94.66 166.36,94.66 v1(166.62,94.4) ; C307.1 151.75,116.7 151.44,116.39 151.44,116.14 v1(151.69,115.89)
  IN4 w0.089: v1(166.62,94.4) 166.62,94.44 166.81,94.63 166.94,94.63 167.05,94.52 168.45,94.52 168.9,94.97 168.9,97.91 167.27,99.53 167.27,99.84 166.4,100.71 166.4,101.25 165.31,102.33 164.57,102.33 163.55,103.36 161.44,103.36 158.8,106 156.53,106 154.19,108.33 154.19,109.7 151.38,112.52 151.38,114.78 151.28,114.88 151.28,115.48 v1(151.69,115.89)
DPB_LANE_N2_C: length 1.7
  TOP w0.102: R264.2 151.53,118.58 151.53,118.02 C307.2
DPB_LANE_N3: length 37.8
  TOP w0.102: v1(153.72,115.89) 153.54,116.08 153.54,116.28 C309.1 ; v1(167.12,93.42) 166.79,93.75 166.09,93.75 165.9,93.94 165.41,93.94 UV8.H14
  IN4 w0.089: v1(153.72,115.89) 153.36,115.52 153.36,112.07 155.53,109.9 155.53,108.02 156.86,106.7 159.08,106.7 161.76,104.01 164.86,104.01 167.91,100.96 167.91,99.91 168.1,99.72 168.78,99.72 169.59,98.91 169.59,94.59 168.84,93.84 167.53,93.84 v1(167.12,93.42)
DPB_LANE_N3_C: length 1.7
  TOP w0.102: C309.2 153.56,118.02 153.56,118.58 R267.2
DPB_LANE_P0: length 36.5
  TOP w0.102: UV8.E13 164.96,96.1 165.65,96.1 166.13,96.58 166.43,96.58 v1(166.62,96.77) ; C294.1 147.21,116.35 147.21,116.34 147.2,116.33 147.2,115.53 147.63,115.1 149.95,115.1 150.28,114.77 150.28,114.42 150.27,114.41 150.27,113.81 150.28,113.81 150.28,113.52 150.19,113.43 149.73,113.43 149.23,112.93 149.23,112.15 v1(149.15,112.08)
  IN4 w0.089: v1(166.62,96.77) 166.94,96.77 167.11,96.94 167.11,97.52 166.03,98.6 165.08,98.6 163.34,100.34 162.77,100.34 161.57,101.54 160.36,101.54 158.01,103.9 155.94,103.9 150.97,108.86 150.97,109.56 149.2,111.33 149.2,112.03 v1(149.15,112.08)
DPB_LANE_P0_C: length 1.7
  TOP w0.102: R260.2 147.25,118.58 147.25,118.02 C294.2
DPB_LANE_P1: length 35.3
  TOP w0.102: C298.1 149.26,116.32 149.26,116.18 v1(149.08,115.99) ; v1(167.82,96.74) 167.63,96.55 167.36,96.55 167.15,96.34 167.15,95.9 166.98,95.73 166.09,95.73 165.82,95.46 164.98,95.46 UV8.F13
  IN4 w0.089: v1(167.82,96.74) 168.01,96.74 168.08,96.81 168.08,97.53 166.38,99.23 166.38,99.55 164.9,101.03 163.08,101.03 161.92,102.18 160.64,102.18 157.7,105.12 155.77,105.12 152.65,108.24 152.65,109.37 150.56,111.46 150.56,114.05 149.15,115.46 149.15,115.92 v1(149.08,115.99)
DPB_LANE_P1_C: length 1.7
  TOP w0.102: C298.2 149.29,118.02 149.29,118.58 R254.2
DPB_LANE_P2: length 36.7
  TOP w0.102: v1(166.62,94.98) 166.51,94.87 165.84,94.87 165.75,94.78 164.95,94.78 UV8.G13 ; C305.1 151.23,116.39 151.23,116.01 v1(151.11,115.89)
  IN4 w0.089: v1(166.62,94.98) 166.81,94.8 167.01,94.8 167.12,94.69 168.38,94.69 168.73,95.04 168.73,97.84 167.1,99.46 167.1,99.77 166.22,100.64 166.22,101.18 165.24,102.16 164.5,102.16 163.48,103.18 161.37,103.18 158.73,105.83 156.46,105.83 154.02,108.26 154.02,109.63 151.21,112.45 151.21,114.71 151.11,114.81 v1(151.11,115.89)
DPB_LANE_P2_C: length 1.7
  TOP w0.102: C305.2 151.32,118.02 151.32,118.58 R262.2
DPB_LANE_P3: length 37.8
  TOP w0.102: v1(153.14,115.89) 153.33,116.08 153.33,116.32 C308.1 ; UV8.H13 164.96,94.15 165.99,94.15 166.18,93.96 167.07,93.96 v1(167.12,94.01)
  IN4 w0.089: v1(153.14,115.89) 153.19,115.84 153.19,112 155.36,109.83 155.36,107.95 156.79,106.53 159.01,106.53 161.69,103.84 164.79,103.84 167.74,100.89 167.74,99.84 168.03,99.55 168.71,99.55 169.42,98.83 169.42,94.66 168.77,94.01 v1(167.12,94.01)
DPB_LANE_P3_C: length 1.7
  TOP w0.102: C308.2 153.35,118.02 153.35,118.58 R258.2
DPC_CA_DET: length 70.1
  TOP w0.102: v1(165.96,99.23) 165.96,99.16 165.3,98.49 UV8.A14
  IN3 w0.122: v1(181.89,102.53) 181.48,102.94 180.63,102.94 179.06,101.36 176.03,101.36 175.17,102.22 169.23,102.22 168.62,102.83 166.48,102.83 165.96,102.31 v1(165.96,99.23) ; v1(165.71,107.22) 165.15,106.66 147.56,106.66 147.31,106.91 v1(147.31,107.09)
  BOTTOM w0.102: JDOCK1.5 146.9,109.21 146.81,109.12 146.81,108.13 147.31,107.64 v1(147.31,107.09) ; v1(165.71,107.22) 165.37,106.88 165.37,104.84 165.96,104.25 v1(165.96,99.23) 167.21,97.98 169.58,97.98 170.09,97.48 171.46,97.48 171.69,97.7 v2(171.69,98.26) RV509.2 172.03,99.72 UV12.1 174.88,99.72 175.27,100.1 175.27,101.36 174.97,101.67 UV12.4 ; QV10.2 182.27,102.91 v1(181.89,102.53)
DPC_CA_DET#: length 9.1
  BOTTOM w0.102: QV10.1 182.92,102.45 v2(182.41,101.95) 181.95,101.49 RV91.2 ; UV12.13 181.92,100.37 RV91.2 ; UV12.10 180.31,102.32 180.83,101.8 180.83,100.96 181.01,100.78 181.57,100.78 RV91.2
DPC_DOCK_AUX: length 49.4
  TOP w0.102: v1(178.3,101.84) 178.94,101.84 179.28,102.19 179.28,103.21 178.97,103.52 175.41,103.52 173.87,101.97 173.14,101.97 v1(172.71,101.54)
  IN2 w0.112: v1(172.71,101.54) 172.14,102.11 172.14,103.65 170.5,105.28 170.5,105.61 171.03,106.14 171.03,106.3 170.8,106.54 170.64,106.54 170.1,106 169.78,106 169.42,106.36 169.42,106.69 169.95,107.22 169.95,107.38 169.72,107.62 169.56,107.62 169.03,107.08 168.7,107.08 168.34,107.44 168.34,107.77 168.88,108.3 168.88,108.46 167.68,109.65 167.68,113.02 167.09,113.62 162.33,113.62 161.94,113.22 161.94,112.56 161.3,111.93 157.24,111.93 157.05,111.74 157.05,110.62 156.82,110.39 154.91,110.39 154.1,111.2 v1(154.1,111.95)
  BOTTOM w0.102: JDOCK1.33 153.9,111.17 153.97,111.24 153.97,111.62 154.1,111.75 v1(154.1,111.95) ; UV12.11 178.47,101.67 v1(178.3,101.84) ; v1(172.71,101.54) 172.71,101.45 173.14,101.02 UV12.3
DPC_DOCK_AUX#: length 50.5
  TOP w0.102: v1(172.76,102.82) 172.76,102.56 173.13,102.18 173.78,102.18 175.32,103.72 179.06,103.72 179.49,103.29 179.49,102.89 179.92,102.45 v1(181.04,102.45)
  IN2 w0.112: v1(172.76,102.82) 172.76,102.43 172.64,102.31 172.44,102.31 172.34,102.41 172.34,103.73 170.7,105.37 170.7,105.52 171.24,106.06 171.24,106.38 170.88,106.74 170.55,106.74 170.02,106.21 169.86,106.21 169.62,106.45 169.62,106.6 170.16,107.14 170.16,107.46 169.8,107.82 169.47,107.82 168.94,107.29 168.78,107.29 168.55,107.52 168.55,107.68 169.08,108.21 169.08,108.54 167.88,109.74 167.88,113.11 167.17,113.82 162.25,113.82 161.73,113.31 161.73,112.65 161.22,112.13 157.15,112.13 156.84,111.82 156.84,110.71 156.73,110.6 155,110.6 154.31,111.29 154.31,111.57 154.67,111.94 v1(154.75,111.94)
  BOTTOM w0.102: UV12.6 172.9,102.97 v1(172.76,102.82) ; UV12.8 180.56,103.62 181.04,103.14 v1(181.04,102.45) ; v1(154.75,111.94) 154.66,111.94 154.18,111.45 154.18,111.29 154.4,111.07 JDOCK1.35
DPC_DOCK_HPD: length 15.7
  TOP w0.076: UV8.A6 159.81,98.67 159.65,98.67 159.19,99.13
  TOP w0.102: v1(159.14,99.43) 159.14,99.18 159.19,99.13
  BOTTOM w0.102: v1(159.14,99.43) 158.89,99.43 v2(158.61,99.71) 158.61,100.37 159.7,101.46 159.7,104.59 159.25,105.04 158.66,105.04 158.29,105.41 R268.1 C310.1 157.51,106.37 155.4,108.47 JDOCK1.39
DPC_DOCK_LANE_N0: length 4
  BOTTOM w0.102: JDOCK1.11 148.4,109.15 148.25,109 v3(148.25,107.67) 148.25,106.82 R252.2
DPC_DOCK_LANE_N1: length 4.2
  BOTTOM w0.102: R255.2 150.28,106.82 150.28,107.03 149.75,107.55 v3(149.75,107.85) 149.75,109 149.9,109.15 JDOCK1.17
DPC_DOCK_LANE_N2: length 4.4
  BOTTOM w0.102: R263.2 152.27,106.87 v3(152.27,107.46) 152.27,107.96 151.25,108.97 151.25,109.16 151.4,109.3 JDOCK1.23
DPC_DOCK_LANE_N3: length 4.6
  BOTTOM w0.102: R266.2 154.3,106.87 154.3,107.36 v3(153.91,107.75) 152.75,108.9 152.75,109 152.9,109.15 JDOCK1.29
DPC_DOCK_LANE_P0: length 4
  BOTTOM w0.102: R259.2 148.05,106.88 148.05,107.37 148.03,107.39 148.03,107.96 148.05,107.98 148.05,109 147.9,109.15 JDOCK1.9
DPC_DOCK_LANE_P1: length 4.2
  BOTTOM w0.102: R253.2 150.07,106.87 150.07,106.94 149.55,107.46 149.55,107.55 149.53,107.57 149.53,108.13 149.55,108.15 149.55,109 149.4,109.15 JDOCK1.15
DPC_DOCK_LANE_P2: length 4.4
  BOTTOM w0.102: JDOCK1.21 150.9,109.32 151.05,109.17 151.05,108.88 152.06,107.87 152.06,107.75 152.04,107.73 152.04,107.18 152.06,107.16 152.06,106.82 R257.2
DPC_DOCK_LANE_P3: length 4.6
  BOTTOM w0.102: R265.2 154.09,106.82 154.09,107.27 153.97,107.39 153.94,107.39 153.55,107.78 153.55,107.81 152.55,108.82 152.55,109 152.4,109.15 JDOCK1.27
DPC_HPD: length 57.3
  TOP w0.076: 155.61,74.93 156.06,74.49 156.06,68.48 155.74,68.16 155.74,65.22 155.99,64.96 RC142.2 155.79,64.59 v1(155.38,64.59)
  TOP w0.102: v1(144.82,90.08) 145.22,89.68 v2(145.22,88.97) 145.71,88.48 145.71,87.77 147.69,85.78 149.17,85.78 149.75,85.21 149.75,77.83 152.48,75.1 155.45,75.1 155.61,74.93
  IN2 w0.086: v1(155.38,64.59) 155.8,65.01 155.8,69.28 156.36,69.84 162.64,69.84 163.98,71.19 165.93,71.19 166.66,71.92 166.66,72.6 v1(166.6,72.66)
  BOTTOM w0.076: UC1.A8 164.45,70.4 164.45,70.4 164.45,70.54 164.57,70.65 165.74,71.82 165.74,72.33 166.09,72.68 166.57,72.68 v1(166.6,72.66)
  BOTTOM w0.102: UV7.3 143.25,90.94 143.64,90.55 143.9,90.55 144.37,90.08 v1(144.82,90.08)
DPC_LANE_N0: length 19.5
  TOP w0.102: v1(160.79,100.97) 160.63,100.81 160.63,98.73 160.75,98.61 UV8.A7
  IN1 w0.089: v1(148.41,102.24) 148.39,102.24 148.02,102.61 148.02,102.75 148.24,102.97 152.49,102.97 153.14,102.32 153.14,101.65 154.42,100.37 156.75,100.37 156.86,100.48 159.9,100.48 159.97,100.42 160.29,100.42 160.51,100.63 160.51,100.7 160.77,100.97 v1(160.79,100.97)
  BOTTOM w0.102: v1(148.41,102.24) 148.14,102.52 148.14,102.91 148.34,103.11 148.5,103.11 C295.2
DPC_LANE_N0_C: length 2
  BOTTOM w0.102: C295.1 148.22,104.31 148.22,105.12 R252.1
DPC_LANE_N1: length 16.1
  TOP w0.102: UV8.A8 161.4,98.6 161.48,98.68 161.48,99.25 161.14,99.6 v1(161.06,99.6)
  IN1 w0.089: v1(161.06,99.6) 160.72,99.25 160.37,99.25 159.94,98.82 159.17,98.82 158.64,99.35 157.47,99.35 157.37,99.25 153.01,99.25 152.58,99.68 151.42,99.68 150.13,100.98 150.13,101.94 v1(150.46,102.27)
  BOTTOM w0.102: v1(150.46,102.27) 150.27,102.45 150.27,102.6 C299.2
DPC_LANE_N1_C: length 2
  BOTTOM w0.102: R255.1 150.26,105.12 150.26,104.31 C299.1
DPC_LANE_N2: length 15.8
  TOP w0.076: UV8.A9 162.05,99.13
  TOP w0.102: 162.05,99.13 162.05,99.21 162.45,99.61 162.45,99.86 v1(161.98,100.32)
  IN1 w0.089: v1(161.98,100.32) 161.65,99.99 161.58,99.99 161.3,100.27 160.82,100.27 160.47,99.91 159.83,99.91 159.74,100.01 157.17,100.01 157.05,99.89 153.52,99.89 153.06,100.36 152.4,100.36 152.01,100.75 152.01,101.26 152.14,101.39 152.14,101.9 v1(152.48,102.24)
  BOTTOM w0.102: C306.2 152.29,102.58 152.29,102.43 v1(152.48,102.24)
DPC_LANE_N2_C: length 2
  BOTTOM w0.102: C306.1 152.29,104.31 152.29,105.12 R263.1
DPC_LANE_N3: length 16
  TOP w0.102: v1(163.06,99.16) 162.92,99.3 162.82,99.3 162.55,99.04 162.55,98.84 162.66,98.73 162.86,98.73 162.99,98.61 162.99,98.15 162.94,98.1 162.8,98.1 162.7,98.2 UV8.A10
  IN1 w0.089: v1(163.06,99.16) 163.22,99.32 163.59,99.32 163.81,99.54 163.81,100.18 162.29,101.7 159.73,101.7 159.33,101.3 156.53,101.3 156.42,101.19 154.77,101.19 154.49,101.47 154.49,102.22 v1(154.53,102.27)
  BOTTOM w0.102: v1(154.53,102.27) 154.35,102.45 154.35,102.61 C301.2
DPC_LANE_N3_C: length 2
  BOTTOM w0.102: R266.1 154.32,105.12 154.32,104.31 C301.1
DPC_LANE_P0: length 19.5
  TOP w0.102: v1(160.21,100.97) 160.43,100.75 160.43,98.62 160.46,98.58 160.46,98.02 UV8.B7
  IN1 w0.089: v1(147.83,102.24) 147.85,102.27 147.85,102.82 148.17,103.14 152.56,103.14 153.31,102.39 153.31,101.72 154.49,100.54 156.68,100.54 156.79,100.66 159.97,100.66 160.04,100.59 160.22,100.59 160.34,100.7 160.34,100.84 v1(160.21,100.97)
  BOTTOM w0.102: C302.2 147.93,102.67 147.93,102.35 v1(147.83,102.24)
DPC_LANE_P0_C: length 2
  BOTTOM w0.102: R259.1 148.02,105.12 148.02,104.31 C302.1
DPC_LANE_P1: length 16.1
  TOP w0.102: v1(161.07,99.01) 161.07,98.06 UV8.B8
  IN1 w0.089: v1(149.87,102.27) 149.96,102.18 149.96,100.9 151.35,99.51 152.51,99.51 152.94,99.08 157.44,99.08 157.54,99.18 158.57,99.18 159.1,98.65 160.01,98.65 160.44,99.08 161,99.08 v1(161.07,99.01)
  BOTTOM w0.102: C297.2 150.06,102.57 150.06,102.45 v1(149.87,102.27)
DPC_LANE_P1_C: length 2
  BOTTOM w0.102: C297.1 150.05,104.31 150.05,105.12 R253.1
DPC_LANE_P2: length 15.8
  TOP w0.076: UV8.B9 162.05,97.78 161.73,98.1 161.73,99.13
  TOP w0.102: 161.73,99.13 161.73,99.49 v1(161.98,99.74)
  IN1 w0.089: v1(151.89,102.24) 151.97,102.16 151.97,101.46 151.84,101.33 151.84,100.68 152.33,100.19 152.99,100.19 153.45,99.72 157.12,99.72 157.24,99.84 159.66,99.84 159.76,99.74 160.54,99.74 160.89,100.1 161.23,100.1 161.51,99.82 161.9,99.82 v1(161.98,99.74)
  BOTTOM w0.102: C304.2 152.08,102.58 152.08,102.43 v1(151.89,102.24)
DPC_LANE_P2_C: length 2
  BOTTOM w0.102: C304.1 152.08,104.31 152.08,105.12 R257.1
DPC_LANE_P3: length 16
  TOP w0.102: v1(163.06,99.74) 162.83,99.51 162.73,99.51 162.35,99.12 162.35,98.44 162.42,98.37 162.42,98.01 UV8.B10
  IN1 w0.089: v1(163.06,99.74) 163.31,99.49 163.52,99.49 163.64,99.61 163.64,100.1 162.22,101.53 159.8,101.53 159.4,101.13 156.6,101.13 156.49,101.02 154.7,101.02 154.32,101.4 154.32,101.9 v1(153.95,102.27)
  BOTTOM w0.102: C300.2 154.14,102.56 154.14,102.45 v1(153.95,102.27)
DPC_LANE_P3_C: length 2
  BOTTOM w0.102: R265.1 154.11,105.12 154.11,104.31 C300.1
DSWODVREN: length 13.3
  TOP w0.076: v1(168.06,43.69) 168.21,43.69 v2(168.58,43.31) 169.43,42.47 169.74,42.47 170.1,42.1 170.1,41.3 169.9,41.1 169.9,40.25 169.45,39.8 169.45,38.35
  TOP w0.102: 169.45,38.35 169.46,38.34 RC78.1
  BOTTOM w0.076: UC1.AW7 164.86,48.21 165.15,47.92 165.15,46.32 166.46,45.01 166.74,45.01 v1(168.06,43.69)
EC5048_TX: length 78.9
  TOP w0.102: UE1.B2 257.92,83.53 v1(257.76,83.38) ; v1(262.84,83.07) 263.06,82.86 v2(263.06,82.36)
  IN2 w0.122: v1(257.76,83.38) 257.77,83.38 257.81,83.34 262.57,83.34 v1(262.84,83.07)
  BOTTOM w0.102: RE74.2 284.11,32.48 283.3,33.29 283.24,33.29 280.02,36.5 JDEG1.9 280.02,38.04 279.72,38.34 274.75,38.34 273.04,40.06 273.04,43.58 271.63,44.99 268.63,44.99 267.78,45.84 267.78,47.32 267.4,47.7 267.4,54.38 267.64,54.63 269.35,54.63 269.74,55.01 269.74,55.91 270.41,56.58 270.41,68.62 268.5,70.52 268.5,72.19 268.1,72.59 267.88,72.59 266.29,74.18 266.29,76.39 264.45,78.23 263.73,78.23 263.23,78.73 263.23,82.64 262.84,83.04 v1(262.84,83.07)
EC_32KHZ_MEC5085: length 64.1
  TOP w0.102: v1(261.76,55.57) 262.2,56 UE2.B2 ; v1(268.69,54.04) 268.82,53.91 269.68,53.91 270.45,53.15 270.45,51.83 271.86,50.42 271.86,47.72 273.05,46.52 284.8,46.52 286.17,47.89 286.17,48.63 285.97,48.83 UZ11.2 ; UE1.B35 250.42,75.49 v1(251.06,76.13)
  IN2 w0.122: v1(268.69,54.04) 268.11,54.63 267.25,54.63 266.75,54.13 264.19,54.13 263.58,54.74 263.16,54.74 262.97,54.55 262.08,54.55 261.58,55.04 261.58,55.39 v1(261.76,55.57)
  IN4 w0.089: v1(261.76,55.57) 261.37,55.96 261.37,56.19 261.01,56.55 257.51,56.55 255.71,58.35 255.71,61.86 255.38,62.2 255.38,66.52 253.24,68.65 253.24,70.19 253.44,70.39 253.44,72.25 253.09,72.61 252.97,72.61 252.39,73.19 252.39,73.93 251.46,74.86 251.46,75.73 v1(251.06,76.13)
  BOTTOM w0.102: v1(261.76,55.57) 261.4,55.21 v2(261.4,54.93)
EDP_BIA_PWM: length 111.4
  TOP w0.102: v1(88.87,92.86) 88.87,93.83 88.02,94.68 88.02,95.39 88.45,95.81 DV1.3
  IN3 w0.086: v1(165.57,72.72) 165.92,73.07 165.92,73.39
  IN3 w0.122: 165.92,73.39 165.92,75.98 165.92,76.19 166.31,76.58 166.86,76.58 166.86,76.57 166.96,76.57 169.37,78.99 169.37,79.89 166.14,83.11 163.4,83.11 162.98,83.53 160.23,83.53 159.78,83.99 154.08,83.99 153.87,83.78 151.71,83.78 149.3,86.2 147.3,86.2 144.35,89.15 143.03,89.15 142.82,89.36 138.69,89.36 138.07,89.99 138.07,90.35 135.42,93 135.42,96.39 133.15,98.66 129.47,98.66 128.47,97.65 117.11,97.65 116.44,96.98 110.74,96.98 108.92,95.16 106.79,95.16 103.24,91.61 90.13,91.61 v1(88.87,92.86)
  BOTTOM w0.076: UC1.B8 164.17,69.67 164.17,70.11 164.17,70.12 164.17,70.35 164.29,70.47 164.29,70.61 165.48,71.8 165.48,72.6 165.57,72.7 v1(165.57,72.72)
  BOTTOM w0.102: v2(88.87,92.23) v1(88.87,92.86)
EDP_COMP: length 3.5
  TOP w0.076: v1(157.24,67.93) v2(157.24,68.87)
  TOP w0.508: RC133.2 156.16,66.89 157.21,67.93 v1(157.24,67.93)
  BOTTOM w0.381: UC1.D20 157.46,67.93 v1(157.24,67.93)
EDP_CPU_AUX: length 94.3
  IN4 w0.089: v1(84.68,96.73) 84.86,96.54 86.03,96.54 87.89,98.39 90,98.39 92.65,101.05 99.77,101.05 100.34,101.62 105.4,101.62 106.03,102.25 110.23,102.25 110.57,101.91 134.64,101.91 137.96,98.59 137.96,97.09 139.67,95.39 139.67,92.91 144.77,87.81 144.77,86.67 143.57,85.47 143.57,74.66 142.26,73.35 v1(141.61,73.35)
  BOTTOM w0.076: 142.11,72.43 142.11,72.41 142.13,72.39 142.13,70.72 141.94,70.54 141.54,70.54 141.44,70.44 141.44,70.08 141.73,69.79 UC1.B45
  BOTTOM w0.102: 142.11,72.43 142.11,73.33 142.04,73.4 141.66,73.4 v1(141.61,73.35) ; CV2.1 85.59,97.47 85.7,97.37 85.7,96.69 85.57,96.56 84.84,96.56 v1(84.68,96.73)
EDP_CPU_AUX#: length 94.1
  IN4 w0.089: v1(84.68,96.14) 84.9,96.37 86.11,96.37 87.96,98.22 90.07,98.22 92.72,100.88 99.84,100.88 100.41,101.45 105.47,101.45 106.1,102.08 110.16,102.08 110.5,101.74 134.57,101.74 137.79,98.52 137.79,97.02 139.5,95.32 139.5,92.84 144.6,87.74 144.6,86.74 143.4,85.54 143.4,74.73 142.18,73.52 141.98,73.52 141.9,73.6 141.9,73.88 141.84,73.93 v1(141.61,73.93)
  BOTTOM w0.076: 142.33,72.43 142.33,72.42 142.32,72.4 142.32,70.64 142.1,70.43 142.1,70.13 141.95,69.98 141.86,69.98 141.73,70.11 UC1.A45
  BOTTOM w0.102: v1(141.61,73.93) 141.93,73.62 142.13,73.62 142.33,73.42 142.33,72.43 ; CV1.1 85.91,97.16 85.91,96.6 85.66,96.35 84.88,96.35 v1(84.68,96.14)
EDP_CPU_AUX#_C: length 2.7
  BOTTOM w0.102: CV1.2 85.78,98.82 85.78,99.03 85.2,99.6 85.2,99.89 85.39,100.08 JEDP1.33
EDP_CPU_AUX_C: length 2.7
  BOTTOM w0.102: JEDP1.34 84.89,99.95 84.99,99.85 84.99,99.52 85.57,98.94 85.57,98.76 CV2.2
EDP_CPU_HPD: length 125.6
  IN3 w0.122: v1(170.84,76.29) 172.28,77.73 172.28,80.16 171.5,80.94 169.95,80.94 166.64,84.25 163.72,84.25 163.44,84.53 160.65,84.53 160.14,85.04 154.82,85.04 152.22,87.64 152.22,89.71 150.87,91.07 145.54,91.07 145.31,90.84 143.83,90.84 143.06,91.61 140.45,91.61 139.02,93.04 139.02,94.27 136.65,96.64 136.65,98.53 136.13,99.05 134.17,99.05 133.42,99.8 132.62,99.8 131.99,100.43 129.84,100.43 128.05,98.65 116.7,98.65 116.03,97.98 106.97,97.98 106.39,97.4 103.45,97.4 101.43,95.38 98.48,95.38 97.84,94.74 97.84,92.99 97.07,92.22 90.84,92.22 v1(89.34,93.72)
  BOTTOM w0.076: UC1.D6 165.78,68.45 166.08,68.75 166.33,68.75 166.5,68.92 166.5,69.01 166.78,69.29 167.23,69.29 167.37,69.43 167.37,69.75 167.24,69.88 166.93,69.88 166.76,70.04 166.76,70.49 167.3,71.02 168.35,71.02
  BOTTOM w0.102: v1(89.34,93.72) 88.29,94.77 88.29,97.37 87.84,97.83 87.84,98.38 88.89,99.44 JEDP1.26 ; RC141.2 170.98,76.43 v1(170.84,76.29) 170.98,76.15 v2(170.98,73.32) 170.98,72.3 169.7,71.02 168.35,71.02
EDP_CPU_LANE_N0: length 107.4
  IN4 w0.086: v1(141.66,71.53) 141.68,71.54 142.63,71.54 144.22,73.14 144.22,73.32 144.23,73.32 144.23,73.37 144.23,73.37 144.23,73.39
  IN4 w0.089: 144.23,73.39 144.23,84.56 144.53,84.86 145.11,84.86 145.5,85.25 145.5,88.71 141.78,92.42 141.78,94.3 138.66,97.42 138.66,98.81 134.92,102.55 110.83,102.55 110.37,103.01 99.77,103.01 98.49,101.73 89.66,101.73 89.32,101.39 89.32,99.93 89.19,99.8 88.99,99.8 88.86,99.93 88.86,101.86 88.63,102.09 88.3,102.09 88.08,101.86 88.08,99.6 87.95,99.47 87.76,99.47 87.63,99.6 87.63,100.93 87.4,101.16 87.08,101.16 86.85,100.93 86.85,100.32 86.72,100.19 85.37,100.19 85.1,99.92 85.1,98.09 83.52,96.51 83.1,96.51 v1(82.88,96.74)
  BOTTOM w0.076: UC1.C45 141.46,69.2 141.46,69.44 141.26,69.64 141.26,70.62 141.15,70.72 141.15,71.51 141.41,71.77 141.53,71.77 141.66,71.64 v1(141.66,71.53)
  BOTTOM w0.102: CV4.1 83.47,97.47 83.7,97.25 83.7,96.73 83.53,96.57 83.05,96.57 82.88,96.73 v1(82.88,96.74)
EDP_CPU_LANE_N0_C: length 3.1
  BOTTOM w0.102: JEDP1.36 83.89,100.03 84.19,99.74 84.19,99.39 84.12,99.32 83.62,99.32 83.44,99.14 83.44,98.66 CV4.2
EDP_CPU_LANE_N1: length 107.4
  IN4 w0.086: v1(139.64,71.09) 139.95,71.09 140.76,70.28 143.31,70.28 144.89,71.86 144.89,73.39
  IN4 w0.089: v1(80.57,96.75) 80.83,96.5 81.53,96.5 81.74,96.71 81.74,97.55 85.2,101.02 85.76,101.02 87.52,102.78 89.76,102.78 90.63,103.65 110.64,103.65 111.1,103.19 135.25,103.19 139.33,99.11 139.33,98.45 139.88,97.91 139.88,97.42 143.43,93.87 143.43,92.52 146.77,89.18 146.77,86.85 146.18,86.25 146.18,84.99 145.76,84.57 145.76,76.4 144.89,75.53 144.89,73.39
  BOTTOM w0.076: UC1.A47 140.7,70.14 140.7,69.98 140.63,69.9 140.32,69.9 140.27,69.95 140.27,70.4 140.52,70.65 140.52,71.55 140.46,71.61 140.3,71.61 139.97,71.29 139.84,71.29 v1(139.64,71.09)
  BOTTOM w0.102: CV6.1 81.43,97.47 81.66,97.24 81.66,96.93 81.34,96.6 80.72,96.6 v1(80.57,96.75)
EDP_CPU_LANE_N1_C: length 3.3
  BOTTOM w0.102: JEDP1.38 82.89,100.08 82.93,100.04 82.93,99.79 82.75,99.61 82.26,99.61 81.13,98.48 CV6.2
EDP_CPU_LANE_P0: length 107.2
  IN4 w0.086: 144.06,73.39 144.06,73.21 142.56,71.71 142.01,71.71 141.66,72.05 v1(141.66,72.18)
  IN4 w0.089: 144.06,73.39 144.06,84.64 144.45,85.03 145.04,85.03 145.33,85.32 145.33,88.64 141.61,92.35 141.61,94.23 138.49,97.35 138.49,98.74 134.85,102.38 110.76,102.38 110.3,102.84 99.84,102.84 98.56,101.56 89.73,101.56 89.49,101.32 89.49,99.86 89.26,99.63 88.92,99.63 88.69,99.86 88.69,101.79 88.56,101.92 88.37,101.92 88.25,101.79 88.25,99.53 88.02,99.3 87.69,99.3 87.46,99.53 87.46,100.86 87.33,100.99 87.15,100.99 87.02,100.86 87.02,100.25 86.79,100.02 85.45,100.02 85.27,99.84 85.27,98.02 83.59,96.34 83.07,96.34 v1(82.88,96.15)
  BOTTOM w0.076: UC1.B46 141,69.26 140.89,69.37 140.89,69.44 141.07,69.62 141.07,70.54 140.96,70.65 140.96,71.59 141.33,71.96 141.44,71.96 v1(141.66,72.18)
  BOTTOM w0.102: v1(82.88,96.15) 83.09,96.36 83.62,96.36 83.9,96.64 83.9,97.19 CV3.1
EDP_CPU_LANE_P0_C: length 3.1
  BOTTOM w0.102: JEDP1.35 84.39,99.3 84.18,99.09 83.69,99.09 83.65,99.05 83.65,98.87 84.13,98.38 CV3.2
EDP_CPU_LANE_P1: length 107.3
  IN4 w0.086: 144.72,73.39 144.72,73.37 144.72,73.37 144.72,73.32 144.72,73.32 144.72,71.93 143.24,70.45 140.83,70.45 140.36,70.92 140.36,71.04 140.39,71.07 140.39,71.19 140.27,71.32 140.15,71.32 140.12,71.29 139.99,71.29 139.64,71.64 v1(139.64,71.67)
  IN4 w0.089: v1(80.57,96.17) 80.74,96.33 81.6,96.33 81.91,96.64 81.91,97.48 85.28,100.85 85.83,100.85 87.59,102.61 89.83,102.61 90.7,103.48 110.57,103.48 111.03,103.02 135.18,103.02 139.16,99.04 139.16,98.38 139.71,97.84 139.71,97.35 143.26,93.8 143.26,92.45 146.6,89.11 146.6,86.92 146.01,86.32 146.01,85.06 145.59,84.64 145.59,76.47 144.72,75.6 144.72,73.39
  BOTTOM w0.076: v1(139.64,71.67) 139.84,71.47 139.9,71.47 140.22,71.8 140.54,71.8 140.7,71.63 140.7,70.62 140.91,70.42 140.91,69.88 UC1.B47
  BOTTOM w0.102: v1(80.57,96.17) 80.8,96.4 81.42,96.4 81.87,96.84 81.87,97.16 82.14,97.44 CV5.1
EDP_CPU_LANE_P1_C: length 3.3
  BOTTOM w0.102: CV5.2 81.81,98.71 81.81,98.86 82.35,99.39 82.83,99.39 82.84,99.4 83.15,99.71 83.15,99.85 83.39,100.1 JEDP1.37
EN: length 12.9
  TOP w0.203: v3(219.8,61.79) 219.75,61.84 219.35,61.84 219.22,61.97 PU100.20 ; PU100.6 219.22,65.89 219.52,66.18
  TOP w0.254: 219.52,66.18 220.08,66.74 v3(221.17,66.74) 221.72,66.74 PC119.1
  IN1 w0.254: v3(221.17,66.74) 221.02,66.74 220.38,66.11 220.38,62.35 219.8,61.76 v3(219.8,61.79)
  BOTTOM w0.102: v2(221.91,65.85) 222.08,66.03 PR113.2
  BOTTOM w0.254: v3(221.17,66.74) 221.55,67.12 PR113.2
EN_+V1.05SP: length 82.5
  TOP w0.254: RZ42.2 RZ41.2 271.86,64.86 271.86,61.48 271.07,60.7 v1(270.84,60.7)
  IN1 w0.254: v1(246.95,54.89) 246.04,55.81 238.95,55.81 236.17,53.03 236.17,49.56 235.23,48.62 233.69,48.62 230.2,45.13 229.17,45.13 228.13,44.08 226.73,44.08 224.78,42.13 219.62,42.13 218.21,43.54 214.87,43.54 214.24,42.9 v1(214.11,42.9)
  IN3 w0.254: v1(246.95,54.89) 246.95,54.71 247.4,54.27 254.72,54.27 255.13,54.68 259.11,54.68 259.32,54.46 262.41,54.46 263.21,55.26 268.02,55.26 269.79,57.03 269.79,59.64 v1(270.84,60.7)
  BOTTOM w0.102: v1(214.11,42.9) v2(214.11,41.65)
  BOTTOM w0.254: v1(214.11,42.9) PR303.1 214.11,45.18 214.92,45.99 PU300.1
EN_DK_PWRBAR: length 2.9
  BOTTOM w0.254: PU800.17 106.06,55.72 106.11,55.67 106.79,55.67 106.85,55.72 PR874.1 PR857.1
EN_DOCK_PWR_BAR: length 204.8
  TOP w0.102: v2(109.08,55.91) 109.31,55.68 v3(109.69,55.68) ; v1(251.89,75.61) 251.42,75.13 UE1.B37
  IN3 w0.254: v1(251.89,75.61) 251.31,75.02 249.96,75.02 249.42,74.48 248.18,74.48 244.58,70.88 244.58,69.46 238.04,62.92 238.04,56.05 236.56,54.57 236.56,48.83 234.9,47.17 228.69,47.17 222.86,41.34 207.36,41.34 196.79,30.77 184.27,30.77 183.73,31.31 105.88,31.31 104.97,32.23 104.97,37.91 103.1,39.78 103.1,45.72 109.69,52.31 v3(109.69,55.68)
  BOTTOM w0.254: PR857.2 108.79,54.8 109.66,55.68 v3(109.69,55.68)
EN_I2S_NB_CODEC#: length 257.8
  TOP w0.102: UA1.1 30.17,92.61 30.76,92.01 31.92,92.01 v1(32.04,91.89) v2(32.04,91.25) ; UE1.B36 250.92,75.33 251.06,75.47 v1(251.06,75.54)
  IN2 w0.122: v1(251.06,75.54) 250.21,75.54 249.33,74.67 245.2,74.67 244.53,75.34 243.92,75.34 v1(243.57,75.68)
  IN3 w0.122: v1(32.04,91.89) 33.55,93.4 33.55,93.78 34.94,95.16 35.8,95.16 37.01,96.38 37.01,97.1 44.29,104.38 56.98,104.38 57.98,105.37 59.63,105.37 60.22,104.78 63.49,104.78 64.25,105.54 74.25,105.54 74.57,105.22 77.89,105.22 78.24,104.87 97.71,104.87 98.68,103.9 103.99,103.9 105.12,102.77 126.09,102.77 128.39,105.07 133.84,105.07 134.55,104.35 154.52,104.35 154.85,104.02 159.25,104.02 160.08,104.86 187.99,104.86 188.07,104.95 195.64,104.95 207.61,92.98 224.14,92.98 225.25,91.87 234.3,91.87 234.99,92.56 240.26,92.56 241.27,93.58 v1(241.27,93.8)
  BOTTOM w0.102: v1(243.57,75.68) 243.28,75.97 243.28,80.82 242.91,81.19 242.91,81.63 242.27,82.28 242.27,84.54 239.97,86.84 239.97,88.75 241.46,90.25 241.46,93.62 v1(241.27,93.8)
EN_INVPWR: length 214.1
  TOP w0.102: RE55.2 258.1,67.33 257.6,66.83 v1(257.6,66.77) UE2.A25 ; v1(236.49,87.72) v2(236.49,87.09) ; QV2.2 88.57,95.38 88.94,95.75 88.94,96.81 v1(88.72,97.03)
  IN2 w0.122: v1(241.4,61.69) 241.4,62.22 242.32,63.13 245.88,63.13 249.54,66.8 250.92,66.8 251.41,67.3 257.07,67.3 v1(257.6,66.77)
  IN3 w0.122: v1(236.49,87.72) 235.29,87.72 234.3,88.71 224.21,88.71 222.99,89.92 212.21,89.92 210.36,88.08 188.94,88.08 187.87,87.01 169.93,87.01 169.66,87.28 168.96,87.28 168.69,87.55 156.49,87.55 156.09,87.95 156.09,89.63 149.08,96.63 139.26,96.63 138.41,97.48 138.41,99.43 134.98,102.86 128.14,102.86 126.66,101.39 108.27,101.39 105.88,99 102.04,99 100.84,97.79 96.7,97.79 96.01,97.11 88.8,97.11 v1(88.72,97.03)
  BOTTOM w0.102: v1(241.4,61.69) 241.4,63.88 241.31,63.97 241.31,70.36 238.84,72.84 238.84,78.13 239.33,78.63 239.33,84.33 237.83,85.83 237.83,86.38 v1(236.49,87.72)
EN_LCDPWR: length 6.4
  TOP w0.102: v2(79.41,98.24) 79.74,97.91 RV3.2 81.13,97.91 81.17,97.95 DV3.1 82.08,96.07 82.88,95.27 UV24.3
ENVDD_PCH: length 498.9
  TOP w0.102: UE2.A7 263.68,58.75 263.75,58.68 264.21,58.68 264.55,59.02 264.55,59.03 v1(264.58,59.06) ; v1(79.86,94.02) 78.8,95.07 v2(78.8,95.29) 78.8,98.9 79.7,99.8 DV3.3
  IN2 w0.122: v1(85.46,21.01) 85.04,21.43 85.04,36.2 84.21,37.03 84.21,47.79 82.99,49 82.99,55.42 80.52,57.89 80.52,61.96 80.24,62.24 79.21,62.24 74.18,67.27 74.18,72.48 74.18,72.69 74.17,72.69 74.17,73.37 74.17,73.58 72.98,74.76 72.12,74.76 72.12,74.77 63.23,74.77 60.29,77.71 57.81,77.71 55.78,79.75 v1(38.06,79.75)
  IN3 w0.122: v1(169.27,77.59) 170.62,77.59 171.99,78.96 171.99,79.84 171.23,80.6 169.94,80.6 166.53,84 163.61,84 163.34,84.28 160.54,84.28 160.06,84.76 154.74,84.76 151.97,87.54 151.97,89.61 150.8,90.78 145.6,90.78 145.41,90.59 145.16,90.59 145.15,90.58 143.73,90.58 142.95,91.36 139.91,91.36 136.41,94.86 136.41,98.4 136,98.8 134.07,98.8 133.46,99.4 132.67,99.4 131.88,100.19 129.94,100.19 128.16,98.4 116.8,98.4 116.13,97.73 107.76,97.73 105.08,95.05 98.51,95.05 98.09,94.63 98.09,92.85 97.17,91.93 90.44,91.93 89.05,93.31 80.57,93.31 v1(79.86,94.02) 77.09,94.02 74.02,97.09 74.02,98.19 72.38,99.82 60.48,99.82 58.95,98.3 57.21,98.3 56.26,97.35 53.34,97.35 52.51,96.52 51.28,96.52 50.33,97.48 40.68,97.48 38.44,95.24 38.44,91.57 38.13,91.25 38.13,79.81 v1(38.06,79.75) ; v1(85.46,21.01) 85.65,21.01 86.98,19.67 97.04,19.67 99.93,22.57 200.3,22.57 211.64,33.9 226.29,33.9 227.25,34.87 227.25,39.88 229.12,41.75 238.77,41.75 240.03,43.01 240.03,44.17 241.67,45.81 241.67,46.73 243.6,48.66 243.6,49.11 243.41,49.3 243.41,51.45 244.15,52.19 244.15,53.31 245.73,54.89 245.73,55.41 247.1,56.78 248.95,56.78 250.06,55.67 251.49,55.67 252.22,56.4 252.22,57.19 253.83,58.79 259.53,58.79 259.66,58.67 264.19,58.67 v1(264.58,59.06)
  IN4 w0.089: v1(169.27,77.59) 168.88,77.59 167.88,76.58 v1(167.88,75.94)
  BOTTOM w0.076: UC1.C6 165.21,69.43 165.74,69.95 165.74,70.66 167.41,72.33 167.68,72.33 168.26,72.92 168.26,73.39
  BOTTOM w0.102: 168.26,73.39 168.26,74.23 167.88,74.62 v1(167.88,75.94) ; v1(169.27,77.59) 169.77,77.08 RC139.2
ERC1: length 2.2
  BOTTOM w0.254: PU800.3 101.4,61.2 PC815.1
ERC2: length 2.1
  BOTTOM w0.254: PC817.1 106.85,57.72 PU800.13
ERC3: length 3.8
  BOTTOM w0.102: PC816.1 v2(107.29,60.57)
  BOTTOM w0.254: PU800.12 106.39,58.22 PC816.1
EXPRESS_DET#: length 5.2
  TOP w0.102: v1(251.75,83.29) 251.42,83.62 UE1.B15 ; v1(252.08,86.18) 252.08,87.14 T97.1
  BOTTOM w0.102: v1(251.75,83.29) 252.08,83.62 v1(252.08,86.18)
F-IMAX: length 6.3
  TOP w0.127: v2(101.89,75.83) 102.67,75.06 102.67,74.35 v3(103.04,73.98)
  TOP w0.254: v3(103.04,73.98) 103.42,73.6 PR508.2
  BOTTOM w0.203: PU500.10 103.61,73.41 v3(103.04,73.98)
  BOTTOM w0.254: v3(103.04,73.98) 102.65,74.36 PR503.1
FAN1_PWM: length 231.1
  TOP w0.102: RE48.2 260.13,70.13 v1(259.99,69.99) 259.99,69.78 v2(259.63,69.41) ; v1(258.6,66.32) 258.1,65.83 UE2.A24
  IN1 w0.089: v1(87.81,54.48) 87.81,53.19 88.09,52.91 88.09,47.59 87,46.5 87,38.06 87.44,37.62 88.56,37.62 88.95,37.23 88.95,35.78 88.63,35.46 88.63,33.07 90.73,30.98 90.73,28.72 v1(91.62,27.83)
  IN3 w0.122: v1(258.6,66.32) 258.6,66.36 257.72,67.23 253.43,67.23 251.43,65.23 247.91,65.23 245.63,62.96 245.63,61.74 244.75,60.86 241.77,60.86 240.53,59.62 240.53,55.87 239,54.35 239,50.85 238.38,50.24 238.38,47.03 236.35,44.99 230.03,44.99 229.81,45.22 229.14,45.22 223.17,39.25 222.3,39.25 221.48,38.42 208.71,38.42 198.42,28.13 103.68,28.13 102.28,26.73 97.43,26.73 97,26.3 93.14,26.3 v1(91.62,27.83)
  IN4 w0.089: v1(259.99,69.99) 260.01,69.98 260.01,68.67 258.6,67.26 v1(258.6,66.32)
  BOTTOM w0.102: JFAN1.2 88.08,55.01 88.08,54.75 v1(87.81,54.48)
FAN1_TACH: length 238.7
  TOP w0.102: v1(87.33,53.1) 88,53.1 v2(88.05,53.15) ; RE51.2 261.66,70.09 v1(261.84,70.09) ; UE2.B22 259.85,63.72 v1(259.61,63.48)
  IN1 w0.089: v1(91.74,26.8) 90.41,28.13 90.41,30.95 88.37,33 88.37,35.63 88.68,35.94 88.68,37.01 88.37,37.33 87.27,37.33 86.73,37.87 86.73,46.8 87.78,47.86 87.78,52.64 v1(87.33,53.1)
  IN3 w0.122: v1(91.74,26.8) 92.6,25.95 96.35,25.95 96.9,25.4 101.65,25.4 104.08,27.83 198.82,27.83 207.54,36.54 217.3,36.54 218.28,35.56 222.99,35.56 225.4,37.97 225.4,40.42 228.59,43.61 230.25,43.61 230.88,44.25 236.66,44.25 239.16,46.75 239.16,49.6 239.75,50.18 239.75,51.5 240.54,52.3 240.54,54.72 243.6,57.77 244.63,57.77 245.7,58.84 245.7,59.35 247.1,60.75 251.84,60.75 252.33,61.24 252.33,62.35 252.91,62.93 252.91,63.31 253.95,64.35 258.74,64.35 v1(259.61,63.48)
  IN4 w0.089: v1(261.84,70.09) 262.8,69.13 262.8,65.84 261.58,64.62 259.98,64.62 259.61,64.25 v1(259.61,63.48)
  BOTTOM w0.102: JFAN1.3 89.16,55.63 89.16,54.06 88.21,53.11 87.34,53.11 v1(87.33,53.1)
FB_3V: length 4
  TOP w0.203: PU100.4 220.55,64.25 v3(221.15,64.84)
  TOP w0.254: PR102.2 v3(221.15,64.84)
  BOTTOM w0.102: v2(222.03,63.82) 222.03,64.63 PR102.2
  BOTTOM w0.254: PR102.2 v3(221.15,64.84)
FB_5V: length 4.3
  TOP w0.203: v3(221.15,62.8) 221.15,63.06 220.76,63.45 PU100.2
  TOP w0.254: PR104.1 v3(221.15,62.8)
  BOTTOM w0.102: v2(221.27,61.79) 221.83,62.35 PR104.1
  BOTTOM w0.254: PR104.1 v3(221.15,62.8)
FB_+V1.05SP: length 7.8
  TOP w0.102: v3(218.16,42.8) 218.61,42.36 v2(218.73,42.36)
  TOP w0.254: v3(218.16,42.8) 218.17,42.81 PR310.1 217.26,44.41 PR309.2
  IN3 w0.254: v3(218.16,42.8) 218.16,43.8 v1(216.81,45.15)
  BOTTOM w0.254: v3(218.16,42.8) 218.17,42.81 PR310.1 ; v1(216.81,45.15) 216.27,45.7 PU300.4
FFS_INT2: length 156.4
  TOP w0.102: v1(284.54,72.86) v2(283.91,72.86) ; QN1.2 281.17,59.74 282.23,59.74 282.77,60.28
  TOP w0.305: v1(282.84,60.35) 282.77,60.28 282.77,59.91 282.93,59.74 UN1.9
  IN2 w0.122: v1(284.54,72.86) 284.39,72.71 284.39,71.54 283.51,70.67 283.51,61.03 v1(282.84,60.35)
  IN3 w0.122: v1(186.35,70.8) 186.19,70.96 185.27,70.96 181.85,67.54 175.5,67.54 v1(172.9,64.94) ; v1(261.61,75.91) 261.95,75.57 266.8,75.57 267.63,74.74 272.15,74.74 276.27,70.62 281.1,70.62 283.43,72.95 284.45,72.95 v1(284.54,72.86)
  IN4 w0.089: v1(186.35,70.8) 186.47,70.68 187.24,70.68 187.74,70.17 189.78,70.17 203.61,83.99 221.74,83.99 222.02,83.71 230.63,83.71 231.5,82.84 238.35,82.84 238.82,83.31 243.79,83.31 245.38,81.73 248.35,81.73 248.35,81.65 250.08,79.92 251.85,79.92 252.74,79.04 257.59,79.04 259.52,77.1 259.52,76.96 259.99,76.49 261.11,76.49 261.61,76 v1(261.61,75.91)
  BOTTOM w0.076: UC1.G2 168.62,66.3 169.71,66.3 170.06,65.95 170.65,65.95
  BOTTOM w0.102: 170.65,65.95 171.89,65.95 v1(172.9,64.94) 173.36,65.39 174.02,65.39 174.92,64.49 178.49,64.49 178.57,64.58 RC158.2
FFS_INT2_Q: length 50.2
  TOP w0.102: QN1.3 281.76,60.41 282.04,60.68 282.04,62.02 v1(281.97,62.09) RN1.2
  IN1 w0.089: v1(302.36,61.6) 302.16,61.8 282.26,61.8 v1(281.97,62.09)
  IN2 w0.122: v1(304.38,47.07) 304.62,47.31 304.62,54.97 304.06,55.53 304.06,59.51 302.36,61.22 v1(302.36,61.6)
  BOTTOM w0.102: JSATA1.19 312,42.24 v2(311.56,42.69) 307.17,47.07 v1(304.38,47.07)
FWP#: length 10.2
  TOP w0.102: v1(259.84,56.15) 260.02,55.97 260.02,55.97 260.26,55.73 260.26,55.73 260.35,55.64 UE2.B65 ; v1(262.25,52.57) 262.69,52.57 RE82.2 RE81.2
  IN4 w0.089: v1(259.84,56.15) 260.39,55.6 260.39,53.56 261.33,52.62 262.2,52.62 262.25,52.57 v1(262.25,52.57)
  BOTTOM w0.102: v2(260.44,56.5) 260.2,56.5 v1(259.84,56.15)
GC6_EVENT#_Q: length 20.8
  TOP w0.102: v2(182.65,64.11) 182.9,64.37 v1(182.9,64.57)
  IN4 w0.086: v1(165.33,62.44) 165.84,61.92 168.72,61.92 169.29,62.5 171.34,62.5 171.52,62.67 171.57,62.67 171.62,62.73 171.77,62.73
  IN4 w0.089: v1(182.9,64.57) 182.47,64.14 182.19,64.14 182.02,63.97 180.44,63.97 180.02,63.55 177.2,63.55 177.18,63.53 174.45,63.53 173.9,62.98 172.16,62.98 171.91,62.73 171.77,62.73
  BOTTOM w0.076: v1(165.33,62.44) 165.7,62.07 UC1.R6
  BOTTOM w0.102: RPC4.8 v1(182.9,64.57)
GFB: length 2.5
  BOTTOM w0.203: 107.58,69.43 107.27,69.74 PU500.23
  BOTTOM w0.254: PR532.2 v2(107.99,69.41) 107.63,69.41 107.61,69.43 107.58,69.43
GPIO_PSID_SELECT: length 259.1
  TOP w0.102: UE1.A6 255.67,85.8 v1(255.82,85.94)
  IN3 w0.122: v1(37.49,80.43) 37.87,80.81 37.87,91.42 38.19,91.73 38.19,95.49 40.46,97.77 49.35,97.77 50.19,98.61 55.36,98.61 55.75,99 58.66,99 60.19,100.52 74.25,100.52 74.82,99.95 74.82,97.45 76.56,95.71 88.16,95.71 89.28,96.83 96.09,96.83 96.76,97.5 100.94,97.5 102.13,98.69 105.93,98.69 108.38,101.14 126.76,101.14 128.24,102.62 134.88,102.62 138.16,99.33 138.16,97.38 139.57,95.97 142.2,95.97 143.11,95.06 145.84,95.06 146.76,95.99 149.38,95.99 155.84,89.52 155.84,87.85 156.39,87.3 168.28,87.3 168.59,86.99 169.45,86.99 169.91,86.53 189.59,86.53 190.72,87.66 210.39,87.66 211.32,88.59 222.39,88.59 223.32,87.66 225.7,87.66 226.56,86.8 233.81,86.8 234.24,86.36 239.88,86.36 241.27,84.97 247.96,84.97 248.45,84.49 254.51,84.49 255.82,85.79 v1(255.82,85.94)
  BOTTOM w0.254: v1(37.49,80.43) 37.88,80.83 v2(38.52,80.83) 40.31,80.83 40.6,80.53 PU1.6
GPU_GC6_FB_EN: length 25.4
  TOP w0.102: v2(186.6,67.12) 186.93,66.79 v1(186.93,66.41)
  IN4 w0.086: 170.65,66.07 168.96,66.07 167.74,64.85 166.55,64.85 166.05,64.35 v1(165.97,64.35)
  IN4 w0.089: v1(186.93,66.41) 186.5,65.98 185.13,65.98 183.61,67.5 181.93,67.5 181.33,66.9 181.26,66.9 181.03,66.67 172.82,66.67 172.23,66.07 170.65,66.07
  BOTTOM w0.076: v1(165.97,64.35) 165.7,64.07 UC1.L6
  BOTTOM w0.102: v1(186.93,66.41) 186.93,66.36 187.19,66.1 RPC15.3
GPU_SMBCLK: length 8
  TOP w0.102: v1(251.79,52.17) 251.64,52.02 251.64,51.56 252.02,51.19 RPE3.4 ; UE2.B49 253.5,56.5 253.73,56.73 v1(253.98,56.73)
  IN4 w0.089: v1(251.79,52.17) 251.79,54.54 v1(253.98,56.73)
GPU_SMBDAT: length 10
  TOP w0.102: v1(254.06,57.32) 253.78,57.32 253.47,57 UE2.B48 ; RPE3.3 253.01,51.2 253.01,51.61 252.75,51.87 252.3,51.87 252.11,51.68 252.11,51.66 v1(252.12,51.66)
  IN4 w0.089: v1(254.06,57.32) 253.9,57.32 251.26,54.68 251.26,52.07 251.66,51.66 v1(252.12,51.66)
GREEN: length 11.6
  TOP w0.102: LV17.2 257.54,107.38 257.46,107.46 CV55.1 257.09,107.94 257.29,108.14 DV5.3 257.29,110.73 258.71,112.16 v2(258.71,114.01) 258.71,115.5 JCRT1.2
GREEN_2320: length 21.8
  TOP w0.102: UV8.M7 160.75,90.18 161.48,89.45 v1(161.48,89.11) 161.48,88.72 161.84,88.37 RV77.1 ; UV16.2 176.49,91.76 v1(176.28,91.54)
  BOTTOM w0.102: v1(176.28,91.54) 176.01,91.54 174.83,90.36 170.19,90.36 169.27,89.44 164.72,89.44 163.84,90.31 162.73,90.31 161.52,89.11 v1(161.48,89.11)
GREEN_CRT: length 93.4
  TOP w0.102: v1(176.47,96.69) 176.47,96.52 176.89,96.1 UV16.25 ; LV17.1 258.1,105.95 258.05,105.9 CV52.1 RV33.1 258.1,104.41 258.1,98.94 v1(258.56,98.48)
  IN1 w0.089: v1(176.47,96.69) 176.47,96.55 177.03,95.99 195.86,95.99 196.89,97.02 229.42,97.02 230.31,97.91 242.34,97.91 242.79,98.35 249.44,98.35 249.78,98.01 256.98,98.01 257.45,98.48 v1(258.56,98.48)
GREEN_DOCK: length 24.7
  TOP w0.102: UV16.24 177.29,96.29 v1(177.06,96.52)
  IN4 w0.089: v1(177.06,96.52) 177.2,96.66 177.2,99.21 172.74,103.67 171.41,103.67 169.53,105.55 169.53,105.58 167.69,107.42 167.06,107.42 166.7,107.79 163.22,107.79 163.2,107.81 163.16,107.81 162.3,108.67 162.3,108.71 162.18,108.83 v1(162.18,108.93)
  BOTTOM w0.102: JDOCK1.59 161.4,109.37 161.84,108.93 v1(162.18,108.93)
H_CATERR#: length 14.7
  TOP w0.076: 126.37,64.07 127.8,64.07 128.29,64.56 128.29,64.83 v1(128.42,64.96)
  TOP w0.102: v2(120.64,60.54) RC114.2 121.21,61.53 121.35,61.39 122.94,61.39 125.62,64.07 126.37,64.07
  BOTTOM w0.076: v1(128.42,64.96) 128.42,64.79 129.09,64.12 130,64.12 130.13,64.26 130.48,64.26 130.68,64.47 130.68,64.64 130.88,64.84 131.4,64.84 UC1.K61
H_CPU_SVIDALRT#: length 15.7
  TOP w0.102: RC207.1 119.25,58.49 v1(119.08,58.31)
  IN2 w0.086: 126.4,61.23 128.3,61.23 128.6,61.53 130.02,61.53 130.19,61.7 130.19,62.93 v1(130.68,63.43)
  IN2 w0.122: 126.4,61.23 124.28,61.23 121.89,58.84 120.07,58.84 119.53,58.31 v1(119.08,58.31)
  BOTTOM w0.076: v1(130.68,63.43) 130.68,63.48 UC1.L62
H_CPUPWRGD: length 80.5
  TOP w0.102: RC103.1 89.48,27.24 v1(88.89,27.84) ; v1(122.47,63.55) 121.5,62.59 CC83.1 RC123.1
  IN2 w0.086: v1(131.27,70.93) 130.14,69.8 130.14,64.33 129.93,64.12 127.86,64.12 127.5,64.48 127.45,64.48
  IN2 w0.122: 127.45,64.48 125.58,64.48 125.43,64.33 123.29,64.33 122.52,63.55 v1(122.47,63.55)
  IN4 w0.089: v1(122.47,63.55) 123.18,62.84 123.18,61.75 123.29,61.64 123.29,57.51 121.68,55.91 121.08,55.91 119.07,53.9 117.64,53.9 113.07,49.33 113.07,38.93 109.64,35.5 106.17,35.5 104.91,34.24 99.64,34.24 97.87,32.48 97.53,32.48 97.03,31.97 97.03,31.09 96.15,30.22 94.16,30.22 92.37,28.43 89.47,28.43 v1(88.89,27.84)
  BOTTOM w0.076: v1(131.27,70.93) 131.5,70.93 131.94,70.49 131.94,69.85 132,69.79 132,69.02 UC1.C61
H_PROCHOT#: length 255.8
  TOP w0.102: v3(70.71,79.35) 69.53,78.17 69.53,77 69.68,76.85 71.82,76.85 72.53,76.14 PR717.1 ; v1(251.69,56.73) 251.71,56.75 UE2.A46 ; PC514.2 104.58,64.71 v1(104.37,64.49) ; v1(112.55,74.13) 112.55,67.25 v1(113.55,66.25) 114.54,65.26 CC20.1 RC116.2 114.54,63.46 RC121.1
  IN2 w0.122: v1(85.56,74.55) 85.67,74.44 85.67,71.8 89.4,68.07 92.34,68.07 95.27,65.15 103.71,65.15 v1(104.37,64.49) 104.63,64.75 112.62,64.75 113.55,65.69 v1(113.55,66.25) ; v1(149.05,85.26) 149.06,85.24 163.43,85.24 164.19,84.48 169.53,84.48 169.7,84.65 175.3,84.65 175.71,84.23 176.82,84.23 177.31,84.71 188.74,84.71 190.65,86.63 195.21,86.63 199.6,91.02 209.62,91.02 209.92,90.72 219.92,90.72 223.37,87.26 224.14,87.26 226.25,85.16 227.15,85.16 234.73,77.57 234.73,77.26 238.7,73.3 238.7,72.91 239.76,71.85 244.28,71.85 244.65,72.21 v1(247.02,72.21) ; v1(112.55,74.13) 112.74,74.13 114.71,76.1 120.56,76.1 122.33,74.34 130.92,74.34 131.74,75.15 133.36,75.15 134.25,76.04 144.34,76.04 144.89,76.6 147.26,76.6 147.69,77.03 147.69,79.04 148.54,79.9 v1(148.54,80.65)
  IN4 w0.089: v3(70.71,79.35) 71.42,80.06 71.42,81.22 73.11,82.91 83.35,82.91 84.77,81.49 84.77,75.34 v1(85.56,74.55) ; v1(149.05,85.26) 149.05,82.44 148.58,81.97 148.58,80.69 v1(148.54,80.65)
  BOTTOM w0.102: PR534.1 103.92,64.95 104.38,64.49 v1(104.37,64.49) ; v1(247.02,72.21) 247.02,71.27 247.99,70.3 247.99,64.87 249.36,63.5 249.36,61.11 250.9,59.58 251.41,59.58 251.97,59.02 251.97,57.01 v1(251.69,56.73)
H_PROCHOT#_R: length 17.8
  TOP w0.102: v1(118.49,63.4) 118.14,63.05 115.04,63.05 RC121.2
  IN2 w0.086: v1(129.78,64.48) 129.78,64.48 128.51,65.75 127.45,65.75
  IN2 w0.122: v1(118.49,63.4) 118.6,63.29 119.27,63.29 119.32,63.34 120.35,63.34 122.76,65.75 127.45,65.75
  BOTTOM w0.076: UC1.K63 130.29,64.48 v1(129.78,64.48)
H_THERMTRIP#: length 171.4
  TOP w0.102: v1(125.21,69.5) 125.01,69.5 121.2,65.69 121.2,65.14 RC161.1 RC25.2 ; v1(239.47,75.19) 241.27,73.38 241.27,72.3 241.67,71.91 242.87,71.91 243,71.78 245.21,71.78 246.28,70.72 246.28,67.19 246.74,66.73 QE4.3
  IN1 w0.086: 127.45,69.5 128.34,70.39 135.56,70.39 136.58,71.4 137.6,71.4 138.16,71.96 138.16,73.39
  IN1 w0.089: 138.16,73.39 138.16,75.02 139.76,76.62 139.76,84.14 138.77,85.13 138.77,90.63 v1(138.8,90.66) ; v1(125.21,69.5) 127.45,69.5
  IN2 w0.122: v1(138.8,90.66) 139.27,91.13 142.11,91.13 142.4,91.41 143.04,91.41 143.33,91.13 144.69,91.13 145.63,90.19 150.74,90.19 151.33,89.6 154.83,89.6 156.18,88.24 156.18,87.81 156.77,87.22 167.1,87.22 168.28,86.05 169.04,86.05 169.28,86.29 178.92,86.29 179.16,86.05 186.89,86.05 188.84,88 193.66,88 198.59,92.93 210.36,92.93 210.7,92.59 221.58,92.59 235.34,78.83 235.99,78.83 239.47,75.35 v1(239.47,75.19)
H_THERMTRIP#_R: length 15.9
  TOP w0.076: v1(131.48,69.08) 130.42,70.14 v2(129.62,70.14) 127.45,70.14
  TOP w0.102: 127.45,70.14 124.75,70.14 120.61,66 120.61,65.47 RC161.2
  BOTTOM w0.076: UC1.D60 132.11,68.43 131.51,69.04 131.51,69.05 v1(131.48,69.08)
H_VCCST_PWRGD: length 159.1
  TOP w0.076: 165.77,38.35 165.77,39.31 165.21,39.87 165.21,40.54 165.6,40.92 165.6,41.16 ; 165.6,41.16 RC202.1 166.35,41.86 UC8.4 ; 165.6,41.16 165.6,41.52 165.57,41.54 CC24.1
  TOP w0.102: v1(90.77,32.77) 90.3,32.3 90.3,29.06 RC102.1 ; 165.77,38.35 v1(165.77,37.96)
  IN2 w0.086: 127.45,71.57 130.35,71.57 v1(130.66,71.87)
  IN2 w0.122: v1(103.89,32.93) 104.28,32.93 109.19,37.85 111.86,37.85 117.58,43.56 118.75,43.56 121.04,45.86 121.04,48.84 118.74,51.15 117.18,51.15 114.2,54.13 114.2,63.53 114.38,63.71 114.38,66.42 115.25,67.29 120.42,67.29 124.7,71.57 127.45,71.57
  BOTTOM w0.076: 132.3,71.14 132.75,70.68 132.75,69.98 133.08,69.65 UC1.B59
  BOTTOM w0.102: v1(130.66,71.87) 131.56,71.87 132.3,71.14 ; v1(165.77,37.96) 163.37,35.56 111.69,35.56 109.06,32.93 v1(103.89,32.93) 103.76,33.06 102.72,33.06 101.52,34.25 94.41,34.25 92.7,32.54 91,32.54 v1(90.77,32.77)
H_VCCST_PWRGD_XDP: length 4.4
  TOP w0.102: RC102.2 RC103.2 v2(91.38,27.24) 92.21,27.24 92.43,27.03 JXDP1.39
H_VR_EN: length 53.8
  TOP w0.076: v1(130.61,70.84) 131.88,69.57 131.88,68.84 131.53,68.49 131.53,67.74 131.7,67.58 132.23,67.58 132.58,67.24
  TOP w0.089: 132.58,67.24 v1(132.66,67.15)
  TOP w0.102: v1(112.32,65.84) v2(112.32,66.39)
  IN2 w0.086: 127.45,72.51 130.68,72.51 131.25,71.94 131.25,71.49 v1(130.61,70.84)
  IN2 w0.122: 127.45,72.51 124.43,72.51 119.99,68.07 114.19,68.07 112.32,66.21 v1(112.32,65.84)
  IN2 w0.254: v3(98.72,74.23) 99.11,74.23 100.18,73.17 100.18,68.09 102.3,65.97 106.69,65.97 106.82,65.84 v1(112.32,65.84)
  BOTTOM w0.076: UC1.F60 132.31,66.79 v1(132.66,67.15)
  BOTTOM w0.102: PR536.1 v3(98.72,74.23) ; v1(112.32,65.84) 112.32,64.02 112.77,63.57 RC201.2
H_VR_READY: length 48.2
  TOP w0.102: v2(99.48,70.81) 99.1,70.81 v3(98.72,71.19)
  IN2 w0.086: 127.45,72.08 128,72.08 v1(128.05,72.02)
  IN2 w0.122: v3(98.72,71.19) 99.3,70.6 99.3,68.52 102.17,65.65 106.29,65.65 106.69,65.26 112.32,65.26 112.74,65.67 112.74,65.67 v1(112.9,65.84) 112.9,66.44 114.27,67.81 120.08,67.81 124.35,72.08 127.45,72.08
  BOTTOM w0.076: v1(128.05,72.02) 128.6,71.48 131.67,71.48 132.59,70.56 132.59,69.91 132.69,69.81 132.69,69.78 132.7,69.76 132.7,69.46 133.08,69.08 UC1.C59
  BOTTOM w0.102: RC201.1 RC199.2 114.54,65.03 113.73,65.84 v1(112.9,65.84)
  BOTTOM w0.254: PR539.2 v3(98.72,71.19)
HDD_A_EQ: length 9
  TOP w0.102: v1(299.25,59.21) 299.25,60 RN12.1 299.45,61.13 RN13.2 298.48,61.28 v2(298.35,61.15) ; UN2.17 295.94,60.51 v1(296.3,60.87)
  IN1 w0.089: v1(299.25,59.21) 299.25,60.48 299.09,60.65 296.53,60.65 v1(296.3,60.87)
HDD_A_EQ2: length 7.3
  TOP w0.102: RN25.1 RN24.2 290.79,60.82 v1(291.27,61.31) ; UN2.18 v1(295.44,60.7)
  IN1 w0.089: v1(291.27,61.31) 294.83,61.31 v1(295.44,60.7)
HDD_A_PRE: length 4.5
  TOP w0.102: UN2.9 295.94,54.81 295.77,54.64 295.77,54.04 RN9.2 RN8.2 298.18,53.61 v2(298.23,53.66)
HDD_B_EQ: length 4.7
  TOP w0.102: UN2.19 294.94,60.51 294.81,60.65 v2(294.81,61.15) 294.81,61.56 295.59,62.35 RN16.2 RN14.2
HDD_B_EQ2: length 5.9
  TOP w0.102: RN22.2 RN23.1 300.77,56.58 300.95,56.76 v2(300.95,56.87) 300.95,56.9 300.13,57.72 UN2.13
HDD_B_PRE: length 3.3
  TOP w0.102: UN2.8 v2(295.44,54.52) 295.19,54.27 RN11.2 RN10.1
HDD_DET#: length 196.8
  TOP w0.102: v1(200.61,54.66) 200.83,54.45 v2(200.83,54.04)
  IN1 w0.089: v1(309,39.47) 306.93,37.4 293.64,37.4 293.38,37.15 289.9,37.15 288.99,36.24 278.74,36.24 278.26,36.72 270.74,36.72 v1(270.65,36.63)
  IN2 w0.122: v1(177.79,57.83) 177.79,57.46 178.31,56.94 178.98,56.94 180.59,55.33 180.59,54.25 181.44,53.39 183.29,53.39 185.33,55.44 185.82,55.44 186.31,54.95 186.74,54.95 189.28,52.4 192.1,52.4 194.28,54.59 200.53,54.59 v1(200.61,54.66) ; v1(199.36,36.77) 199.82,36.31 215.68,36.31 217.7,34.29 226.42,34.29 234.71,42.58 234.71,43.37 239.15,47.81 239.15,48.98 240.94,50.76 243.97,50.76 244.79,49.94 245.76,49.94 246.35,50.53 250.55,50.53 252.36,48.72 256.31,48.72 256.6,48.43 258.89,48.43 260.11,47.21 260.11,47 260.4,46.71 265.57,46.71 266.39,47.54 271.01,47.54 271.92,46.62 271.92,43.07 270.65,41.8 v1(270.65,36.63)
  IN3 w0.122: v1(199.36,36.77) 199.36,37.16 200.91,38.71 200.91,53.56 200.61,53.87 v1(200.61,54.66)
  BOTTOM w0.089: 170.83,60.87 169.09,60.87 UC1.U1
  BOTTOM w0.102: 177.79,57.67 176.94,57.67 175.21,59.4 173.52,59.4 172.1,60.82 170.88,60.82 170.83,60.87 ; 177.79,57.67 v1(177.79,57.83) ; 177.79,57.67 177.79,57.52 178.19,57.11 178.69,57.11 179.05,57.47 RPC17.6 ; v1(309,39.47) JSATA1.13
HDD_DEVSLP: length 188.1
  TOP w0.102: v2(187.46,71.26) 187.97,70.75 v1(187.97,70.7)
  IN1 w0.089: v1(308,39.49) 306.26,37.75 297.69,37.75 297.32,38.12 v1(296.94,38.12) 296.81,37.99 293.95,37.99 292.25,39.69 v1(287.78,39.69)
  IN3 w0.122: v1(187.97,70.7) 187.15,70.7 186.54,71.31 185.12,71.31 181.65,67.83 175.18,67.83 v1(172.3,64.95)
  IN4 w0.089: v1(187.97,70.7) 188.29,71.02 188.58,71.02 201.77,84.21 221.86,84.21 222.14,83.93 230.74,83.93 231.61,83.06 238.26,83.06 238.73,83.53 243.94,83.53 245.51,81.96 248.47,81.96 249.49,80.94 251.98,80.94 252.88,80.04 257.54,80.04 258.21,79.37 258.76,79.37 260.67,77.46 261.16,77.46 261.57,77.05 261.57,76.62 262.03,76.16 262.03,75.19 262.23,74.98 262.23,72.37 264.88,69.71 269.7,69.71 272.16,67.25 272.16,64.92 273.55,63.53 273.55,59.02 275.48,57.08 275.48,50.18 275.2,49.89 275.2,48.21 275.5,47.91 275.5,41.56 276.78,40.29 287.19,40.29 v1(287.78,39.69)
  BOTTOM w0.076: UC1.L2 168.33,63.91 168.64,64.21 168.77,64.21 168.79,64.23 169.31,64.23 ; 170.19,64.38 170.36,64.54 171.77,64.54
  BOTTOM w0.089: 169.31,64.23 169.43,64.35 169.43,64.35 169.46,64.38 170.19,64.38
  BOTTOM w0.102: 171.77,64.54 171.81,64.54 172.21,64.95 v1(172.3,64.95) ; v1(296.94,38.12) 296.67,38.12 296.46,38.33 RN5.2 ; v1(308,39.49) JSATA1.11
HDD_FALL_INT: length 167.7
  TOP w0.305: UN1.11 282.79,58.74 282.74,58.79 282.02,58.79 281.83,58.98 v1(281.83,59.24)
  IN1 w0.089: v1(261.02,76) 261.67,76.65 270.04,76.65 273.98,80.58 283.35,80.58 v1(283.85,81.08)
  IN2 w0.122: v1(283.85,81.08) 284.06,80.86 284.06,71.56 283.18,70.69 283.18,61.38 281.83,60.02 v1(281.83,59.24)
  IN4 w0.086: 171.77,63.58 171.68,63.58 171.64,63.62 169.96,63.62 169.68,63.34 169.03,63.34 168.81,63.11 167.56,63.11 167.34,62.89 v1(167.34,62.65)
  IN4 w0.089: v1(261.02,76) 261.01,76 260.92,76.09 260.06,76.09 257.32,78.83 252.14,78.83 251.29,79.67 249.77,79.67 248.63,80.81 248.04,80.81 247.43,80.2 246.07,80.2 243.88,82.39 241.46,82.39 241.14,82.07 240.17,82.07 239.01,80.91 231.56,80.91 229.97,82.51 211.62,82.51 211.49,82.64 208.63,82.64 207.84,81.84 203.98,81.84 203.77,81.63 203.55,81.63 193.76,71.84 193.76,64.94 191.67,62.84 189.44,62.84 187.33,60.73 186.76,60.73 186.36,61.13 v1(186.36,61.17) 186.36,61.2 186.02,61.55 185.72,61.55 184.24,63.02 184.24,63.8 183.06,64.98 180.81,64.98 180.46,64.64 177.59,64.64 176.92,63.97 174.16,63.97 173.79,63.59 173.75,63.59 173.74,63.58 171.77,63.58
  BOTTOM w0.076: v1(167.34,62.65) 167.34,62.68 167.03,62.98 UC1.N4
  BOTTOM w0.102: RPC18.6 186.73,61.54 v1(186.36,61.17) ; v2(262.17,75.38) 261.53,75.38 261.02,75.89 v1(261.02,76)
HDMI_CEC: length 16.7
  TOP w0.102: v2(103.29,110.56) 103.07,110.56 v1(102.7,110.19) RV8.2
  IN1 w0.089: JHDMI1.13 92.11,112.31 93.92,112.31 94.45,111.78 94.45,110.09 95.69,108.84 101.36,108.84 v1(102.7,110.19)
