# Allegro board Houston14_UMA_DOCK_BRD_A00_20140716.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
TMDS_CON_N2: length 9.2
  TOP w0.102: v1(88.32,110.22) 88.32,110.21 88.52,110.02 88.52,109.76 88.21,109.46 LV12.3
  IN4 w0.089: JHDMI1.3 86.19,113.22 86.13,113.22 84.9,111.99 84.9,110.71 85.63,109.98 87.12,109.98 87.43,109.67 88.32,109.67 88.49,109.84 88.49,110.05 88.49,110.05 v1(88.32,110.22)
TMDS_CON_P0: length 13.5
  TOP w0.102: LV6.2 86.58,108.42 86.27,108.73 86.27,108.86 86.64,109.24 v1(86.65,109.24)
  IN1 w0.089: JHDMI1.7 88.61,112.8 88.61,112.72 88.5,112.6 85.43,112.6 84.56,111.73 84.56,110.43 85.14,109.85 86.76,109.85 87.17,109.44 87.17,108.87 86.86,108.55 86.45,108.55 86.32,108.67 86.32,109.15 86.41,109.24 v1(86.65,109.24)
TMDS_CON_P1: length 7.7
  TOP w0.102: JHDMI1.4 87.13,111.28 87.13,111.11 87.39,110.86 89,110.86 89.66,110.2 89.66,109.6 89.91,109.35 90.31,109.35 90.33,109.33 90.9,109.33 90.92,109.35 91.34,109.35 91.53,109.16 91.53,108.98 91.17,108.63 LV9.3
TMDS_CON_P2: length 9.4
  TOP w0.102: v1(88.9,110.22) 88.72,110.05 88.72,109.79 89.06,109.46 LV12.2
  IN4 w0.089: JHDMI1.1 85.2,112.53 84.73,112.06 84.73,110.64 85.56,109.81 87.05,109.81 87.36,109.5 88.39,109.5 88.66,109.77 88.66,109.98 88.66,109.98 v1(88.9,110.22)
TMDS_N0_C: length 2.9
  TOP w0.102: CV18.1 86.02,104.32 86.02,104.42 85.68,104.76 RV15.1 86.03,105.2 86.03,105.65 85.73,105.95 LV6.4
TMDS_N1_C: length 2.9
  TOP w0.102: LV9.1 91.74,105.96 91.74,105.18 RV13.1 91.76,104.47 91.76,104.19 92.05,103.9 CV21.1
TMDS_N2_C: length 3
  TOP w0.102: CV29.1 88.71,105.15 88.71,105.39 88.38,105.73 RV11.1 88.59,105.99 88.59,106.46 88.21,106.84 LV12.4
TMDS_P0_C: length 2.9
  TOP w0.102: LV6.1 86.58,105.98 86.24,105.63 86.24,105.14 RV14.1 86.54,104.73 86.23,104.42 86.23,104.32 CV17.1
TMDS_P1_C: length 2.9
  TOP w0.102: LV9.4 91.53,105.88 91.53,105.11 RV12.1 91.49,104.56 91.49,104.33 CV22.1
TMDS_P2_C: length 2.9
  TOP w0.102: CV28.1 88.93,105.26 88.93,105.42 89.19,105.69 RV10.1 88.8,106.13 88.8,106.36 89.06,106.62 LV12.1
TOUCH_PANEL_INTR#: length 131.7
  IN1 w0.089: v1(134.32,99.7) 134.05,99.96 134.05,100.17 132.21,102.01 128.25,102.01 125.02,98.78 119.48,98.78 117.73,97.03 110.24,97.03 108.93,95.72 103.24,95.72 100.63,98.33 100.01,98.33 v1(99.14,99.2)
  IN2 w0.122: v1(134.32,99.7) 135.64,99.7 136.59,98.75 136.59,92.69 137.36,91.91 137.36,89.75 138.49,88.62 143.56,88.62 145.3,86.88 145.3,83.33 145.6,83.03 145.6,82.06 146.01,81.65 147.15,81.65 147.72,82.22 149.13,82.22 150.16,81.18 150.16,79.09 150.12,79.05 150.12,77.37 152.43,75.06 154.26,75.06 154.76,74.56 157.4,74.56 157.54,74.42 163.93,74.42 166.37,76.86 167.38,76.86 168.56,78.03 170.23,78.03 171.64,76.62 171.64,74.37 171.41,74.15 171.41,69.32 169.8,67.71 169.8,65.94 169.13,65.27 169.13,64.61 169.52,64.23 170.33,64.23 v1(171.35,63.21)
  BOTTOM w0.076: 171.77,62.79 v1(171.35,63.21) 171.3,63.16 171.3,63.12 170.93,62.75 169.42,62.75 169.23,62.57 168.77,62.57 168.65,62.45 168.65,62.06 168.49,61.9 168.02,61.9 168.02,61.89 UC1.P3
  BOTTOM w0.102: RPC16.5 v2(177.51,59.77) 175.84,61.45 173.44,61.45 172.14,62.75 171.81,62.75 171.77,62.79 ; v1(99.14,99.2) 99.39,99.46 JEDP1.5
TOUCH_SCREEN_PD#: length 5.2
  TOP w0.102: v1(258.29,77.16) 258.51,76.94 UE1.B55 ; v1(261,74.96) 261.02,74.93 T96.1
  IN2 w0.122: v1(261,74.96) 259.94,76.01 259.44,76.01 v1(258.29,77.16)
TOUCHPAD_INTR#: length 22.6
  IN4 w0.086: 171.77,60.83 171.56,60.63 167.15,60.63 166.75,61.03 166.15,61.03 165.7,61.48 165.7,61.67 165.38,61.99 165.18,61.99 v1(164.72,62.45)
  IN4 w0.089: 171.77,60.83 172.5,61.57 177.33,61.57 177.7,61.21 181.73,61.21 v1(182.44,61.92)
  BOTTOM w0.076: v1(164.72,62.45) 164.72,61.45 165.05,61.13 UC1.U7
  BOTTOM w0.102: v1(182.44,61.92) 182.44,61.76 183.18,61.02 RPC3.7
TP_DC_TEST_B2: length 9.9
  BOTTOM w0.254: RC192.2 172,76.3 172.38,75.92 v2(172.38,72.3) 169.91,69.84 168.59,69.84 UC1.B2
TP_LAN_JTAG_TCK: length 2.7
  TOP w0.102: RL2.2 282.94,88.46 282.2,87.72 UL1.35
TP_LAN_JTAG_TDI: length 2.6
  TOP w0.102: T88.1 283.5,86.68 282.26,86.68 282.1,86.52 UL1.32
TP_LAN_JTAG_TDO: length 1.6
  TOP w0.102: UL1.34 282.13,87.32 282.63,87.82 T89.1
TP_LAN_JTAG_TMS: length 2.4
  TOP w0.102: UL1.33 282.08,86.92 282.09,86.91 284.04,86.91 RL1.2
TPM_PIRQ#: length 56.8
  TOP w0.102: UZ1.20 189.58,64.29 190.14,64.85 190.78,64.85 191.25,65.32 191.25,66.54 190.68,67.11 v1(190.68,67.31) 190.68,67.46 191.63,68.42 v2(191.63,69.23) ; v1(173.98,56.23) 173.98,55.88 RC247.1
  IN3 w0.086: 171.77,62.72 169.98,62.72 168.43,61.16 v1(168,61.16) 167.21,61.95 164.69,61.95 162.83,60.09 162.83,58.44 164,57.27 169.06,57.27 169.28,57.05 171.77,57.05
  IN3 w0.122: v1(190.68,67.31) 190.22,67.77 189.53,67.77 188.85,67.08 185.56,67.08 185.13,66.65 185.13,65.46 184.84,65.17 181.43,65.17 178.86,62.6 177.65,62.6 176.54,63.71 172.92,63.71 171.92,62.72 171.77,62.72 ; 171.77,57.05 173.15,57.05 v1(173.98,56.23)
  BOTTOM w0.076: UC1.T3 167.68,61.5 168,61.19 v1(168,61.16)
TRST#_XDP: length 28.9
  TOP w0.102: v1(97.16,25.9) 97.21,25.85 97.21,24.03 97.71,23.53 JXDP1.54 ; UC7.12 104.81,36.14 104.66,36.29 104.22,36.29 103.88,35.95 103.88,34.31 104.58,33.61 104.58,30.42 v2(106.54,28.46) v1(108.08,26.93)
  BOTTOM w0.102: v1(97.16,25.9) 97.16,26.04 97.54,26.42 101.8,26.42 102.9,27.51 107.49,27.51 v1(108.08,26.93)
UG_3V: length 14.9
  IN1 w1.016: 216.95,66.97 216.95,69.66 213.93,72.68 206.77,72.68
  BOTTOM w0.102: v3(217.08,65.98) v2(217.08,66.74)
  vias: v3(205.74,73.14) v3(205.74,72.48) v3(217.11,65.32)
UG_5V: length 9.5
  TOP w0.127: v3(217.11,61.42) 216.17,61.42 v2(215.95,61.2)
  IN1 w1.016: 216.93,60.28 216.93,59.15 216.27,58.49 213.78,58.49 213.02,59.25 210.35,59.25
  vias: v3(208.57,59.45) v3(209.21,59.43) v3(217.09,62.09)
UIM_CLK: length 68.9
  TOP w0.102: v1(282.11,91.46) 282.16,91.4 CZ66.1
  IN2 w0.122: v1(282.11,91.46) 281.67,91.89 281.67,93.2 281.99,93.51 281.99,94.45 277.76,98.68 262.64,98.68 261.86,99.46 258.24,99.46 257.74,98.96 251.64,98.96 248.98,101.62 241.15,101.62 240.9,101.37 230.8,101.37 v1(229.81,102.36)
  BOTTOM w0.102: JSIM1.4 226.71,99.25 v1(229.81,102.36) ; JNGFF2.24 282.21,91.35 v1(282.11,91.46)
UIM_DATA: length 70.4
  TOP w0.102: v2(285.48,90.92) 284.92,90.92 284.06,91.78 CZ65.1 283.36,91.89 v1(283.32,91.85)
  IN2 w0.122: v1(228.97,102.35) 229.5,102.89 230.14,102.89 231.15,101.88 240.7,101.88 240.94,102.12 249.19,102.12 251.85,99.46 257.53,99.46 258.03,99.96 262.07,99.96 262.85,99.19 278.01,99.19 283.76,93.43 283.76,92.29 v1(283.32,91.85)
  BOTTOM w0.102: JNGFF2.26 v1(283.32,91.85) ; v1(228.97,102.35) 228.88,102.35 226.48,99.95 JSIM1.3
UIM_RESET: length 72.7
  TOP w0.102: CZ67.1 283.71,89.6 v1(283.3,90.01) 282.94,89.65 v2(282.94,89.49)
  IN2 w0.122: v1(283.3,90.01) 283.3,90.96 284.07,91.73 284.07,93.5 278.14,99.44 262.95,99.44 262.17,100.21 257.93,100.21 257.43,99.71 251.95,99.71 249.29,102.37 240.84,102.37 240.59,102.12 231.56,102.12 v1(231.33,102.35)
  BOTTOM w0.102: JSIM1.6 226.24,97.85 230.75,102.35 v1(231.33,102.35) ; v1(283.3,90.01) 283.3,90.5 283.65,90.85 JNGFF2.22
USB3RN1: length 53.3
  TOP w0.102: v1(189.32,87.06) 189.15,87.23 v3(189.15,88.27) 189.15,88.85 188.93,89.08 188.93,89.85 189.2,90.12 189.2,91.38 189.03,91.56 189.03,91.8 189.12,91.9 UI4.5
  IN1 w0.086: v1(157.37,66.74) 157.38,66.74 157.58,66.54 157.58,66.44 157.48,66.33 156.49,66.33 155.71,67.11 155.71,68.04 157.18,69.5 157.18,71.37 158.88,73.07 158.88,73.32 158.88,73.32 158.88,73.37 158.88,73.37 158.88,73.39
  IN1 w0.089: v1(189.32,87.06) 189.32,86.5 189.06,86.25 175.25,86.25 172.22,83.23 172.22,82.95 168.72,79.44 168.72,79.35 168.02,78.65 167.44,78.65 165.3,76.5 161.94,76.5 158.88,73.44 158.88,73.39
  BOTTOM w0.076: UC1.G20 157.8,66.32 v1(157.37,66.74)
USB3RN1_D-: length 18
  TOP w0.102: LI1.3 73.27,102.74 73.59,103.06 73.59,103.26 73.84,103.51 73.84,103.62 73.71,103.75 DI1.1 DI1.9 73.71,105.75 73.18,106.28 v3(71.46,106.28) 68.69,106.28 68.67,106.26 68.11,106.26 68.09,106.28 65.79,106.28 63.54,108.53 63.54,109.21 63.31,109.44 63.31,109.92 62.71,110.52 JUSB1.5
USB3RN2: length 178
  IN1 w0.086: v1(158.28,67.29) 158.38,67.19 158.58,67.19 158.74,67.34 158.74,67.78 158.97,68.01 158.97,69.66 159.39,70.08 159.39,73 159.77,73.39
  IN1 w0.089: 159.77,73.39 160.52,74.13 162.01,74.13 162.57,74.68 164.31,74.68 167.65,78.03 168.1,78.03 169.22,79.15 169.22,79.24 172.74,82.76 172.74,82.99 175.34,85.58 196.04,85.58 199.14,88.68 221.93,88.68 222.18,88.93 228.28,88.93 230.1,90.74 241.59,90.74 242.74,89.6 242.97,89.6 242.98,89.6 247,89.6 247.53,89.6 247.57,89.6 248.47,90.49 249.28,90.49 249.44,90.66 250.88,90.66 252.77,92.54 265.63,92.54 268.29,95.21 284.98,95.21 286.04,96.26 290,96.26 290.17,96.43 290.65,96.43 291.05,96.03 291.05,89.62 298.31,82.36 298.31,81.3 300.44,79.17 301.92,79.17 302.94,80.18 302.94,82.18 303.35,82.59 303.63,82.59 v1(303.9,82.86)
  BOTTOM w0.076: v1(158.28,67.29) 158.61,67.62 UC1.E18
  BOTTOM w0.102: LI6.1 304.53,83.04 304.18,82.69 304.06,82.69 v1(303.9,82.86)
USB3RN2_D-: length 13
  BOTTOM w0.102: JUSB3.5 315.45,87.64 315.02,87.21 314.79,87.21 314.13,86.55 312.28,86.55 311.86,86.13 311.86,83.68 310.88,82.71 v3(310.62,82.71) 310.23,82.71 310.08,82.85 DI4.1 DI4.9 308.39,82.85 308.25,82.72 308.13,82.72 308.11,82.74 307.51,82.74 307.49,82.72 307.38,82.72 307.38,82.72 307.35,82.72 307.03,83.04 LI6.2
USB3RN4: length 117.3
  IN1 w0.086: v1(161.1,66.56) 160.72,66.17 160.72,65.16 160.31,64.74 157.14,64.74 154.5,67.38 154.5,68.9 154.5,69.04 156.21,70.75 156.21,73.7 157.44,74.93 157.58,74.93 157.58,74.93 158,74.93
  IN1 w0.089: v1(230.39,92.83) 230.6,92.62 230.6,92.2 228.59,90.19 197.68,90.19 195.35,87.86 186.97,87.86 186.33,87.23 174.88,87.23 172.97,85.32 172.47,85.32 168.54,81.4 168.27,81.4 166.45,79.57 166.45,79.24 165.68,78.48 161.71,78.48 158.17,74.93 158,74.93
  BOTTOM w0.076: v1(161.1,66.56) 160.7,66.97 UC1.F15
  BOTTOM w0.102: v1(230.39,92.83) 230.57,93 230.57,93.67 230.44,93.79 223.04,93.79 220.42,96.41 220.42,97.68 220.4,97.7 220.4,98.26 220.42,98.28 220.42,100.9 220.1,101.22 LI9.1
USB3RN4_D-: length 17.1
  BOTTOM w0.102: LI9.2 220.1,103.87 220.42,104.19 220.42,104.47 220.53,104.57 DI6.9 DI6.1 220.53,106.28 220.67,106.42 220.67,106.61 v3(221.78,107.72) 222.28,108.22 223.93,108.22 223.95,108.24 224.54,108.24 224.56,108.22 230.6,108.22 230.89,108.52 230.89,109.35 229.72,110.52 JUSB2.5
USB3RP1: length 53.3
  TOP w0.102: v1(188.73,87.06) 188.95,87.27 188.95,87.97 188.93,87.99 188.93,88.54 188.95,88.56 188.95,88.77 188.72,88.99 188.72,89.94 189,90.21 189,91.29 188.82,91.47 188.82,91.8 188.72,91.9 UI4.4
  IN1 w0.086: v1(157.38,65.97) 157.18,66.17 156.42,66.17 155.55,67.04 155.55,68.11 157.01,69.57 157.01,71.44 158.71,73.14 158.71,73.39
  IN1 w0.089: 158.71,73.39 158.71,73.51 161.87,76.67 165.23,76.67 167.37,78.82 167.95,78.82 168.55,79.42 168.55,79.51 172.05,83.02 172.05,83.3 175.18,86.42 188.99,86.42 189.15,86.57 189.15,86.67 188.75,87.06 v1(188.73,87.06)
  BOTTOM w0.076: UC1.H20 157.57,65.66 157.38,65.85 v1(157.38,65.97)
USB3RP1_D+: length 17.9
  TOP w0.102: JUSB1.6 63.76,110.52 63.52,110.28 63.52,109.53 63.75,109.3 63.75,108.62 65.87,106.49 v3(68.39,106.49) 71.14,106.49 71.16,106.51 71.76,106.51 71.78,106.49 73.27,106.49 73.92,105.84 73.92,105.47 74.21,105.18 DI1.8 DI1.2 74.21,103.72 74.05,103.56 74.05,103.41 73.8,103.15 73.8,103.06 74.12,102.74 LI1.2
USB3RP2: length 178
  IN1 w0.086: 159.89,73.27 159.88,73.26 159.88,73.26 159.84,73.22 159.84,73.22 159.68,73.06 159.55,72.93 159.55,70.01 159.13,69.59 159.13,67.94 158.91,67.71 158.91,67.24 v1(158.3,66.64)
  IN1 w0.089: v1(303.9,82.27) 303.75,82.42 303.42,82.42 303.11,82.11 303.11,80.11 301.99,79 300.37,79 298.14,81.23 298.14,82.29 290.88,89.55 290.88,95.96 290.58,96.26 290.24,96.26 290.07,96.09 286.11,96.09 285.05,95.04 268.36,95.04 265.7,92.37 252.84,92.37 250.95,90.48 249.51,90.48 249.35,90.32 248.54,90.32 247.64,89.43 247.61,89.43 242.91,89.43 242.9,89.43 242.66,89.43 241.52,90.57 230.17,90.57 228.35,88.76 222.25,88.76 222,88.51 199.21,88.51 196.11,85.41 175.41,85.41 172.91,82.91 172.91,82.69 169.39,79.17 169.39,79.08 168.17,77.86 167.72,77.86 164.38,74.51 162.64,74.51 162.08,73.96 160.59,73.96 159.89,73.27
  BOTTOM w0.076: v1(158.3,66.64) 158.63,66.97 UC1.F18
  BOTTOM w0.102: v1(303.9,82.27) 304.11,82.48 304.24,82.48 304.53,82.19 LI6.4
USB3RP2_D+: length 13
  BOTTOM w0.102: JUSB3.6 315.45,86.55 314.99,87.01 314.88,87.01 314.22,86.34 312.37,86.34 312.06,86.04 312.06,83.59 310.97,82.5 310.91,82.5 310.89,82.48 310.34,82.48 310.32,82.5 310.17,82.5 310.02,82.35 DI4.2 DI4.8 308.36,82.35 308.21,82.51 v3(307.81,82.51) 307.46,82.51 307.14,82.19 LI6.3
USB3RP4: length 117.2
  IN1 w0.086: 158,74.76 157.98,74.76 157.98,74.76 157.93,74.76 157.93,74.77 157.65,74.77 157.65,74.76 157.51,74.76 157.51,74.76 156.38,73.63 156.38,70.71 156.38,70.68 154.67,68.97 154.67,67.45 157.21,64.91 160.24,64.91 160.55,65.23 160.55,66.24 160.68,66.37 160.68,66.59 160.57,66.7 160.32,66.7 v1(160.17,66.55)
  IN1 w0.089: 158,74.76 158.24,74.76 161.78,78.31 165.75,78.31 166.62,79.17 166.62,79.5 168.34,81.23 168.61,81.23 172.54,85.15 173.04,85.15 174.95,87.06 186.41,87.06 187.04,87.69 195.42,87.69 197.75,90.02 228.66,90.02 230.77,92.13 230.77,92.62 v1(230.98,92.83)
  BOTTOM w0.076: UC1.G15 160.43,66.55 v1(160.17,66.55)
  BOTTOM w0.102: v1(230.98,92.83) 230.78,93.03 230.78,93.75 230.53,94 223.12,94 220.63,96.5 v3(220.63,97.98) 220.63,100.9 220.95,101.22 LI9.4
USB3RP4_D+: length 17.3
  BOTTOM w0.102: JUSB2.6 231.06,110.52 230.86,110.31 230.86,109.68 231.1,109.44 231.1,108.43 230.69,108.02 v3(224.24,108.02) 222.39,108.02 222.15,107.77 222.15,107.76 221.73,107.34 221.72,107.34 220.88,106.51 220.88,106.42 221.03,106.28 DI6.2 DI6.8 221.03,104.65 220.63,104.25 220.63,104.14 220.95,103.82 LI9.3
USB3TN1: length 56.5
  TOP w0.102: v1(185.01,89.89) 184.82,90.08 184.82,90.43 185.14,90.74 v3(186.12,90.74) 186.88,90.74 187.86,91.72 187.86,91.99 187.92,92.05 UI4.2
  IN1 w0.086: 149.27,72.58 149.27,72.56 149.27,72.55 149.27,70.6 148.88,70.21 148.47,70.21 148.4,70.27 148.4,70.37 148.78,70.75 v1(148.83,70.75)
  IN1 w0.089: v1(185.01,89.89) 185,89.9 185,90.48 184.84,90.63 183.95,90.63 183.16,89.84 175.68,89.84 172.67,86.83 172.11,86.83 168.85,83.57 165.06,83.57 162.42,80.93 159.4,80.93 158.34,79.87 153.5,79.87 153.2,79.57 153.2,77.21 149.95,73.96 149.8,73.96 149.27,73.43 149.27,72.58
  BOTTOM w0.076: UC1.C33 149.16,69.03 149.16,69.24 148.96,69.44 148.96,69.86 148.79,70.03 148.79,70.72 v1(148.83,70.75)
USB3TN1_C: length 2.1
  TOP w0.102: LI2.4 75.31,100.11 75.62,99.79 75.62,99.53 75.88,99.28 75.88,99.23 CI4.1
USB3TN1_D-: length 15.5
  TOP w0.102: JUSB1.8 68.71,110.52 69.03,110.19 69.03,109.77 68.54,109.27 68.54,108.44 69.55,107.43 70.21,107.43 70.23,107.41 70.79,107.41 70.81,107.43 v3(72.66,107.43) 75.01,107.43 75.36,107.08 75.36,105.53 75.21,105.39 DI1.7 DI1.4 75.21,103.74 75.4,103.56 75.4,103.34 75.63,103.12 75.63,103.04 75.31,102.71 LI2.3
USB3TN2: length 187.5
  IN1 w0.086: 148.19,73.13 148.19,73.11 148.19,73.06 148.23,73.02 148.23,71.78 148.53,71.48 148.65,71.48 v1(148.83,71.3)
  IN1 w0.089: v1(301.12,80.25) 301.17,80.21 301.17,79.99 301.06,79.88 300.72,79.88 299.1,81.5 299.1,82.49 291.7,89.89 291.7,96.29 290.91,97.07 289.9,97.07 289.73,96.9 275.65,96.9 275.46,97.09 269.15,97.09 266.29,94.24 252.12,94.24 249.14,91.25 248.29,91.25 247.27,90.24 243.24,90.24 242.06,91.42 235.73,91.42 232.99,94.16 232.85,94.16 228.66,94.16 226.48,91.98 197.3,91.98 196.1,90.78 190.1,90.78 189.6,91.28 183.05,91.28 182.25,90.48 174.45,90.48 173.58,89.61 173.58,88.67 172.52,87.61 171.79,87.61 168.41,84.22 155.37,84.22 155.22,84.22 152.08,81.07 152.08,78 148.62,74.54 148.62,74.4 148.62,73.92 148.19,73.49 148.19,73.13
  BOTTOM w0.076: UC1.B33 149.26,69.8 149,70.05 149,70.05 148.98,70.08 148.98,70.38 149.19,70.59 149.19,70.94 v1(148.83,71.3)
  BOTTOM w0.102: v1(301.12,80.25) 301.27,80.4 301.27,80.73 301.6,81.06 302.06,81.06 CI13.2
USB3TN2_C: length 2
  BOTTOM w0.102: LI5.1 304.53,81.26 304.21,80.94 303.67,80.94 CI13.1
USB3TN2_D-: length 10.3
  BOTTOM w0.102: LI5.2 307.11,81.26 307.36,81.01 v3(307.71,81.01) 307.91,81.01 308.12,81.22 308.23,81.22 308.37,81.35 DI4.7 DI4.4 310.05,81.35 310.19,81.21 310.44,81.21 310.46,81.23 311.11,81.23 311.13,81.21 311.71,81.21 312.37,81.87 314.29,81.87 314.92,81.23 315.21,81.23 315.45,81.47 JUSB3.8
USB3TN4: length 111.9
  IN1 w0.086: v1(150.6,70.94) 150.8,71.15 151.03,71.15 151.24,71.36
  IN1 w0.089: 151.24,71.36 151.24,74.07 152.21,75.05 153.78,75.05 154.39,75.65 154.39,77.72 154.98,78.32 159.94,78.32 161.56,79.94 163.76,79.94 166.55,82.73 169.18,82.73 172.36,85.9 172.88,85.9 175.68,88.69 193.04,88.69 194.03,89.68 196.5,89.68 197.97,91.16 226.86,91.16 229.01,93.32 232.52,93.32 232.63,93.2 232.63,93.1 232.54,93 232.54,92.92 232.46,92.84 v1(232.19,92.84)
  BOTTOM w0.076: UC1.B31 150.64,69.84 150.75,69.95 150.75,69.95 150.92,70.12 150.92,70.35 150.6,70.67 v1(150.6,70.94)
  BOTTOM w0.102: CI28.2 222.01,98.44 222.01,97.58 221.79,97.36 221.79,96.23 222.6,95.43 223.25,95.43 223.56,95.12 223.59,95.12 223.97,94.73 224.15,94.73 231.4,94.73 232.47,93.66 232.47,93.12 v1(232.19,92.84)
USB3TN4_C: length 2.3
  BOTTOM w0.102: CI28.1 222.14,100.18 222.14,101.09 221.88,101.35 LI8.1
USB3TN4_D-: length 20.8
  BOTTOM w0.102: JUSB2.8 236.12,110.52 236.36,110.28 236.36,110.01 235.61,109.26 235.61,108.55 234.29,107.23 228.75,107.23 228.73,107.25 228.14,107.25 228.12,107.23 v3(226.48,107.23) 222.64,107.23 222.19,106.78 222.19,106.32 222.03,106.15 DI6.4 DI6.7 222.03,104.61 222.24,104.4 222.24,104.12 221.88,103.76 LI8.2
USB3TP1: length 56.4
  TOP w0.102: UI4.1 187.52,92.06 187.65,91.93 187.65,91.81 186.79,90.95 186.42,90.95 186.4,90.97 185.84,90.97 185.82,90.95 185.05,90.95 184.61,90.51 184.61,90.08 v1(184.43,89.89)
  IN1 w0.086: 149.44,72.58 149.44,72.56 149.44,72.55 149.44,70.53 148.95,70.04 148.4,70.04 148.23,70.2 v1(148.23,70.72)
  IN1 w0.089: v1(184.43,89.89) 184.44,89.89 184.83,90.28 184.83,90.41 184.77,90.46 184.02,90.46 183.23,89.67 175.75,89.67 172.74,86.66 172.18,86.66 168.92,83.4 165.13,83.4 162.49,80.76 159.47,80.76 158.41,79.7 153.57,79.7 153.37,79.5 153.37,77.13 150.03,73.79 149.87,73.79 149.44,73.36 149.44,72.58
  BOTTOM w0.076: UC1.B34 148.51,69.44 148.51,69.5 148.58,69.56 148.7,69.56 148.78,69.64 148.78,69.78 148.61,69.95 148.61,70.47 148.37,70.72 v1(148.23,70.72)
USB3TP1_C: length 2.1
  TOP w0.102: LI2.1 76.16,100.14 75.83,99.81 75.83,99.62 76.09,99.36 76.09,99.23 CI5.1
USB3TP1_D+: length 15.6
  TOP w0.102: LI2.2 76.16,102.74 75.83,103.06 75.83,103.24 75.63,103.44 75.63,103.59 75.71,103.67 DI1.5 DI1.6 75.71,105.39 75.57,105.53 75.57,107.16 75.1,107.64 72.96,107.64 72.94,107.66 72.37,107.66 72.35,107.64 v3(70.51,107.64) 69.63,107.64 68.75,108.52 68.75,109.18 69.24,109.68 69.24,110.19 69.57,110.52 JUSB1.9
USB3TP2: length 187.4
  IN1 w0.086: v1(148.83,71.85) 148.83,71.82 148.68,71.67 148.58,71.67 148.39,71.85 148.39,73.09 148.36,73.13 148.36,73.13
  IN1 w0.089: 148.36,73.13 148.36,73.42 148.79,73.85 148.79,74.47 152.25,77.93 152.25,81 155.3,84.05 168.48,84.05 171.86,87.44 172.59,87.44 173.75,88.6 173.75,89.54 174.52,90.31 182.32,90.31 183.12,91.11 189.53,91.11 190.03,90.61 196.17,90.61 197.37,91.81 226.55,91.81 228.73,93.99 232.92,93.99 235.66,91.25 241.99,91.25 243.17,90.07 247.2,90.07 247.38,90.07 248.39,91.08 249.21,91.08 252.19,94.07 266.36,94.07 269.22,96.92 275.39,96.92 275.58,96.73 289.81,96.73 289.97,96.9 290.84,96.9 291.53,96.22 291.53,89.82 298.92,82.42 298.92,81.43 300.65,79.71 301.13,79.71 301.3,79.88 301.32,79.88 301.69,80.25 v1(301.71,80.25)
  BOTTOM w0.076: UC1.A33 149.42,70.23 149.49,70.31 149.49,70.41 149.37,70.53 149.37,71.02 149.18,71.2 149.18,71.45 148.83,71.8 v1(148.83,71.85)
  BOTTOM w0.102: v1(301.71,80.25) 301.48,80.48 301.48,80.64 301.69,80.85 302.22,80.85 302.35,80.72 CI16.2
USB3TP2_C: length 2
  BOTTOM w0.102: CI16.1 303.67,80.73 304.21,80.73 304.53,80.41 LI5.4
USB3TP2_D+: length 10.3
  BOTTOM w0.102: LI5.3 307.08,80.41 307.44,80.78 308.01,80.78 308.14,80.91 308.14,80.91 308.24,81.01 308.3,81.01 308.45,80.85 DI4.6 DI4.5 310.05,80.85 310.19,81 310.78,81 v3(310.78,81) 311.8,81 312.45,81.66 314.2,81.66 314.84,81.02 315.02,81.02 315.45,80.6 JUSB3.9
USB3TP4: length 112
  IN1 w0.086: v1(150.6,71.53) 150.81,71.32 150.96,71.32 151.07,71.42 151.07,71.43
  IN1 w0.089: 151.07,71.43 151.07,74.14 152.14,75.22 153.71,75.22 154.22,75.73 154.22,77.79 154.91,78.49 159.87,78.49 161.49,80.11 163.69,80.11 166.48,82.9 169.11,82.9 172.29,86.07 172.81,86.07 175.61,88.86 192.97,88.86 193.96,89.86 196.43,89.86 197.9,91.33 226.78,91.33 228.94,93.49 232.59,93.49 232.8,93.27 232.8,92.98 v1(232.94,92.84)
  BOTTOM w0.076: v1(150.6,71.53) 150.24,71.17 150.24,70.77 150.64,70.37 UC1.A31
  BOTTOM w0.102: v3(223.51,95.49) 223.51,95.49 v3(223.51,95.49) ; v3(223.51,95.49) 224.06,94.94 231.49,94.94 232.68,93.75 232.68,93.1 v1(232.94,92.84) ; v3(223.51,95.49) 223.37,95.63 222.68,95.63 222,96.32 222,97.27 222.22,97.49 222.22,98.32 CI27.2
USB3TP4_C: length 2.3
  BOTTOM w0.102: LI8.4 222.73,101.34 222.35,100.97 222.35,100.03 CI27.1
USB3TP4_D+: length 20.7
  BOTTOM w0.102: LI8.3 222.73,103.4 222.73,103.8 222.44,104.09 222.44,104.47 222.53,104.56 DI6.6 DI6.5 222.53,106.15 222.4,106.28 222.4,106.7 222.73,107.03 226.16,107.03 226.18,107.01 226.78,107.01 226.8,107.03 v3(228.43,107.03) 234.38,107.03 235.82,108.47 235.82,109.18 237.16,110.52 JUSB2.9
USB_DB_DET#: length 2.8
  TOP w0.102: T98.1 257.72,86.93 258.31,86.35 258.31,85.88 257.67,85.24 UE1.A2
USB_OC0#: length 230.9
  TOP w0.102: v1(59.77,102.91) 60.08,102.6 UI1.5 ; v1(192.67,73.84) 193.97,72.54 v2(193.97,71.31) 193.97,68.65 194.96,67.67 195.96,67.67 196.51,67.12 197.13,67.12 197.78,66.47 197.78,64.15 197,63.38 197,62.93 197.3,62.63 197.62,62.63 198.01,62.24 198.01,57.45 196.51,55.95 196.51,52.87 v1(196.08,52.44)
  IN2 w0.122: v1(59.77,102.91) 60.34,103.48 70.93,103.48 71.52,104.08 73.32,104.08 74.29,103.11 87.47,103.11 88.1,102.48 90.2,102.48 91.01,103.3 97.49,103.3 99.55,101.24 100.34,101.24 101.66,99.92 101.66,99.22 103.21,97.67 105.46,97.67 106.66,98.86 108,98.86 110.16,96.7 116.75,96.7 117.27,97.22 125.29,97.22 127.77,99.71 129.84,99.71 130.38,100.25 131.69,100.25 132.26,99.68 133.32,99.68 133.85,100.22 135.54,100.22 136.89,98.86 136.89,92.73 137.61,92.01 137.61,89.95 138.69,88.87 143.66,88.87 145.55,86.98 145.55,83.51 145.85,83.21 145.85,82.17 146.11,81.9 147.06,81.9 147.62,82.47 149.23,82.47 150.26,81.43 150.42,81.28 150.42,79.69 150.41,79.68 150.41,78.99 150.37,78.95 150.37,77.48 152.53,75.31 154.47,75.31 154.94,74.84 158.06,74.84 158.58,75.36 164.36,75.36 166.11,77.11 167.25,77.11 168.42,78.28 170.33,78.28 173.75,74.86 173.75,72 177.66,68.08 180.34,68.08 182.72,70.46 182.72,70.75 185.06,73.09 191.92,73.09 v1(192.67,73.84)
  IN4 w0.086: 172.84,53.95 172.64,53.95 172.5,54.1 170.11,54.1 169.3,53.28 167.71,53.28 v1(167.35,53.65)
  IN4 w0.089: 172.84,53.95 173.94,53.95 174.69,53.2 176.68,53.2 177.17,53.69 179.08,53.69 179.36,53.42 182.5,53.42 v1(182.89,53.81) 185.1,53.81 185.52,53.4 187.68,53.4 188,53.08 190.89,53.08 191.35,53.53 193.21,53.53 193.97,52.77 195.75,52.77 v1(196.08,52.44)
  BOTTOM w0.076: UC1.AL3 167.68,53.31 v1(167.35,53.65)
  BOTTOM w0.102: RPC10.5 183.01,53.93 v1(182.89,53.81)
USB_OC1#: length 189.1
  TOP w0.102: v1(302.88,54.12) 302.88,54.05 v2(302.46,53.63) ; v1(308.27,80.22) 307.87,79.82 307.71,79.82 307.62,79.73 UI3.13
  IN1 w0.089: v1(269.28,55.16) 269.79,54.65 273.43,54.65 274.22,53.86 275.25,53.86 276.02,54.63 278.43,54.63 278.68,54.38 281.3,54.38 281.85,54.93 296.06,54.93 296.72,55.59 301.82,55.59 302.88,54.52 v1(302.88,54.12)
  IN2 w0.122: v1(308.27,80.22) 308.91,79.57 308.91,73 303.52,67.6 303.52,64.96 301.43,62.88 301.43,60.95 301.69,60.7 301.69,59.16 302.13,58.72 302.41,58.72 303.26,57.86 303.26,54.5 v1(302.88,54.12) ; v1(269.28,55.16) 269.58,54.86 269.58,53.15 268.05,51.62 261.89,51.62 259.14,54.36 255.58,54.36 255.37,54.57 254.36,54.57 253.7,55.23 252.59,55.23 251.67,54.31 246.9,54.31 245.32,55.88 241.96,55.88 239.27,53.2 239.27,52.65 239.27,52.65 239.27,52.34 237.33,50.39 236.02,50.39 226.92,41.29 206.18,41.29 206.18,41.29 200.9,41.29 200.01,42.18 195.01,42.18 194.83,42.01 192.54,42.01 189.42,45.13 189.42,47.7 188.62,48.49 v1(186.25,48.49)
  IN4 w0.086: 171.77,49.46 171.63,49.31
  IN4 w0.089: v1(186.25,48.49) 185.88,48.85 184.83,48.85 184.67,48.69 183.16,48.69 180.68,51.17 176.17,51.17 174.89,49.89 172.67,49.89 172.24,49.46 171.77,49.46 ; 171.63,49.31 v1(171.03,48.72)
  BOTTOM w0.076: UC1.AT1 169.34,50.24 170.24,49.33 170.58,49.33 170.65,49.26
  BOTTOM w0.102: v1(171.03,48.72) 171.03,48.87 170.65,49.26 ; v1(186.25,48.49) 186.42,48.31 RPC7.8
USB_OC2#: length 178
  TOP w0.102: v1(198.56,36.77) 198.31,36.52 v2(198.31,35.12) 198.31,33.72 198.17,33.58 v1(198.17,33.56)
  IN1 w0.089: v1(198.56,36.77) 198.22,37.11 198.2,37.11 194.96,40.35 194.96,43.68 193.08,45.56 193.08,48.88 192.33,49.62 190.69,49.62 190.03,50.28 189.12,50.28 187.94,49.11 185.83,49.11 185.66,48.94 183.74,48.94 183.57,49.11 183.56,49.11 181.72,50.94 179.26,50.94 178.94,51.26 177.61,51.26 176.63,52.24 v1(176.63,53.72)
  BOTTOM w0.076: UC1.AH2 168.62,55.06 169.11,55.06 169.59,54.57 170.12,54.57 170.15,54.54 172.84,54.54
  BOTTOM w0.102: UI2.5 244.94,115.25 245.26,114.92 245.26,111.41 236.63,102.77 236.63,99.27 238.39,97.5 238.39,90.13 237.53,89.27 236.46,89.27 236.08,88.89 236.08,87.24 239.1,84.22 239.1,78.72 238.61,78.22 238.61,72.68 240.97,70.32 240.97,61.86 240.8,61.7 240.8,55.91 238.81,53.92 238.81,51.74 237.67,50.6 237.67,48.85 235.34,46.52 233.64,46.52 231.36,44.24 231.36,43.96 230.64,43.24 230.64,42.31 228.79,40.46 228.79,39.68 228.28,39.17 228.28,35.98 225.5,33.2 222.3,33.2 221.98,32.88 221.61,32.88 220.83,32.1 208.69,32.1 206.98,33.8 198.41,33.8 v1(198.17,33.56) ; 172.84,54.54 174.33,54.54 175.15,53.72 v1(176.63,53.72) 177.15,54.24 178.92,54.24 179.1,54.43 RPC5.6
USB_OC3#: length 24.6
  TOP w0.102: v1(186.19,47.3) 186.19,47.07 v2(186.58,46.69)
  IN4 w0.089: v1(186.19,47.3) 186.19,47.61 185.97,47.84 183.26,47.84 180.36,50.74 177.56,50.74 v1(173.27,46.45)
  BOTTOM w0.076: 170.65,47.51 170.23,47.51 169.15,48.59 168.85,48.59 168.84,48.6 168.09,48.6 167.76,48.93 UC1.AV3
  BOTTOM w0.102: RPC7.6 186.21,47.31 v1(186.19,47.3) ; v1(173.27,46.45) 173.27,46.5 172.91,46.85 172.91,47.09 172.49,47.51 170.65,47.51
USB_PWR_EN1#: length 233.6
  TOP w0.102: UE1.B44 254.92,75.37 v1(254.66,75.63) ; UI1.4 57.47,102.6 v1(58.76,103.89) ; v1(248.12,73.74) 247.98,73.6 v2(247.56,73.6) ; RPE9.2 253.4,71.54 253.85,71.99 v1(253.85,72.05)
  IN1 w0.089: v1(248.12,73.74) 248.33,73.95 253.07,73.95 253.39,73.64 253.39,72.56 253.85,72.11 v1(253.85,72.05)
  IN2 w0.122: v1(248.12,73.74) 248.08,73.78 244.1,73.78 243.88,74.01 243.87,74.01 242.17,75.7 240.32,75.7 222.57,93.44 211.05,93.44 210.74,93.75 198.22,93.75 193.33,88.86 188.49,88.86 186.54,86.91 179.64,86.91 179.36,87.19 168.76,87.19 167.89,88.05 157.95,88.05 154.97,91.03 147.63,91.03 146.65,92.01 143.61,92.01 143.39,92.24 142.06,92.24 141.83,92.01 139.47,92.01 139.14,92.34 139.14,96 138.04,97.11 138.04,99.2 135.96,101.27 133.39,101.27 132.82,101.84 128.5,101.84 124.91,98.26 116.9,98.26 116.34,97.7 111.54,97.7 109.27,99.96 106.33,99.96 105.16,98.79 103.5,98.79 102.66,99.63 102.66,100.47 100.1,103.02 99.23,103.02 97.92,104.33 77.11,104.33 76.74,104.69 73.97,104.69 73.83,104.84 71.16,104.84 70.6,104.28 59.16,104.28 v1(58.76,103.89)
  BOTTOM w0.102: v1(253.85,72.05) 253.85,72.1 253.39,72.55 253.39,73.99 254.66,75.26 v1(254.66,75.63)
USB_PWR_EN2#: length 65.8
  TOP w0.102: RPE9.3 252.9,71.94 v1(253.04,72.09) ; v1(239.53,73.45) 239.71,73.45 v2(240.07,73.09) ; UE1.A33 v1(250.67,73.26)
  IN1 w0.089: v1(253.04,72.09) 253.02,72.11 253.02,72.29 252.06,73.26 v1(250.67,73.26) 249.17,73.26 248.96,73.04 243,73.04 242.43,73.61 240.32,73.61 240.16,73.45 v1(239.53,73.45)
  BOTTOM w0.102: UI2.4 246.08,115.25 245.49,114.66 245.49,111.31 236.89,102.71 236.89,99.53 238.63,97.79 238.63,85.71 239.9,84.44 239.9,73.81 v1(239.53,73.45)
USB_PWR_SHR_EN#: length 76.1
  TOP w0.102: v1(252.46,72.11) 252.4,72.05 RPE9.4 ; v1(253.91,62) 253.91,62 UE2.B38 ; v2(306.58,71.82) 306.58,72.76 v1(306.59,72.77) 306.62,72.8 UI3.6
  IN3 w0.122: v1(252.46,72.11) 252.46,71.8 252.68,71.58 254.92,71.58 256.04,72.71 259.31,72.71 259.44,72.58 260.97,72.58 260.98,72.59 261.32,72.59 261.33,72.58 264.9,72.58 265.93,73.62 266.88,73.62 267.54,72.96 270.08,72.96 270.21,73.09 271.56,73.09 275.3,69.36 282.52,69.36 285.29,72.12 294.06,72.12 294.39,71.79 305.61,71.79 v1(306.59,72.77)
  IN4 w0.089: v1(252.46,72.11) 252.46,71.89 252.56,71.78 252.56,70.75 252.28,70.47 252.28,69.15 252.6,68.82 252.6,63.31 v1(253.91,62)
USB_PWR_SHR_VBUS_EN: length 64.9
  TOP w0.102: UI3.5 v2(306.12,74.74) 306.12,73.37 v1(305.54,72.79) ; v1(254.57,70.15) 254.46,70.15 253.9,70.72 RPE9.1 ; v1(257.66,75.5) 257.92,75.24 UE1.B50
  IN1 w0.089: v1(257.66,75.5) 256.95,74.79 256.95,72.41 254.69,70.15 v1(254.57,70.15)
  IN3 w0.122: v1(305.54,72.79) 304.79,72.04 294.5,72.04 294.17,72.37 285.18,72.37 282.42,69.61 275.4,69.61 271.94,73.07 271.67,73.34 270.11,73.34 269.98,73.21 267.68,73.21 266.83,74.07 265.75,74.07 265.24,73.56 262.33,73.56 261.85,74.04 259.12,74.04 v1(257.66,75.5)
USBP0+: length 108.5
  TOP w0.102: v1(188.01,35) 188.37,35.36 188.37,35.68 189.13,36.43 190.03,36.43 192.38,38.78 192.38,39.82 193.35,40.79 194.73,40.79 199.78,45.83 199.78,54.74 202.88,57.84 202.88,61.85 200.7,64.03 200.7,70.54 197.67,73.56 197.67,75.38 197.67,84.86 194.6,87.92 190.08,87.92 189.77,88.24 189.77,89.76 189.64,89.89 189.64,91.01 189.71,91.08 189.71,91.81 189.52,92 UI4.6
  IN1 w0.086: 170.65,45.35 167.94,48.06 166.36,48.06 165.8,48.62 165.8,49.77 165.24,50.33 165.24,51.73 164.88,52.09 164.43,52.09 v1(164.29,52.22)
  IN1 w0.089: v1(188.01,35) 188.35,34.66 188.35,34.59 188.18,34.42 185.62,34.42 184.05,35.99 184.05,38.14 180.33,41.85 175.76,41.85 172.53,45.08 170.92,45.08 170.65,45.35
  BOTTOM w0.076: UC1.AM8 164.55,52.48 v1(164.29,52.22)
USBP0-: length 108.6
  TOP w0.102: UI4.7 189.92,90.99 189.85,90.92 189.85,89.98 189.98,89.85 189.98,88.32 190.17,88.13 194.52,88.13 194.52,88.13 194.69,88.13 197.88,84.94 197.88,73.65 200.91,70.62 200.91,70.45 200.91,68.19 200.91,64.12 203.09,61.94 203.09,61.77 203.09,57.75 199.99,54.65 199.99,45.75 194.82,40.58 193.43,40.58 192.59,39.74 192.59,38.69 190.12,36.22 189.21,36.22 188.58,35.59 188.58,35.01 v1(188.59,35)
  IN1 w0.086: 170.53,45.23 170.52,45.25 170.52,45.25 170.48,45.28 170.48,45.29 167.88,47.89 166.29,47.89 165.63,48.55 165.63,49.7 165.07,50.26 165.07,51.66 164.81,51.92 164.64,51.92 v1(164.29,51.57)
  IN1 w0.089: v1(188.59,35) 188.52,34.92 188.52,34.52 188.25,34.25 185.55,34.25 183.88,35.92 183.88,38.07 180.26,41.68 175.69,41.68 172.46,44.91 170.85,44.91 170.53,45.23
  BOTTOM w0.076: v1(164.29,51.57) 164.55,51.83 UC1.AN8
USBP0_D+: length 20.4
  TOP w0.102: LI3.3 61.61,99.34 61.27,99.68 60.38,99.68 DI2.2 59.5,99.56 59.4,99.66 58.78,99.66 58.14,100.29 58.14,101.29 58.84,101.99 62.8,101.99 v3(63.95,103.13) 64.87,104.06 64.87,104.62 v1(64.69,104.8)
  IN1 w0.089: JUSB1.3 65.89,109.02 66,108.91 66,107.34 64.75,106.09 64.75,104.86 v1(64.69,104.8)
USBP0_D-: length 20.3
  TOP w0.102: LI3.2 61.55,100.19 61.25,99.89 60.34,99.89 DI2.3 59.5,99.97 59.4,99.87 58.86,99.87 58.35,100.38 58.35,101.2 58.93,101.78 62.72,101.78 62.89,101.78 63.79,102.68 63.82,102.68 63.9,102.76 63.9,102.76 64.32,103.18 64.32,103.21 65.08,103.97 65.08,104.61 v1(65.28,104.8)
  IN1 w0.089: JUSB1.2 66.53,109.02 66.17,108.66 66.17,107.27 64.92,106.02 64.92,105.16 v1(65.28,104.8)
USBP1+: length 196.2
  TOP w0.102: v1(301.37,46.62) 301.6,46.84 301.8,46.84 302.02,47.06 302.02,48.53 301.17,49.37 301.17,53.94 301.78,54.54 301.78,57.25 301.49,57.54 301.49,61.26 299.94,62.81 299.94,64.91 299.43,65.42 299.43,65.88 299.98,66.43 299.98,68.67 301.02,69.72 301.02,70.94 300.87,71.09 300.87,71.44 300.89,71.46 v3(300.89,71.86) 300.89,73.15 300.91,73.17 300.91,73.74 300.89,73.76 300.89,76.78 301.98,77.87 303.54,77.87 303.76,77.65 304.61,77.65 304.72,77.54 UI3.3
  IN1 w0.089: v1(165.68,50.56) 165.74,50.61 165.92,50.61 165.98,50.55 165.98,50.11 166.28,49.81 167.07,49.81 171.14,45.74 172.56,45.74 175.91,42.39 180.51,42.39 186.99,35.91 188.59,35.91 189.06,35.44 189.06,33.34 191.7,30.71 201.91,30.71 204.36,28.26 227.71,28.26 230.29,30.84 230.29,33.68 231.46,34.85 231.61,34.85 237.48,40.73 239.24,40.73 243.59,45.08 265.87,45.08 266.92,44.03 268.46,44.03 270.54,46.1 284.05,46.1 285.29,47.34 289.29,47.34 289.72,47.77 290.87,47.77 291.53,47.12 297.26,47.12 297.74,46.64 300.53,46.64 300.71,46.81 301.15,46.81 301.24,46.73 301.26,46.73 v1(301.37,46.62)
  BOTTOM w0.076: UC1.AT7 165.34,50.21 165.68,50.55 v1(165.68,50.56)
USBP1-: length 196.4
  TOP w0.102: UI3.2 304.86,78.04 304.68,77.86 303.85,77.86 303.62,78.08 301.89,78.08 300.68,76.87 v3(300.68,73.46) 300.68,72.16 300.66,72.14 300.66,71.01 300.81,70.86 300.81,69.8 299.77,68.76 299.77,66.51 299.22,65.96 299.22,65.33 299.73,64.82 299.73,62.73 301.28,61.18 301.28,57.45 301.57,57.17 301.57,54.63 300.96,54.03 300.96,49.29 301.81,48.44 301.81,47.14 301.72,47.06 301.51,47.06 v1(301.37,47.2)
  IN1 w0.089: v1(301.37,47.2) 301.35,47.2 301.14,46.98 300.64,46.98 300.46,46.81 297.81,46.81 297.33,47.29 291.6,47.29 290.94,47.95 289.65,47.95 289.22,47.51 285.22,47.51 283.98,46.27 270.46,46.27 268.39,44.2 266.99,44.2 265.94,45.25 243.52,45.25 239.17,40.9 237.41,40.9 231.54,35.02 231.39,35.02 230.12,33.75 230.12,30.91 227.64,28.43 204.43,28.43 201.98,30.88 191.77,30.88 189.24,33.41 189.24,35.51 188.67,36.08 187.07,36.08 180.58,42.56 175.98,42.56 172.63,45.91 171.21,45.91 167.14,49.98 166.35,49.98 166.15,50.18 166.15,50.65 v1(165.64,51.17)
  BOTTOM w0.076: v1(165.64,51.17) 165.64,51.04 165.46,50.86 UC1.AR7
USBP1_R_D+: length 16.2
  IN4 w0.089: v1(311.39,79.15) 311.62,78.92 312.12,78.92 312.45,79.25 312.45,83.39 313.24,84.19 313.86,84.19 313.95,84.27 JUSB3.3
  BOTTOM w0.102: LI7.2 305.15,78.47 305.47,78.15 306.49,78.15 DI5.3 307.35,78.64 307.7,78.3 308.06,78.3 308.72,78.96 311.2,78.96 v1(311.39,79.15)
USBP1_R_D-: length 16.4
  IN4 w0.089: JUSB3.2 313.95,83.93 313.86,84.02 313.31,84.02 312.62,83.32 312.62,79.18 312.19,78.75 311.58,78.75 v1(311.39,78.56)
  BOTTOM w0.102: v1(311.39,78.56) 311.2,78.75 308.81,78.75 308.14,78.08 307.77,78.08 307.35,77.66 DI5.2 307.31,77.08 306.45,77.94 305.47,77.94 305.15,77.62 LI7.3
USBP2+: length 135.7
  IN1 w0.089: v1(270.01,39.4) 269.82,39.2 267.19,39.2 266.8,39.59 266.8,43.44 265.76,44.48 243.79,44.48 239.51,40.2 237.66,40.2 235.9,38.44 235.9,37.3 234.67,36.07 233.58,36.07 231.31,33.8 231.31,30.87 227.82,27.38 203.51,27.38 200.76,30.13 188.5,30.13 182.9,35.73 182.9,38.18 179.86,41.21 175.49,41.21 172.69,44.01 170.71,44.01 168.24,46.48 167.11,46.48 165.96,47.63 165.3,47.63 164.67,48.27 164.67,50.18 164.29,50.56 v1(164.29,50.85)
  BOTTOM w0.076: v1(164.29,50.85) 164.78,50.85 164.88,50.95 164.88,51.07 164.77,51.18 UC1.AP8
  BOTTOM w0.102: v1(270.01,39.4) 270.02,39.4 270.31,39.1 270.36,39.1 270.64,39.37 270.64,39.68 270.56,39.75 270.43,39.75 270.35,39.84 JNGFF1.3
USBP2-: length 135.9
  IN1 w0.089: v1(270.01,38.81) 269.79,39.03 267.12,39.03 266.63,39.52 266.63,43.37 265.69,44.31 243.86,44.31 239.58,40.03 237.73,40.03 236.07,38.37 236.07,37.23 234.74,35.9 233.65,35.9 231.48,33.73 231.48,30.8 227.89,27.21 203.44,27.21 200.69,29.96 188.43,29.96 182.73,35.66 182.73,38.11 179.79,41.04 175.42,41.04 172.62,43.84 170.64,43.84 168.17,46.31 167.04,46.31 165.89,47.46 165.23,47.46 164.5,48.2 164.5,50.1 164.41,50.18 163.98,50.18 v1(163.88,50.08)
  BOTTOM w0.076: v1(163.88,50.08) 163.88,50.08 164.21,50.41 164.43,50.41 164.55,50.53 UC1.AR8
  BOTTOM w0.102: v1(270.01,38.81) 270.09,38.89 270.45,38.89 270.84,39.29 270.84,39.96 270.85,39.96 JNGFF1.5
USBP3+: length 83.8
  IN1 w0.089: v1(146.51,84.64) 146.68,84.8 146.68,90.05 147.59,90.97 154.71,90.97 154.87,91.13 161.02,91.13 161.49,91.6 164.32,91.6 165.65,92.94 165.65,95.15 166.03,95.53 166.03,97.91 166.48,98.36 166.48,99.32 164.99,100.82 164.54,100.82 164.33,101.02 164.33,101.24 v1(163.93,101.64)
  IN4 w0.086: v1(163.79,50.62) 163.62,50.79 163.4,50.79 162.91,51.28 162.91,53.01 163.28,53.39 163.28,54.38 163.11,54.56 163.11,55.58 163.65,56.13 163.65,58.83 162.36,60.12 162.36,61.35 160.78,62.93 159.34,62.93 156.69,65.58 156.69,65.96 154.51,68.14 151.54,68.14 149.25,70.43 149.25,73.18 149.25,73.18
  IN4 w0.089: 149.25,73.18 148.24,74.19 148.24,78.35 147.23,79.36 147.23,82.84 146.71,83.37 146.71,84.44 v1(146.51,84.64)
  BOTTOM w0.076: UC1.AT10 163.33,50.27 163.68,50.62 v1(163.79,50.62)
  BOTTOM w0.102: UI5.8 163.36,103.44 163.51,103.29 163.51,102.87 164.1,102.29 164.1,101.8 v1(163.93,101.64)
USBP3-: length 83.7
  IN1 w0.089: v1(147.1,84.64) 146.85,84.88 146.85,89.98 147.66,90.79 154.78,90.79 154.94,90.96 161.09,90.96 161.56,91.43 164.39,91.43 165.82,92.87 165.82,95.07 166.2,95.46 166.2,97.84 166.65,98.29 166.65,99.39 165.06,100.99 164.61,100.99 164.5,101.09 164.5,101.62 v1(164.52,101.64)
  IN4 w0.086: v1(163.81,51.32) 163.87,51.25 163.87,51.12 163.74,50.99 163.43,50.99 163.07,51.35 163.07,52.94 163.45,53.32 163.45,54.45 163.27,54.63 163.27,55.51 163.82,56.06 163.82,58.9 162.53,60.19 162.53,61.42 160.85,63.1 159.41,63.1 156.86,65.65 156.86,66.03 154.58,68.3 151.61,68.3 149.42,70.5 149.42,73.26
  IN4 w0.089: 149.42,73.26 148.41,74.26 148.41,78.42 147.4,79.43 147.4,82.91 146.88,83.44 146.88,84.42 v1(147.1,84.64)
  BOTTOM w0.076: v1(163.81,51.32) 163.79,51.3 163.79,51.29 163.35,50.86 UC1.AR10
  BOTTOM w0.102: UI5.7 163.86,103.43 163.72,103.28 163.72,102.96 164.3,102.37 164.3,101.85 v1(164.52,101.64)
USBP3_D+: length 27.9
  IN2 w0.112: JUSB2.3 233.39,109.02 233.5,108.91 233.5,108.79 232.45,107.75 221.69,107.75 220.56,108.88 216.62,108.88 216.28,108.54 216.28,108.32 v1(216.05,108.09)
  BOTTOM w0.102: v1(216.05,108.09) 216.24,107.9 216.24,105.71 217.33,104.61 217.33,104.29 217.23,104.19 DI3.3 217.3,103.36 217.3,102.61 216.94,102.24 LI4.2
USBP3_D-: length 27.9
  IN2 w0.112: JUSB2.2 233.81,109.02 233.7,108.91 233.7,108.71 232.54,107.55 221.61,107.55 220.48,108.68 216.71,108.68 216.48,108.45 216.48,108.24 v1(216.63,108.09)
  BOTTOM w0.102: LI4.3 217.79,102.36 217.51,102.64 217.51,103.3 DI3.2 217.64,104.19 217.54,104.29 217.54,104.7 216.45,105.8 216.45,107.9 v1(216.63,108.09)
USBP4+: length 106.6
  IN4 w0.089: v1(107.1,93.65) 106.9,93.85 106.9,95.56 108.92,97.58 115.29,97.58 116.49,98.79 116.49,99.6 117.05,100.16 118.07,100.16 118.85,99.38 129.16,99.38 130.02,100.24 131.68,100.24 133.14,98.78 135.57,98.78 136.27,98.08 136.27,91.56 134.54,89.84 134.54,76.28 133.88,75.63 133.88,69.12 135.9,67.1 146.42,67.1 147.92,65.6 152.96,65.6 153.74,64.81 153.74,63.48 154.55,62.67 155.56,62.67 155.87,62.35 155.87,60.85 157.21,59.52 158.34,59.52 159.68,58.18 159.68,56.45 160.06,56.07 160.2,56.07 160.77,55.5 160.77,52.76 160.67,52.66 160.55,52.66 160.49,52.72 160.42,52.72 160.34,52.81 v1(160.34,52.94)
  BOTTOM w0.076: v1(160.34,52.94) 160.53,53.13 UC1.AL15
  BOTTOM w0.102: LV27.3 106.22,92.67 106.32,92.78 106.32,93 106.45,93.13 106.57,93.13 v1(107.1,93.65)
USBP4-: length 106.7
  IN4 w0.089: v1(106.51,93.65) 106.73,93.87 106.73,95.63 108.85,97.75 115.21,97.75 116.32,98.86 116.32,99.67 116.98,100.33 118.14,100.33 118.92,99.55 129.09,99.55 129.95,100.41 131.75,100.41 133.22,98.95 135.64,98.95 136.44,98.15 136.44,91.49 134.71,89.77 134.71,76.21 134.05,75.56 134.05,69.19 135.97,67.27 146.49,67.27 147.99,65.77 153.03,65.77 153.91,64.88 153.91,63.55 154.62,62.84 155.63,62.84 156.04,62.42 156.04,60.92 157.28,59.69 158.41,59.69 159.85,58.25 159.85,56.53 160.13,56.24 160.27,56.24 160.94,55.57 160.94,52.69 160.55,52.29 160.42,52.29 v1(160.32,52.2)
  BOTTOM w0.076: UC1.AM15 160.61,52.48 v1(160.32,52.2)
  BOTTOM w0.102: v1(106.51,93.65) 106.56,93.61 106.56,93.43 106.46,93.33 106.19,93.33 106,93.52 LV27.2
USBP4_D+: length 12.5
  BOTTOM w0.102: JEDP1.3 100.39,99.89 100.55,99.73 100.55,98.54 100.03,98.02 100.03,97.04 101.07,96 101.07,95.91 100.97,95.81 100.55,95.81 DV4.3 100.99,95.49 101.09,95.39 101.09,93.91 101.07,93.89 101.07,93.29 101.09,93.27 101.09,93.1 101.49,92.69 101.87,92.69 101.89,92.67 v3(102.7,92.67) LV27.4
USBP4_D-: length 12.6
  BOTTOM w0.102: LV27.1 103.3,93.52 103.11,93.33 103.11,93.11 102.91,92.9 101.58,92.9 101.3,93.18 v3(101.3,93.59) 101.3,95.39 101.4,95.49 DV4.2 101.82,95.82 101.39,95.82 101.28,95.93 101.28,96.09 100.24,97.13 100.24,97.94 100.76,98.46 100.76,99.79 100.89,99.93 JEDP1.2
USBP5+: length 121.3
  IN4 w0.089: v1(162.28,52.14) 162.34,52.2 162.34,52.22 162.53,52.41 162.53,53.09 162.29,53.33 161.77,53.33 161.55,53.55 161.55,56.7 161.34,56.91 161.34,59.05 160.62,59.77 160.62,60.67 159.53,61.76 157.78,61.76 157.36,62.17 156.79,62.17 156.38,62.59 156.38,63.15 155.59,63.93 155.15,63.93 154.83,64.26 154.83,66.48 154.2,67.11 150.05,67.11 147.71,69.45 136.36,69.45 135.87,69.94 135.87,83.07 135.76,83.19 135.76,88.25 137.26,89.76 137.26,98.34 135.08,100.52 133.86,100.52 133.16,101.22 110.35,101.22 109.98,101.59 106.71,101.59 106.09,100.97 101.03,100.97 100.4,100.34 96.11,100.34 94.74,98.97 94.74,95.48 94.48,95.21 94.22,95.21 v1(94.01,95.43)
  BOTTOM w0.076: UC1.AN13 161.51,52.26 162.15,52.26 v1(162.28,52.14)
  BOTTOM w0.102: v1(94.01,95.43) 94.17,95.27 94.44,95.27 94.61,95.44 94.61,95.84 94.21,96.25 LZ1.1
USBP5-: length 121.3
  IN4 w0.089: v1(94.03,94.84) 94.02,94.84 94.22,95.04 94.55,95.04 94.91,95.41 94.91,98.9 96.18,100.17 100.47,100.17 101.1,100.8 106.16,100.8 106.78,101.42 109.91,101.42 110.28,101.05 133.09,101.05 133.79,100.35 135.01,100.35 137.09,98.27 137.09,89.83 135.59,88.32 135.59,83.12 135.7,83 135.7,69.87 136.29,69.28 147.64,69.28 149.98,66.94 154.12,66.94 154.66,66.41 154.66,64.18 155.08,63.76 155.52,63.76 156.21,63.07 156.21,62.52 156.72,62 157.29,62 157.71,61.59 159.46,61.59 160.45,60.6 160.45,59.7 161.17,58.98 161.17,56.84 161.38,56.63 161.38,53.48 161.7,53.16 162.22,53.16 162.36,53.02 162.36,52.58 162.3,52.52 162.03,52.52 v1(161.9,52.64)
  BOTTOM w0.076: UC1.AM13 161.41,52.91 161.52,53.03 161.84,53.03 161.9,52.96 v1(161.9,52.64)
  BOTTOM w0.102: v1(94.03,94.84) 94.25,95.06 94.52,95.06 94.82,95.35 94.82,95.79 95.06,96.03 LZ1.4
USBP5_D+: length 3.2
  BOTTOM w0.102: JEDP1.13 95.39,100.02 95.57,99.84 95.57,99.64 95.12,99.18 94.91,99.18 94.58,98.85 94.58,98.57 LZ1.2
USBP5_D-: length 3.1
  BOTTOM w0.102: LZ1.3 94.79,98.47 94.79,98.76 95,98.97 95.2,98.97 95.78,99.55 95.78,99.84 95.89,99.95 JEDP1.12
USBP6+: length 97.6
  TOP w0.102: JUSH1.18 233.94,20.8 232.56,22.18 232.56,27.97 231.72,28.81 231.72,33.76 231.18,34.31 222.28,34.31 v3(221.04,35.55) 220.73,35.85 v1(220.73,37.4)
  IN4 w0.089: v1(220.73,37.4) 220.73,37.22 220.64,37.13 219.79,37.13 219.4,37.52 206.93,37.52 202.19,42.26 200.1,42.26 199.66,42.69 198.11,42.69 197.97,42.84 195.21,42.84 194.58,42.21 191.99,42.21 191.79,42.01 185.96,42.01 184.46,43.51 182.66,43.51 181.87,44.29 177.21,44.29 175.62,45.88 172.5,45.88 172,46.38 170.64,46.38 168.75,48.27 163.91,48.27 163.88,48.24 163.58,48.24 162.78,49.03 162.78,51.1 162.64,51.23 162.64,51.39 162.53,51.51 v1(162.37,51.51)
  BOTTOM w0.076: UC1.AN11 162.69,51.83 v1(162.37,51.51)
USBP6-: length 97.6
  TOP w0.102: JUSH1.19 236.56,21.3 236.49,21.23 236.49,21.07 236.44,21.01 234.02,21.01 232.77,22.27 232.77,28.06 231.93,28.9 231.93,33.85 231.26,34.51 222.36,34.51 221.41,35.47 221.41,35.5 220.99,35.92 220.98,35.92 220.94,35.96 220.94,37.03 v1(221.31,37.4)
  IN4 w0.089: v1(162.37,50.86) 162.61,50.62 162.61,48.96 163.51,48.07 163.95,48.07 163.98,48.1 168.68,48.1 170.57,46.21 171.93,46.21 172.43,45.71 175.55,45.71 177.14,44.12 181.8,44.12 182.59,43.33 184.39,43.33 185.89,41.84 191.86,41.84 192.06,42.04 194.65,42.04 195.28,42.67 197.9,42.67 198.04,42.52 199.59,42.52 200.03,42.09 202.12,42.09 206.86,37.35 219.33,37.35 219.72,36.96 220.87,36.96 v1(221.31,37.4)
  BOTTOM w0.076: v1(162.37,50.86) 162.69,51.18 UC1.AP11
USBP7+: length 225.9
  IN1 w0.089: v1(161.8,51.83) 161.7,51.94 161.11,51.94 160.88,51.71 160.88,50.48 161.82,49.54 162.39,49.54 162.6,49.33 162.6,48.24 166.22,44.61 168.47,44.61 170.21,42.87 171.9,42.87 174.57,40.21 179.72,40.21 182.09,37.84 182.09,35.39 188.21,29.26 199.39,29.26 202.23,26.42 228.31,26.42 233.71,31.82 233.71,34.49 234.35,35.13 234.97,35.13 236.82,36.98 236.82,37.6 237.84,38.62 239.41,38.62 244.38,43.58 265.47,43.58 265.96,43.1 265.96,38.57 267.15,37.37 284.77,37.37 288.1,40.71 298.28,40.71 299.94,42.36 299.94,42.82 v1(300.1,42.98)
  BOTTOM w0.076: UC1.AP13 161.48,51.51 v1(161.8,51.83)
  BOTTOM w0.102: JNGFF2.7 292,85.11 291.02,85.11 290.94,85.18 290.94,85.32 290.87,85.39 289.46,85.39 288.69,84.62 288.69,82.12 288.16,81.59 286.31,81.59 285.82,81.11 285.82,79.64 286.22,79.24 286.22,76.05 290.84,71.43 290.84,62.61 291.9,61.55 291.9,57.76 293.51,56.15 293.51,51.57 295.05,50.04 295.08,50.04 295.5,49.61 295.5,49.59 296.28,48.8 296.28,48.63 296.28,45.92 296.86,45.35 298.97,45.35 299.84,44.48 299.84,43.24 v1(300.1,42.98)
USBP7-: length 225.9
  IN1 w0.089: v1(299.52,42.98) 299.54,42.98 299.77,42.75 299.77,42.43 298.21,40.88 288.03,40.88 284.7,37.54 267.22,37.54 266.13,38.64 266.13,43.17 265.54,43.75 244.31,43.75 239.34,38.79 237.77,38.79 236.65,37.67 236.65,37.05 234.9,35.3 234.28,35.3 233.54,34.56 233.54,31.89 228.24,26.59 202.31,26.59 199.46,29.43 188.29,29.43 182.26,35.46 182.26,37.91 179.79,40.38 174.64,40.38 171.97,43.04 170.28,43.04 168.54,44.78 166.29,44.78 162.77,48.31 162.77,49.4 162.46,49.71 161.89,49.71 161.05,50.55 161.05,51.64 161.18,51.77 161.35,51.77 161.42,51.7 161.42,51.09 161.54,50.97 161.68,50.97 161.8,51.09 v1(161.8,51.18)
  BOTTOM w0.076: UC1.AR13 161.48,50.86 v1(161.8,51.18)
  BOTTOM w0.102: v1(299.52,42.98) 299.63,43.09 299.63,44.39 298.88,45.14 296.77,45.14 296.08,45.83 296.08,48.71 295.29,49.5 295.29,49.5 295.13,49.66 v3(295.13,49.66) 295.08,49.7 295.08,49.7 294.96,49.82 294.96,49.83 293.31,51.48 293.31,56.06 291.69,57.67 291.69,61.47 290.63,62.53 290.63,71.34 286.01,75.96 286.01,79.15 285.61,79.55 285.61,81.19 286.22,81.8 288.07,81.8 288.48,82.21 288.48,84.71 289.38,85.6 JNGFF2.9
USBRBIAS: length 3.6
  TOP w0.076: v1(162.92,53.72) 162.73,53.72 v2(162.45,53.44) 162.23,53.23 RC152.1
  BOTTOM w0.076: v1(162.92,53.72) 162.81,53.72 162.52,54.02 UC1.AJ11 162.63,54.22 163.22,54.22 UC1.AJ10
USH_DET#: length 169
  TOP w0.076: 170.65,67.99 v1(167.25,67.99)
  TOP w0.102: 170.65,67.99 170.73,67.99 171.17,68.43 v1(173.69,68.43) 174.21,68.43 176.24,66.4 176.72,66.4 177.2,65.92 177.77,65.92 179.2,64.49 179.2,63.92 179.3,63.82 RPC6.6 ; JUSH1.1 233.23,12.3 231.85,13.68 231.85,27.79 231.09,28.55 231.09,33.48 v1(230.89,33.68) ; v1(235.36,43.23) 235.36,44.44 236.02,45.1 236.02,46.23 236.19,46.41 236.19,53.34 237.34,54.49 237.34,59.06 237.58,59.3 237.58,72.6 236.61,73.56 236.61,75.07 239.44,77.9 239.44,83.24 v2(239.18,83.51) v1(238.62,84.06)
  IN4 w0.089: v1(173.69,68.43) 174.01,68.1 180.4,68.1 182.41,70.11 184.76,70.11 186.14,71.49 187.89,71.49 200.83,84.43 222.08,84.43 222.36,84.15 231.11,84.15 231.32,83.94 238.49,83.94 v1(238.62,84.06)
  BOTTOM w0.076: UC1.E3 167.29,67.95 167.28,67.95 v1(167.25,67.99)
  BOTTOM w0.102: v1(230.89,33.68) 230.89,34.39 235.36,38.86 v1(235.36,43.23)
USH_PWR_STATE#: length 76.1
  TOP w0.102: v1(250.67,72.67) 251.01,73 251.01,73 251.17,73.16 UE1.A34 ; RZ10.2 239.04,13.27 v2(238.79,13.52) v1(238.26,14.06) 238.01,14.3 JUSH1.5
  IN2 w0.122: v1(237.85,37.07) 237.79,37.07 236.74,36.02 236.74,29.86 237.52,29.09 237.52,16.64 238.68,15.47 238.68,14.48 v1(238.26,14.06)
  BOTTOM w0.102: v1(237.85,37.07) 238.32,37.54 239.29,37.54 239.61,37.86 239.61,40.1 242.4,42.89 242.4,46.93 244.53,49.05 244.53,51.19 245.92,52.58 245.92,53.55 246.61,54.23 248.13,54.23 249.09,55.18 250.79,55.18 252.37,56.77 252.37,59.86 251.78,60.45 251.18,60.45 251.16,60.48 250.8,60.48 250.34,60.94 250.34,63.9 251.99,65.55 251.99,69.78 250.67,71.1 v1(250.67,72.67)
USH_SMBCLK: length 51.9
  TOP w0.102: v1(253.19,52.95) 254.01,52.95 254.6,53.54 UE2.A50 ; RZ8.2 239.38,20.89 v1(239.28,21) 238.89,20.6 238.84,20.6 238.03,19.8 JUSH1.16
  IN1 w0.089: v1(242,53.01) 242,53.53 242.1,53.63 252.53,53.63 253.12,53.04 253.12,53.01 v1(253.19,52.95)
  IN2 w0.122: v1(239.28,21) 239.28,22.82 238.73,23.38 238.73,35.32 238.99,35.58 v1(238.99,37.99)
  BOTTOM w0.102: v1(238.99,37.99) 238.85,38.13 238.85,40.82 240.58,42.55 240.58,44.01 240.89,44.33 240.89,47.69 242.18,48.97 242.18,49.62 242.51,49.95 242.51,52.5 v1(242,53.01)
USH_SMBDAT: length 57
  TOP w0.102: UE2.B53 254.35,55.25 254.42,55.31 254.42,55.79 254.45,55.82 254.45,56.34 v1(254.84,56.73) ; JUSH1.15 238.27,19.3 v2(238.76,19.79) 239.2,20.23 v1(239.27,20.23) 239.77,20.23 RZ9.2
  IN1 w0.089: v1(241.45,52.68) 241.53,52.76 241.53,53.72 241.91,54.1 253.7,54.1 254.42,54.83 254.42,56.29 254.84,56.71 v1(254.84,56.73)
  IN2 w0.122: v1(238.34,37.95) 238.48,37.81 238.48,35.82 238.23,35.56 238.23,22.89 238.72,22.39 238.72,20.77 v1(239.27,20.23)
  BOTTOM w0.102: v1(238.34,37.95) 238.37,37.98 238.37,41.02 240.09,42.75 240.09,44.21 240.41,44.53 240.41,47.89 241.69,49.17 241.69,49.7 242.18,50.18 242.18,52.07 241.57,52.68 v1(241.45,52.68)
VCI_IN2#: length 11.8
  TOP w0.102: v1(258.85,56.15) 259.35,55.65 UE2.B63 ; RPE5.4 v1(265.72,57.74)
  IN3 w0.122: v1(258.85,56.15) 259,56.15 259.38,55.77 259.38,55.39 259.69,55.08 262.07,55.08 262.71,55.72 262.71,56.14 263.87,57.29 265.28,57.29 v1(265.72,57.74)
  BOTTOM w0.102: v2(258.74,56.84) 258.74,56.26 v1(258.85,56.15)
VCT_LAN_R1:
  vias: v2(273.47,86.68)
VFB: length 2.8
  BOTTOM w0.203: PU500.24 107.14,69.34 107.51,68.98 107.71,68.98 107.73,69
  BOTTOM w0.254: PR531.2 109.03,68.39 108.42,69 107.73,69
VGA_ID: length 8.4
  TOP w0.102: UE1.B59 v1(258.29,78.94) ; v2(261.28,81.09) 261.84,81.09 v1(261.87,81.05) 261.82,81 261.82,80.57 262.32,80.08 RE85.1 RE84.1
  IN2 w0.122: v1(261.87,81.05) 261.85,81.05 260.87,80.08 259.43,80.08 v1(258.29,78.94)
VIDALERT_N: length 33.4
  TOP w0.102: v1(121.28,58.35) 121.15,58.49 RC207.2 RC204.2
  IN4 w0.089: v1(102.81,67.9) 102.81,67.78 103.27,67.33 103.72,67.33 104.63,68.24 108.36,68.24 109.16,67.44 110.01,67.44 110.02,67.45 119.86,67.45 120.24,67.07 121.02,66.29 121.02,60.49 121.84,59.66 121.84,59.21 121.65,59.02 121.65,58.71 v1(121.28,58.35)
  BOTTOM w0.102: PU500.32 103.21,68.3 v1(102.81,67.9) 102.44,67.9 101.83,67.29 101.83,66.12 PR528.2
VIDSCLK: length 45
  IN4 w0.086: v1(129.74,62.73) 130.25,63.24 130.25,64.63 130.47,64.85 131.91,64.85 132.39,65.33 133.25,65.33 133.5,65.58 133.61,65.58 133.94,65.91 133.94,66.62 133.69,66.86 133.13,66.86 132.81,66.55 130.34,66.55 129.79,67.1 127.45,67.1
  IN4 w0.089: v3(103.49,67.87) 104.41,68.79 108.59,68.79 109.39,67.99 109.78,67.99 109.8,68 120.26,68 121.17,67.1 127.45,67.1
  BOTTOM w0.102: UC1.N63 130.32,63.05 129.99,62.73 v1(129.74,62.73) ; PR527.2 103.21,66.06 103.34,66.18 103.34,66.45 103.21,66.57 102.51,66.57 102.39,66.7 102.39,67.06 102.64,67.31 103,67.31 103.05,67.26 103.05,67.15 103.14,67.07 v2(103.29,67.07) 103.43,67.07 103.57,67.21 103.57,67.79 v3(103.49,67.87) 103.61,67.99 PU500.31
