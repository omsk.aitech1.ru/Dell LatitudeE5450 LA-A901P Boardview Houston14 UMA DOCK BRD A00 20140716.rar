# Allegro board Houston14_UMA_DOCK_BRD_A00_20140716.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
POWER_SW_IN#: length 11.8
  TOP w0.102: v1(262.62,53.55) 262.76,53.55 263.61,52.69 v2(264.92,52.69) 265.95,52.69 RE31.2 266.74,53.69 266.03,54.4 RE33.1 CE12.1 ; v1(260.84,56.15) 261.02,55.97 261.02,55.97 261.26,55.73 261.26,55.3 261.35,55.2 UE2.B67
  IN4 w0.089: v1(262.62,53.55) 261.3,54.87 261.3,55.69 v1(260.84,56.15)
PROC_OPI_RCOMP: length 7.5
  BOTTOM w0.203: UC1.AY15 160.43,47.54 160.43,47.17 160.55,47.04
  BOTTOM w0.305: 160.55,47.04 160.55,46.81 160.87,46.5 160.87,45.58 161.99,44.46 v2(161.99,42.31) 161.99,42.18 161.14,41.33 RC187.1
PROCHOT_GATE: length 3.3
  TOP w0.102: RE83.2 262.47,75.97 261.82,75.33 261.43,75.33 v2(261.26,75.49) 260.92,75.49 260.22,76.19 UE1.A50
PS8338_CFG0: length 2.1
  BOTTOM w0.102: UV7.59 v2(145.87,92.65) 146.65,92.65 RV51.2
PS8338_SW: length 6.7
  BOTTOM w0.102: UV7.18 137.25,90.65 136.63,90.03 v2(136.32,90.03) 136.03,90.03 RV52.2 134.7,88.7 134.7,87.24 134.88,87.06 QV11.1
PS8338B_P0: length 4.7
  BOTTOM w0.102: v2(148.87,90.96) 147.32,90.96 RV60.2 146.03,92.25 UV7.60
PS8338B_P1: length 5.9
  BOTTOM w0.102: UV7.1 144.05,91.1 144.37,90.77 144.82,90.77 145.33,90.26 RV53.2 RV100.1 v2(146.82,90.35)
PS8338B_PC10: length 6.6
  BOTTOM w0.102: UV7.56 145.41,93.85 145.61,93.65 146.66,93.65 RV58.2 146.77,93.44 147.17,93.04 148.82,93.04 RV65.1 149.52,93.33 149.52,92.74 v2(149.9,92.36)
PS8338B_PC11: length 5.3
  BOTTOM w0.102: RV63.1 148.86,94.1 147.21,94.1 146.77,94.53 RV57.2 146.19,93.97 145.71,93.97 145.43,94.25 UV7.55
PS8338B_PC20: length 5.4
  BOTTOM w0.102: UV7.54 145.28,94.65 145.46,94.83 146.06,94.83 146.77,95.54 146.77,95.56 ; 146.77,95.56 RV56.2 ; 146.77,95.56 147.27,95.06 148.81,95.06 RV64.1
PS8338B_PC21: length 7.2
  BOTTOM w0.102: UV7.53 145.25,95.05 145.27,95.06 145.83,95.06 146.13,95.35 146.13,95.94 RV55.2 146.81,96.59 147.33,96.07 148.79,96.07 RV62.1 v2(149.31,97.81)
PS8338B_PEQ: length 4.6
  TOP w0.102: v2(143.42,91.38) 143.37,91.43 RV61.1 RV54.2 141.14,90.63 141.25,90.52 v1(141.25,90.35)
  BOTTOM w0.102: UV7.8 v1(141.25,90.35)
PS_ID: length 293.3
  TOP w0.122: UE2.B24 258.85,63.55 v1(258.74,63.44)
  IN2 w0.122: v1(84.19,22.85) 83.96,23.08 83.96,47.69 82.68,48.97 82.68,55.29 80.2,57.76 80.2,59.71 73.67,66.23 73.67,73.37 72.8,74.25 62.89,74.25 60.06,77.08 57.53,77.08 56.3,78.31 v1(41.9,78.31)
  IN3 w0.122: v1(258.74,63.44) 258.74,63.51 258.14,64.1 254.06,64.1 253.2,63.25 253.2,62.88 252.58,62.25 252.58,61.14 251.94,60.5 247.2,60.5 245.98,59.28 245.98,58.66 243.43,56.11 242.29,56.11 240.79,54.61 240.79,52.19 239.99,51.4 239.99,50.08 239.41,49.5 239.41,46.65 236.76,44 230.99,44 230.35,43.36 228.69,43.36 225.69,40.36 225.69,35.59 225.39,35.28 218.21,35.28 217.2,36.29 208.74,36.29 198.5,26.05 107.73,26.05 107.25,26.53 105.82,26.53 104.38,25.1 99.75,25.1 96.37,21.72 92.93,21.72 92.31,22.34 88.3,22.34 87.73,22.91 84.25,22.91 v1(84.19,22.85)
  BOTTOM w0.122: PU1.4 v2(41.9,78.91) v1(41.9,78.31)
PS_USBP1_D+: length 15.4
  TOP w0.102: v1(310.49,75.61) 310.24,75.85 309.9,75.85 309.59,76.16 309.59,77.36 309.16,77.79 309.03,77.79 308.97,77.73 308.97,77.6 308.91,77.54 UI3.10
  BOTTOM w0.102: v1(310.49,75.61) 309.22,75.61 308.7,76.13 303.08,76.13 301.75,77.45 301.75,78.12 302.1,78.47 LI7.1
PS_USBP1_D-: length 15.2
  TOP w0.102: v1(310.49,76.22) 310.33,76.06 309.98,76.06 309.8,76.25 309.8,77.44 309.2,78.04 UI3.11
  BOTTOM w0.102: v1(310.49,76.22) 310.08,75.81 309.31,75.81 308.79,76.33 303.16,76.33 301.96,77.54 301.96,78.03 302.17,78.25 302.27,78.25 302.36,78.16 302.36,77.75 302.49,77.62 LI7.4
PSID_DISABLE#: length 276.8
  TOP w0.102: UE1.A37 252.67,73.56 252.91,73.32 v1(252.91,73.23) ; v2(48.81,80.58) v1(48.81,81.26)
  IN3 w0.122: v1(252.91,73.23) 252.47,73.67 250.17,73.67 240.31,63.81 240.31,61.81 239.52,61.03 239.52,56.12 237.44,54.04 237.44,48.56 235.45,46.57 229.24,46.57 223.02,40.34 207.83,40.34 197.23,29.74 119.36,29.74 119.33,29.71 105.41,29.71 104.21,30.91 98.91,30.91 98.8,30.8 91.91,30.8 v1(91.4,31.31)
  IN4 w0.089: v1(48.81,81.26) 49.04,81.02 59.74,81.02 60.19,80.57 65.71,80.57 69.41,76.88 72.75,76.88 73.45,76.17 73.45,75.9 75.58,73.77 75.58,69.84 77.11,68.31 77.11,67.97 81.58,63.49 85.97,63.49 88.21,61.24 88.21,49.47 86.79,48.05 86.79,37.18 87.86,36.11 92.44,36.11 92.75,35.8 92.75,32.65 v1(91.4,31.31)
  BOTTOM w0.254: PR13.2 v1(48.81,81.26)
PWM1: length 54.7
  TOP w0.102: v2(101.13,71.95) 101.13,71.88 v3(101.67,71.34)
  IN4 w0.254: v3(101.67,71.34) 101.67,71.38 99.89,73.17 99.89,74.26 100.6,74.97 104.61,74.97 106.97,77.33 110.15,77.33 111.62,75.86 117.18,75.86 118.3,76.98 118.3,91.4 119.63,92.73 130.16,92.73 130.59,92.29 v3(130.59,92.08)
  BOTTOM w0.203: PU501.8 130.54,91.63 130.59,91.68 v3(130.59,92.08) ; PU500.6 v3(101.67,71.34)
PWR_SRC_ON: length 5.8
  TOP w0.102: v2(93.51,92.52) 93.43,92.45 CV11.2 RV4.2 91.25,92.45 RV5.1 89.73,93.97 89.73,94.55 89.86,94.68 QV1.3
RED: length 12.7
  TOP w0.102: JCRT1.1 255.36,114.44 DV5.2 255.36,107.51 CV54.1 255.23,107.38 LV16.2 v2(252.98,107.38)
RED_2320: length 21.8
  TOP w0.102: RV76.1 160.82,89.44 v1(160.48,89.78) 160.39,89.87 160.39,90.94 UV8.M6 ; UV16.1 176.09,92.06 175.6,91.57 v1(175.17,91.57)
  BOTTOM w0.102: v1(175.17,91.57) 174.62,91.02 169.93,91.02 168.95,90.05 165.05,90.05 164.15,90.95 162.47,90.95 161.3,89.78 v1(160.48,89.78)
RED_CRT: length 91.8
  TOP w0.102: v1(175.49,96.64) 175.81,96.32 175.81,96.31 176.09,96.02 UV16.27 ; v1(255.14,98.54) 255.14,103.11 254.22,104.04 RV32.1 CV51.1 254.22,105.93 254.29,106.01 LV16.1
  IN1 w0.089: v1(175.49,96.64) 175.55,96.64 175.99,97.08 176.14,97.08 176.5,97.44 180,97.44 180.81,96.62 186.23,96.62 187.96,98.35 190.06,98.35 190.58,97.83 200.85,97.83 201.03,97.65 225.98,97.65 226.47,98.14 229.54,98.14 229.91,98.5 241.86,98.5 242.3,98.95 250.2,98.95 250.52,98.63 255.05,98.63 v1(255.14,98.54)
RED_DOCK: length 26.9
  TOP w0.102: v1(176.58,97.84) 176.45,97.84 176.03,97.43 176.03,96.54 176.49,96.08 UV16.26
  IN4 w0.089: v1(161.23,108.88) 161.25,108.88 163.32,106.81 166.52,106.81 168.38,104.96 169.23,104.96 171.09,103.09 171.09,101.4 171.69,100.8 174.77,100.8 176.58,98.99 v1(176.58,97.84)
  BOTTOM w0.102: JDOCK1.53 159.9,108.99 160.01,108.88 v1(161.23,108.88)
REGCTL_PNP10:
  vias: v2(272.96,84.9)
REM_DIODE1_N: length 219.3
  TOP w0.102: v1(264.45,71.82) v2(264.45,71.19)
  TOP w0.254: UE2.B13 262.01,61.5 v1(261.75,61.76) ; v1(152.31,73.09) 152.57,73.35 153.52,73.35 153.78,73.09 153.78,73.07 154.21,72.63 154.21,67.19 154.47,66.93 154.47,65.75 153.56,64.83 153.56,60.98 152.28,59.71 CE35.1 146.21,59.71 QE3.3 ; v1(265.65,62.21) 266.2,62.21 CE24.1 266.88,62.78 266.88,62.16 v1(267.17,61.86)
  IN1 w0.254: v1(261.75,61.76) 263.32,61.76 263.94,62.38 265.07,62.38 265.25,62.21 v1(265.65,62.21) ; v1(147.51,83.86) 147.5,83.86 147.4,83.76 147.04,83.76 146.72,83.44 145.76,83.44 145.42,83.78 145.42,86.43 145.19,86.65 144.72,86.65 143.7,85.64 143.7,79.59 143.17,79.06 143.17,71.3 143.93,70.53 143.93,68.09 145.26,66.76 145.26,65.43 145.92,64.77 151.53,64.77 152.19,65.44 152.19,66.42 151.49,67.12 151.49,69.01 153.73,71.26 153.73,72.81 153.33,73.22 152.44,73.22 v1(152.31,73.09)
  IN2 w0.254: v1(147.51,83.86) 147.61,83.76 152.46,83.76 153.25,84.55 163.13,84.55 163.89,83.78 169.81,83.78 169.95,83.92 174.89,83.92 175.33,83.48 177.32,83.48 177.69,83.85 193.43,83.85 199.81,90.24 209.17,90.24 210.97,88.43 221.21,88.43 223.16,86.48 223.91,86.48 225.95,84.44 226.86,84.44 233.79,77.51 233.79,77 237.68,73.11 237.68,72.76 239.65,70.79 244.48,70.79 245.03,71.35 247.68,71.35 247.87,71.16 251.05,71.16 251.47,70.73 252.62,70.73 253.4,71.52 262.56,71.52 263.44,72.39 263.88,72.39 v1(264.45,71.82)
  BOTTOM w0.254: v1(264.45,71.82) 264.99,71.29 264.99,68.93 267.61,66.3 267.62,66.31 267.63,66.31 267.7,66.25 267.7,64.68 267.17,64.14 v1(267.17,61.86)
REM_DIODE1_P: length 222.8
  TOP w0.102: v2(266.48,64.96) 266.48,64.94 v1(266.87,64.56)
  TOP w0.254: v1(266.17,63.85) 266.27,63.74 CE24.2 266.83,64.47 266.87,64.51 v1(266.87,64.56) ; v1(264.13,61.83) 264.06,61.75 UE2.A13 ; QE3.1 145.33,59.25 145.98,58.6 QE3.2 146.21,58.79 CE35.2 147.76,59.2 152.49,59.2 154.06,60.77 154.06,64.62 154.98,65.53 154.98,67.14 154.72,67.4 154.72,72.84 154.28,73.28 154.28,73.3 153.73,73.85 153.71,73.85 152.25,73.85 v1(152.12,73.73)
  IN1 w0.254: v1(266.17,63.85) 266.42,63.59 266.42,61.85 265.85,61.28 264.68,61.28 v1(264.13,61.83) ; v1(152.12,73.73) 153.54,73.73 154.24,73.02 154.24,71.05 151.99,68.8 151.99,67.33 152.7,66.63 152.7,65.22 151.74,64.26 145.71,64.26 144.75,65.22 144.75,66.55 143.42,67.88 143.42,70.32 142.66,71.08 142.66,79.36 143.24,79.95 143.24,85.9 144.51,87.16 145.4,87.16 145.92,86.64 145.92,84.32 v1(146.29,83.95)
  IN2 w0.254: v1(263.69,71.82) 262.93,71.06 262.82,71.06 262.77,71.01 253.61,71.01 252.83,70.23 251.26,70.23 250.84,70.65 247.66,70.65 247.46,70.84 245.26,70.84 244.7,70.28 239.44,70.28 237.17,72.55 237.17,72.9 233.29,76.79 233.29,77.3 226.65,83.94 225.74,83.94 223.7,85.97 222.95,85.97 221,87.92 210.76,87.92 208.96,89.73 200.03,89.73 193.64,83.34 177.9,83.34 177.53,82.97 175.12,82.97 174.57,83.53 170.23,83.53 170,83.3 163.65,83.3 162.92,84.04 153.46,84.04 152.67,83.25 147.4,83.25 147.25,83.4 146.7,83.95 v1(146.29,83.95)
  BOTTOM w0.254: v1(263.69,71.82) 264.48,71.03 264.48,68.72 267.2,66 267.2,64.89 v1(266.87,64.56)
REM_DIODE2_N: length 123.6
  TOP w0.254: UE2.B14 262.21,62 261.79,62.42 v1(261.79,62.61) ; v1(265.57,63.73) 265.53,63.77 CE26.1 264.46,63.77 264.13,63.44 v1(264.11,63.44)
  IN1 w0.254: v1(293.15,45.19) 293.15,45.3 292.54,45.91 291.29,45.91 289.3,43.92 284.3,43.92 283.72,44.5 275.18,44.5 274.4,43.72 271.4,43.72 v1(271.18,43.5)
  IN2 w0.254: v1(271.18,43.5) 271.14,43.54 270.63,43.54 270.21,43.12 266.53,43.12 265.75,43.9 244.97,43.9 242.29,41.21 241.55,41.21 241.27,40.94 241.27,31.22 241.03,30.98 241.03,26.45 241.99,25.49 242.71,25.49 243.17,25.03 v1(243.17,24.91)
  IN4 w0.254: v1(264.11,63.44) 263.28,62.61 v1(261.79,62.61) ; v1(271.18,43.5) 272.24,44.55 272.24,56.33 270.01,58.55 270.01,62.16 268.99,63.19 266.13,63.19 265.58,63.73 v1(265.57,63.73)
  BOTTOM w0.254: v1(243.17,24.91) 243.01,24.75 243.01,23.65 243.18,23.48 v2(243.18,16.83) 243.18,15.13 242.69,14.65 241.51,14.65 240.02,13.15 CE37.2 240.21,12.57 QE5.3 ; v1(293.15,45.19) 293.15,45.16 293.31,45.01 QE7.1 293.16,44.07 292.66,44.58 QE7.2 292.66,46.23 292.85,46.42 CE46.2
REM_DIODE2_P: length 120.3
  TOP w0.254: UE2.A14 263.71,62.25 264.31,62.85 CE26.2 265.54,62.85 v1(265.61,62.92)
  IN1 w0.254: v1(293.84,45.18) 293.84,45.3 292.72,46.42 291.08,46.42 289.03,44.36 284.58,44.36 283.93,45.01 274.97,45.01 274.19,44.22 271.18,44.22 v1(270.89,44.52)
  IN2 w0.254: v1(242.51,24.92) 241.85,24.92 240.53,26.24 240.53,31.19 240.77,31.44 240.77,41.15 241.34,41.72 242.07,41.72 244.76,44.41 265.96,44.41 266.74,43.63 270,43.63 v1(270.89,44.52)
  IN4 w0.254: v1(265.61,62.92) 265.68,62.92 265.92,62.68 268.74,62.68 269.46,61.97 269.46,58.31 271.7,56.06 271.7,45.33 v1(270.89,44.52)
  BOTTOM w0.254: QE5.1 238.91,10.18 QE5.2 238.91,12.57 CE37.1 239.1,12.96 241.3,15.15 v2(241.59,15.15) 242.48,15.15 242.67,15.34 242.67,23.24 242.51,23.41 v1(242.51,24.92) ; CE46.1 293.76,46.68 293.96,46.48 QE7.3 293.96,45.29 v1(293.84,45.18)
REM_DIODE4_N: length 253.5
  TOP w0.127: v2(93.76,70.04) 94.32,69.49 v1(94.32,69.49)
  TOP w0.254: v1(94.32,69.49) 94.37,69.45 94.37,69.12 94.38,69.1 QE6.3 94.38,65.84 94.58,65.65 CE39.1 ; UE2.A16 263.3,63.46 264.6,64.76 CE27.1 265.34,64.76 v1(265.52,64.94)
  IN2 w0.254: v1(103.75,99.96) 103.92,100.14 103.92,101.06 104.57,101.7 125.88,101.7 127.89,103.71 135.28,103.71 136.69,105.12 144.69,105.12 145.19,104.63 149.19,104.63 150.79,106.23 168.58,106.23 171.18,103.62 171.18,101.21 172.07,100.32 172.07,91.87 173.44,90.5 174.92,90.5 175.41,90.02 180.78,90.02 182.26,91.49 184.21,91.49 184.65,91.93 188.56,91.93 189.95,90.53 191.3,90.53 191.52,90.74 191.94,90.74 192.47,91.27 192.47,92.1 192.29,92.28 192.29,94.59 192.99,95.29 196.86,95.29 198.95,97.39 223.34,97.39 224.18,96.55 224.18,94.47 237.93,80.72 238.65,80.72 240.25,79.12 241.54,79.12 243.74,76.93 244.81,76.93 245.41,76.32 246.78,76.32 247.05,76.05 248.46,76.05 249.5,77.09 251.4,77.09 251.73,77.42 254.43,77.42 255.77,76.09 255.77,75.47 256.42,74.82 259.08,74.82 259.56,74.34 260.59,74.34 v1(261.39,73.54)
  IN4 w0.254: v1(103.75,99.96) 104.03,99.68 104.03,98.36 104.2,98.18 104.2,94.38 104.64,93.94 104.64,93.13 107.28,90.49 107.28,84.75 104.94,82.41 104.94,78.15 103.74,76.95 100.78,76.95 100.65,77.08 97.52,77.08 96.99,76.55 96.99,75.25 95.71,73.97 95.71,71.51 94.46,70.27 94.46,69.63 v1(94.32,69.49)
  BOTTOM w0.254: v1(261.39,73.54) 261.49,73.43 261.49,73.19 262.65,72.03 262.65,71.7 263.56,70.79 263.56,68.4 265.75,66.21 265.75,66.2 266.05,65.9 266.05,65.45 265.54,64.94 v1(265.52,64.94)
REM_DIODE4_P: length 253.1
  TOP w0.102: CE39.2 v2(96.69,65.09)
  TOP w0.254: UE2.B17 262.7,63.5 264.15,64.95 264.15,65.17 264.66,65.67 CE27.2 v1(265.48,65.67) ; CE39.2 95.49,65.97 QE6.1 95.03,67.68 QE6.2 95.68,68.87 v1(94.98,69.57)
  IN2 w0.254: v1(104.64,99.96) 104.37,100.23 104.37,100.96 104.72,101.32 126.04,101.32 128.05,103.33 135.44,103.33 136.85,104.74 144.53,104.74 145.03,104.24 149.34,104.24 150.95,105.85 168.42,105.85 170.8,103.46 170.8,101.05 171.69,100.16 171.69,91.71 173.28,90.12 174.76,90.12 175.25,89.64 180.94,89.64 182.42,91.11 184.37,91.11 184.8,91.54 188.4,91.54 189.8,90.15 191.46,90.15 191.67,90.36 192.1,90.36 192.85,91.11 192.85,92.26 192.67,92.43 192.67,94.43 193.15,94.91 197.02,94.91 199.11,97.01 223.18,97.01 223.8,96.39 223.8,94.31 237.78,80.34 238.49,80.34 240.09,78.74 241.38,78.74 243.58,76.55 244.65,76.55 245.26,75.94 246.62,75.94 246.89,75.67 248.62,75.67 249.66,76.71 251.55,76.71 251.88,77.04 254.27,77.04 255.38,75.93 255.38,75.31 256.26,74.44 258.92,74.44 259.4,73.95 260.16,73.95 v1(260.67,73.45)
  IN4 w0.254: v1(104.64,99.96) 104.41,99.74 104.41,98.51 104.58,98.34 104.58,94.53 105.02,94.1 105.02,93.29 107.66,90.65 107.66,84.59 105.32,82.25 105.32,77.99 103.9,76.57 100.62,76.57 100.5,76.7 97.68,76.7 97.37,76.39 97.37,75.09 96.09,73.81 96.09,71.36 94.84,70.11 94.84,69.71 v1(94.98,69.57)
  BOTTOM w0.254: v1(260.67,73.45) 260.69,73.45 262.27,71.87 262.27,71.54 263.18,70.63 263.18,68.24 265.37,66.05 265.37,66.05 265.48,65.94 v1(265.48,65.67)
RES_BIAS: length 3.7
  TOP w0.102: RL13.1 273.5,81.6 274.45,82.55 v2(274.45,83.1) 274.45,83.23 274.62,83.4 275.01,83.4 275.32,83.72 UL1.12
RESET_OUT#: length 133
  TOP w0.076: v1(167.17,43.69) 167.23,43.69 168.63,42.29 169.63,42.29 169.93,42 169.93,41.46 169.68,41.21 UC8.2
  TOP w0.102: UE2.B39 253.56,61.5 253.61,61.56 254.17,61.56 254.52,61.2 v1(254.52,61.04) ; RE56.2 249.92,61.86 251,62.94 251.02,62.94 v1(251.05,62.98)
  IN2 w0.122: v1(251.05,62.98) 250.67,63.36 250.67,63.76 250.93,64.02 252.08,64.02 253.07,63.04 253.07,61.85 253.33,61.58 254.2,61.58 254.52,61.27 v1(254.52,61.04)
  IN4 w0.086: 170.65,44.1 169.67,44.1 169.16,44.6 167.86,44.6 167.17,43.92 v1(167.17,43.69)
  IN4 w0.089: 170.65,44.1 174.5,44.1 176,42.6 180.09,42.6 182.27,40.41 190.6,40.41 190.87,40.68 192.05,40.68 192.45,41.07 197.59,41.07 198.06,41.54 199.17,41.54 199.32,41.4 199.57,41.15 201.71,41.15 203.02,39.84 203.02,39.84 206.46,36.4 218.03,36.4 219.53,34.9 226.42,34.9 227,35.48 227,40.01 228.3,41.3 228.81,41.3 229.23,41.3 232.14,44.21 239.88,44.21 240.58,44.91 241.72,44.91 v1(241.92,44.71) ; v1(251.05,62.98) 250.66,63.37 250.66,63.83 250.16,64.33 249.47,64.33 249.18,64.04 249.18,63.58 248.81,63.21 248.81,59.69 248.65,59.53 248.65,54.85 248.01,54.21 246.87,54.21 v1(245.44,52.78)
  BOTTOM w0.076: UC1.AY7 164.86,47.16 164.98,47.04
  BOTTOM w0.089: 164.98,47.04 164.98,46.25 167.17,44.06 v1(167.17,43.69)
  BOTTOM w0.102: v1(241.92,44.71) 241.92,47.13 243.54,48.74 243.54,50.88 v1(245.44,52.78)
RING2:
  vias: v1(15.28,88.57) v1(15.29,87.95) v1(22.19,96.5) v1(22.62,96.05)
RING2_R: length 0.9
  BOTTOM w0.508: v1(16.27,85.26) 16.43,85.09 DA3.2
  vias: v1(14.82,82.35) v1(14.82,81.77) v2(15.86,84.83)
RSMRST#: length 20.6
  TOP w0.102: RZ51.2 v1(242.39,71.41) ; UZ6.2 245.66,53.85 245.08,54.42 244.21,54.42 UZ5.3 243.81,55.68 RZ22.2 244.08,56.9 v1(243.85,57.13)
  BOTTOM w0.102: v1(243.85,57.13) v2(243.85,59.5) 243.85,60.43 243.41,60.87 243.41,63.19 243.19,63.4 243.19,70.61 v1(242.39,71.41)
RUN_ON: length 134.8
  TOP w0.102: RZ41.1 269.89,65.36 269.98,65.27 269.98,64.77 269.77,64.57 RPE10.1 269.47,65.14 v1(268.9,65.71) ; UZ9.3 v4(216.24,87.06) 216.24,86.43 v1(216.74,85.93) 217.22,86.41 217.22,87.02 217.04,87.2 UZ9.5 ; v1(177,79.44) 177.13,79.57 UZ7.3 ; v1(262.34,65.97) 262.31,65.97 261.91,66.36 QE2.2
  IN3 w0.122: v1(268.9,65.71) 268,66.61 264.5,66.61 263.86,65.97 v1(262.34,65.97) ; v1(260.64,80.86) 259.25,79.47 258.23,79.47 255.75,76.99 255.75,76.13 254.72,75.1 253.04,75.1 251.6,76.54 249.84,76.54 249.58,76.27 244.47,76.27 241.62,79.12 240.91,79.12 238.91,81.13 238.91,81.73 236.24,84.41 223.88,84.41 222.92,85.36 217.31,85.36 v1(216.74,85.93) 214.55,83.75 194.39,83.75 191.17,80.53 178.09,80.53 v1(177,79.44)
  BOTTOM w0.102: v1(260.64,80.86) 260.55,80.77 260.55,74.72 259.97,74.13 259.97,72.95 260.41,72.51 260.41,71.16 261.11,70.46 261.11,69.22 261.81,68.52 261.81,67.26 261.98,67.1 261.98,66.33 v1(262.34,65.97) 262.34,65.7 262.09,65.45 262.09,63.82 263.56,62.35 263.56,60.45
RUN_ON#: length 4.3
  TOP w0.102: v2(263.69,69.54) RE68.2 262.52,68.34 261.91,68.95 QE2.5 QE2.6
RUN_ON_EC: length 4.6
  TOP w0.102: v1(261.8,59.4) 261.9,59.5 UE2.B9
  BOTTOM w0.102: v1(261.8,59.4) 262.2,59.81 262.2,60.9 RE279.1 262.65,62.68 v2(262.47,62.85)
RUNPWROK: length 247.1
  TOP w0.102: v1(257.89,86.07) 257.89,86.01 257.42,85.54 256.95,85.54 256.67,85.26 UE1.A4 ; QE2.3 262.56,67.15 262.38,66.97 v1(262.38,66.55) ; UC7.1 107.04,34.6 v1(107.42,34.23) 107.42,34.06 107.71,33.77 107.71,32.28 v2(106.98,31.55) 106.09,30.66 v1(106.03,30.66) 104.88,31.81 104.88,34.29 104.48,34.69 v1(104.48,35.83) 104.67,35.64 UC7.13 ; UC7.4 v1(108.94,36.64) ; UE2.B26 257.85,63.45 v1(257.87,63.44) ; UC7.10 104.58,37.14 v1(104.44,37.28) ; RE67.2 v1(259.12,69.97)
  IN1 w0.089: v1(257.87,63.44) 258.27,63.04 258.27,62.69 257.59,62.02 255.17,62.02 254.46,62.73 254.19,62.73 254.08,62.62 253.75,62.62 253.51,62.85 253.51,63.1 252.09,64.52 247.5,64.52 247.33,64.35 241.58,64.35 241.29,64.65 237.4,64.65 236.59,65.46 v1(236.59,65.6)
  IN2 w0.122: v1(104.48,35.83) 104.48,37.24 v1(104.44,37.28) ; v1(107.42,34.23) 107.42,35.12 v1(108.94,36.64)
  IN4 w0.089: v1(208.61,42.84) 209.79,41.66 224.12,41.66 230,47.54 235.83,47.54 237.34,49.05 237.34,57.58 238.35,58.6 238.35,63.82 236.59,65.59 v1(236.59,65.6) ; v1(257.87,63.44) 257.87,64.03 258.52,64.68 259.41,64.68 260.36,65.64 260.36,66.39 260.82,66.84 261.82,66.84 262.12,66.55 v1(262.38,66.55) 262.38,68.73 260.62,70.5 259.65,70.5 v1(259.12,69.97)
  BOTTOM w0.102: v1(106.03,30.66) 106.09,30.66 106.2,30.55 108.87,30.55 110.96,32.64 175.95,32.64 179.34,36.03 183.55,36.03 184.49,36.97 185.84,36.97 186.99,38.13 190.49,38.13 193.32,35.3 193.32,33.04 193.8,32.55 195.05,32.55 198.22,35.73 207.12,35.73 208.46,37.06 208.46,42.69 v1(208.61,42.84) ; v1(257.89,86.07) 258,85.96 258,85.8 258.81,84.99 258.81,82.59 257.12,80.9 257.12,80.43 257.75,79.81 258.25,79.81 258.75,79.31 258.75,75.2 258.11,74.56 258.11,70.97 v1(259.12,69.97)
S5_1.35V: length 6.8
  BOTTOM w0.102: PR207.2 262.85,38.55 v2(264.33,38.55)
  BOTTOM w0.203: PU200.8 261.09,37.02 261.4,36.71
  BOTTOM w0.254: PR207.2 PC215.1 261.79,36.01 261.66,36.13 261.66,36.45 261.4,36.71
SATA2_PCIE6_L1: length 118.5
  TOP w0.102: UE1.A62 v1(260.67,82.19) ; v2(243.5,82.74) 243.5,82.11 v1(243.38,81.99)
  IN3 w0.122: v1(260.67,82.19) 259.7,82.19 259.2,81.7 254.74,81.7 254.42,82.02 250.96,82.02 250.95,82.02 249.76,82.02 248.45,80.71 246.31,80.71 244.89,82.13 243.52,82.13 v1(243.38,81.99)
  IN4 w0.086: 171.77,60.19 171.68,60.28 167.45,60.28 167.14,59.97 166.43,59.97 v1(166.08,59.62)
  IN4 w0.089: v1(243.38,81.99) 243.38,81.59 242.57,80.78 240.01,80.78 239.46,80.23 231.3,80.23 230.31,81.22 221.18,81.22 220.78,81.62 218.15,81.62 217.72,81.18 204.29,81.18 204.09,80.98 203.82,80.98 201.84,79 201.84,77.88 196.3,72.34 196.3,66.92 196.25,66.86 196.25,64.84 191.72,60.31 189.34,60.31 187.99,58.96 187.99,58.9 187.14,58.05 185.39,58.05 183.68,59.76 183.68,59.92 183.11,60.49 182.72,60.49 182.45,60.22 182.45,60.2 182.33,60.09 ; v1(182.33,59.91) 182.33,60.09 ; 182.33,60.09 182.33,60.1 181.95,60.49 176,60.49 175.7,60.19 171.77,60.19
  BOTTOM w0.076: UC1.V6 165.7,59.96 166.04,59.62 v1(166.08,59.62)
  BOTTOM w0.102: v1(182.33,59.91) 182.33,60.14 182.72,60.52 RPC3.6
SATA_ACT#: length 114.8
  TOP w0.102: v2(256.32,93.03) 256.25,93.11 v1(255.41,93.11) 255.41,92.57 255.45,92.53 QZ3.4
  IN1 w0.086: 170.65,65.92 169.67,65.92 169,65.24 169,63.26 170.54,61.72 v1(170.54,61.66)
  IN1 w0.089: 170.65,65.92 172.52,65.92 174.33,67.73 174.33,71.66 177.47,74.79 195.67,74.79 201.6,80.72 204.06,80.72 204.49,81.15 214.99,81.15 215.98,82.14 230.38,82.14 231.27,81.26 236.68,81.26 240.44,85.02 253.93,85.02 254.55,85.64 v1(254.55,85.97)
  BOTTOM w0.076: UC1.U3 167.94,60.47 168.46,60.47 168.69,60.71 168.69,60.89 168.86,61.05 169.87,61.05 170.48,61.66 v1(170.54,61.66)
  BOTTOM w0.102: v1(254.55,85.97) 254.42,86.1 254.42,92.11 v1(255.41,93.11)
SATA_COMP: length 11.3
  IN3 w0.381: v1(162.15,74.92) 162.15,73.84 162.34,73.65 162.34,72.42 163.16,71.61 163.16,70.35 162.52,69.71 162.52,68.43 v1(162.04,67.95)
  BOTTOM w0.203: UC1.C12 161.87,68.12 v1(162.04,67.95)
  BOTTOM w0.381: v1(162.15,74.92) 162.1,74.97 v2(162.1,75.69) 162.1,76.38 162.57,76.85 RC17.1
SATA_LED: length 104.3
  TOP w0.102: v1(293.08,42.23) 293.33,42.48 294.42,42.48 294.58,42.33 JLED1.3 ; QZ4.3 251.42,93.3 251.82,92.9 253.14,92.9 254.54,94.31 259.68,94.31 260.39,95.01 272.94,95.01 273.5,94.45 282.11,94.45 282.79,93.77 282.79,91.71 283.25,91.25 283.6,91.25 283.83,91.02 284.49,91.02 285.1,90.42 285.77,90.42 v2(287.71,88.48) 289.46,86.73 290.63,86.73 291.05,86.31 293.31,86.31 v1(293.34,86.35)
  IN2 w0.122: v1(293.34,86.35) 293.41,86.41 295.58,86.41 299.48,82.51 299.48,73.85 294.32,68.7 294.32,54.59 296.94,51.97 296.94,43.75 295.41,42.23 v1(293.08,42.23)
SATA_LED#: length 2.9
  TOP w0.102: QZ4.2 251.54,92.13 v2(252.77,92.13) 253.38,92.13 253.56,91.95 QZ3.6
SATA_PRX_DKTX_N0: length 4.9
  TOP w0.102: v1(162.11,115.55) 161.92,115.36 161.92,115.25 C313.2
  BOTTOM w0.102: v1(162.11,115.55) 162.11,115.6 161.56,116.14 160.82,116.14 160.25,116.71 160.25,117 160.4,117.15 JDOCK1.56
SATA_PRX_DKTX_N0_C: length 67.1
  TOP w0.102: v1(165.27,80.16) 165.27,79.87 165.14,79.74 164.34,79.74 164.08,80 162.68,80 162.03,79.35 162.03,75.62 162.83,74.83 162.83,71.6 164.5,69.93 164.5,67.86 165.37,66.99 165.37,65.73 165.58,65.52 165.85,65.52 v1(166.01,65.36) ; v1(161.06,112.59) 161.13,112.65 161.72,112.65 162.08,113.01 162.08,113.64 C313.1
  IN4 w0.089: v1(165.27,80.16) 165.7,80.59 165.7,80.62 165.96,80.88 167.74,80.88 170.66,83.79 170.66,89.04 170.21,89.49 170.21,99.02 168.57,100.66 168.57,102.18 168.19,102.56 167.26,102.56 165.35,104.48 162.03,104.48 159.88,106.64 159.88,107.78 159.41,108.25 159.41,109.56 160.82,110.97 160.82,111.34 161.67,112.19 161.67,112.72 161.51,112.88 161.35,112.88 161.34,112.87 v1(161.06,112.59)
  BOTTOM w0.076: UC1.J5 v1(166.01,65.36)
SATA_PRX_DKTX_P0: length 4.8
  TOP w0.102: v1(161.52,115.55) 161.71,115.36 161.71,115.2 C312.2
  BOTTOM w0.102: v1(161.52,115.55) 161.58,115.61 161.58,115.82 161.47,115.94 160.73,115.94 160.05,116.62 160.05,117 159.9,117.15 JDOCK1.54
SATA_PRX_DKTX_P0_C: length 67
  TOP w0.102: C312.1 161.54,113.91 161.87,113.58 161.87,113.1 161.63,112.86 161.37,112.86 v1(161.06,113.17) ; v1(166.01,65.99) 165.76,65.74 165.66,65.74 165.58,65.82 165.58,67.08 164.71,67.95 164.71,70.02 163.04,71.69 163.04,74.91 162.24,75.71 162.24,79.26 162.77,79.79 163.99,79.79 164.25,79.53 165.22,79.53 v1(165.86,80.16)
  IN4 w0.089: v1(165.86,80.16) 165.87,80.18 165.87,80.55 166.03,80.71 167.81,80.71 170.83,83.72 170.83,89.11 170.38,89.56 170.38,99.1 168.74,100.73 168.74,102.25 168.26,102.73 167.34,102.73 165.42,104.65 162.1,104.65 160.05,106.71 160.05,107.85 159.58,108.32 159.58,109.49 160.99,110.9 160.99,111.27 161.84,112.12 161.84,112.79 161.58,113.05 161.19,113.05 v1(161.06,113.17)
  BOTTOM w0.076: UC1.H5 166.34,65.66 v1(166.01,65.99)
SATA_PRX_DTX_N1: length 160.3
  TOP w0.102: v1(275.75,65.7) 275.64,65.81 275.32,65.81 275.13,66.01 275.13,66.53 275.54,66.94 v3(282.83,66.94) 284.17,66.94 289.06,62.05 289.06,58.07 289.55,57.58 289.55,56.79 289.88,56.45 290.16,56.45 CN25.1
  IN4 w0.086: 170.81,69.4 170.8,69.4 169.93,68.52 168.69,68.52 168.07,69.14 167.63,69.14 167.45,68.96 165.61,68.96 164.62,67.97 164.62,65.69 164.42,65.5 164.25,65.5 v1(164.02,65.27)
  IN4 w0.089: 170.81,69.4 171.46,69.4 179.25,77.19 180.04,77.19 183.46,80.6 192.49,80.6 199.02,87.13 220.07,87.13 221.57,85.63 231.83,85.63 232.33,85.14 244.1,85.14 244.73,84.51 248.2,84.51 248.4,84.31 248.75,84.31 249.25,83.81 258.06,83.81 259,82.88 259,81.69 261.48,79.21 261.89,79.21 263.04,78.06 263.04,77.11 263.36,76.79 263.36,75.9 263.86,75.4 264.64,75.4 266.89,73.15 271.9,73.15 275.51,69.54 275.51,66.94 275.16,66.59 275.16,66.16 275.33,65.99 275.48,65.99 275.75,65.71 v1(275.75,65.7)
  BOTTOM w0.076: UC1.J8 164.27,65.01 v1(164.02,65.27)
SATA_PRX_DTX_N1_C: length 2.9
  TOP w0.102: CN25.2 291.75,56.28 291.9,56.28 292.24,56.62 292.24,56.85 292.46,57.08 292.65,57.08 292.8,57.22 UN2.4
SATA_PRX_DTX_N1_RP: length 21.3
  TOP w0.102: UN2.12 297.92,57.22 298.06,57.08 299.55,57.08 v1(299.74,57.26)
  IN4 w0.089: v1(299.74,57.26) 299.55,57.08 298.49,57.08 298.08,56.66 298.08,45.59 298.27,45.4 298.27,44.64 v1(298.1,44.47)
  BOTTOM w0.102: v1(298.1,44.47) 298.16,44.41 298.16,44.11 297.96,43.91 296.55,43.91 296.06,43.42 296.06,42.73 296.35,42.44 296.69,42.44 CN18.2
SATA_PRX_DTX_N1_RP_C: length 9.4
  BOTTOM w0.102: CN18.1 297.85,42.56 297.92,42.62 298.45,42.62 298.82,42.25 301,42.25 301.29,42.55 301.38,42.55 301.4,42.53 302,42.53 302.02,42.55 v3(303.68,42.55) 304.84,42.55 305.16,42.22 305.16,41.81 305,41.65 JSATA1.5
SATA_PRX_DTX_P1: length 160.3
  TOP w0.102: CN26.1 290.6,55.88 290.6,56.1 290.45,56.25 289.79,56.25 289.34,56.7 289.34,57.5 288.85,57.99 288.85,61.97 284.08,66.74 283.13,66.74 283.11,66.72 282.55,66.72 282.53,66.74 275.63,66.74 275.34,66.45 275.34,66.1 275.41,66.02 275.48,66.02 275.74,66.29 v1(275.75,66.29)
  IN4 w0.086: v1(164.02,65.92) 164.28,65.66 164.35,65.66 164.45,65.76 164.45,68.04 165.54,69.13 167.38,69.13 167.56,69.31 168.14,69.31 168.76,68.69 169.86,68.69 170.74,69.57 170.8,69.57
  IN4 w0.089: 170.8,69.57 171.39,69.57 179.18,77.36 179.97,77.36 183.39,80.77 192.42,80.77 198.95,87.3 220.14,87.3 221.64,85.8 231.76,85.8 231.9,85.8 232.4,85.31 244.17,85.31 244.8,84.68 248.27,84.68 248.47,84.48 248.82,84.48 249.32,83.98 258.14,83.98 259.17,82.95 259.17,81.76 261.55,79.38 261.96,79.38 263.21,78.13 263.21,77.18 263.53,76.86 263.53,75.97 263.93,75.57 264.71,75.57 266.96,73.32 271.97,73.32 275.68,69.61 275.68,66.87 275.33,66.52 275.33,66.23 275.4,66.16 275.62,66.16 v1(275.75,66.29)
  BOTTOM w0.089: UC1.H8 164.27,65.66 164.02,65.92 v1(164.02,65.92)
SATA_PRX_DTX_P1_C: length 2.9
  TOP w0.102: UN2.5 292.8,56.72 292.65,56.87 292.55,56.87 292.45,56.77 292.45,56.5 v3(292.29,56.35) 292.01,56.07 291.71,56.07 CN26.2
SATA_PRX_DTX_P1_RP: length 21.3
  TOP w0.102: UN2.11 297.88,56.72 298.03,56.87 299.55,56.87 v1(299.74,56.68)
  IN4 w0.089: v1(299.74,56.68) 299.51,56.91 298.56,56.91 298.25,56.59 298.25,45.66 298.44,45.47 298.44,44.71 v1(298.68,44.47)
  BOTTOM w0.102: v1(298.68,44.47) 298.37,44.15 298.37,44.03 298.04,43.7 296.64,43.7 296.27,43.33 296.27,42.82 296.43,42.65 296.94,42.65 297.03,42.74 297.03,43 CN17.2
SATA_PRX_DTX_P1_RP_C: length 9.4
  BOTTOM w0.102: JSATA1.6 305.5,41.64 305.37,41.77 305.37,42.31 304.92,42.76 304,42.76 303.98,42.78 303.38,42.78 303.36,42.76 v3(301.7,42.76) 301.21,42.76 300.91,42.46 298.91,42.46 298.53,42.83 298.11,42.83 CN17.1
SATA_PTX_DKRX_N0: length 5.3
  TOP w0.102: C315.1 163.96,115.24 163.96,115.34 v1(164.15,115.53)
  BOTTOM w0.102: JDOCK1.62 161.9,117.35 161.76,117.22 161.76,117.12 162.7,116.18 163.78,116.18 163.98,115.98 163.98,115.69 v1(164.15,115.53)
SATA_PTX_DKRX_N0_C: length 71.1
  TOP w0.102: v1(160.94,81.55) 160.72,81.77 160.51,81.77 160.13,81.4 160.13,80.16 160.67,79.63 160.67,76.55 159.74,75.62 v3(159.74,74.95) 159.74,72.16 159.47,71.89 159.03,71.89 v1(158.8,71.66) ; v1(164.17,113.11) 163.97,113.31 163.97,113.51 C315.2
  IN4 w0.089: v1(160.94,81.55) 161.29,81.55 161.71,81.13 161.71,79.11 162.37,78.45 165.74,78.45 166.51,79.21 166.51,79.4 167.15,80.04 169.38,80.04 171.86,82.51 171.86,98.94 171.45,99.34 171.04,99.34 169.43,100.95 169.43,102.49 168.48,103.44 167.58,103.44 165.67,105.35 162.37,105.35 160.73,106.99 160.73,108.13 160.38,108.49 160.38,109.26 161.67,110.55 162.44,110.55 162.77,110.88 162.77,111.53 163.96,112.72 163.96,112.85 163.96,112.9 v1(164.17,113.11)
  BOTTOM w0.076: v1(158.8,71.66) 159.25,71.66 159.34,71.57 159.34,71.31 159.59,71.07 159.59,69.72 UC1.B15
SATA_PTX_DKRX_P0: length 5.3
  TOP w0.102: C314.1 163.75,115.21 163.75,115.34 v1(163.56,115.53)
  BOTTOM w0.102: v1(163.56,115.53) 163.77,115.74 163.77,115.89 163.69,115.97 162.62,115.97 161.56,117.03 161.56,117.13 161.4,117.29 JDOCK1.60
SATA_PTX_DKRX_P0_C: length 70.9
  TOP w0.102: v1(163.59,113.11) 163.77,113.29 163.77,113.5 C314.2 ; v1(158.8,72.31) 159.01,72.1 159.39,72.1 159.53,72.24 159.53,74.65 159.51,74.67 159.51,75.22 159.53,75.24 159.53,75.7 160.46,76.63 160.46,79.55 159.93,80.08 159.93,81.48 160.42,81.98 160.8,81.98 v1(160.94,82.13)
  IN4 w0.089: v1(163.59,113.11) 163.6,113.11 163.79,112.92 163.79,112.79 162.6,111.6 162.6,110.95 162.37,110.72 161.6,110.72 160.21,109.33 160.21,108.42 160.56,108.06 160.56,106.92 162.3,105.18 165.6,105.18 167.51,103.27 168.41,103.27 169.26,102.42 169.26,100.88 170.97,99.17 171.38,99.17 171.69,98.86 171.69,82.59 169.31,80.21 167.08,80.21 166.34,79.47 166.34,79.28 165.67,78.62 162.45,78.62 161.88,79.18 161.88,81.2 v1(160.94,82.13)
  BOTTOM w0.076: v1(158.8,72.31) 158.8,72.18 159.14,71.84 159.33,71.84 159.52,71.65 159.52,71.39 159.77,71.14 159.77,70.48 160.02,70.23 UC1.A15
SATA_PTX_DRX_N1: length 166.8
  TOP w0.102: CN30.1 290.09,58.05 289.99,58.05 289.67,58.37 289.67,62.48 284.59,67.55 v3(277.66,67.55) 275.3,67.55 275.18,67.43 274.88,67.43 274.59,67.73 274.59,67.97 v1(274.43,68.12)
  IN4 w0.086: v1(158.82,71.06) 158.68,70.92 158.49,70.92 158.19,70.62 158.19,70.2 159.17,69.22 159.63,69.22 160.55,68.3 160.55,65.1 161.09,64.55 164.37,64.55 164.54,64.72 165.2,64.72 165.54,65.06 165.54,68.04 165.91,68.4 167.41,68.4 167.89,67.92 169.22,67.92 169.29,67.92 170.32,67.92 170.65,68.25
  IN4 w0.089: v1(274.43,68.12) 274.43,69.71 273.85,70.3 273.24,70.3 273.06,70.12 270.52,70.12 269.84,70.81 266.23,70.81 264.6,72.43 263.46,72.43 263,72.89 263,75.33 262.72,75.61 262.72,76.51 262.38,76.85 262.38,77.73 261.92,78.19 261.23,78.19 257.73,81.68 256.38,81.68 255.43,81.68 255.25,81.87 250.24,81.87 250.1,81.87 248.3,83.67 244.64,83.67 243.82,84.49 231.88,84.49 231.42,84.95 199.85,84.95 194.56,79.67 185.61,79.67 180.7,74.76 177.86,74.76 171.75,68.66 171.06,68.66 170.76,68.36 170.75,68.36 170.72,68.32 170.72,68.32 170.65,68.25
  BOTTOM w0.076: v1(158.82,71.06) 159.29,70.6 UC1.A17
SATA_PTX_DRX_N1_C: length 2.5
  TOP w0.102: CN30.2 291.71,58.11 292.05,58.11 292.32,58.37 292.85,58.37 293,58.22 UN2.2
SATA_PTX_DRX_N1_RP: length 27.9
  TOP w0.102: UN2.14 297.91,58.22 298.03,58.35 299.22,58.35 299.4,58.52 299.76,58.52 299.99,58.3 v1(299.99,58.28)
  IN4 w0.089: v1(299.99,58.28) 299.99,58.3 299.8,58.49 299.35,58.49 299.17,58.3 297.9,58.3 297.59,57.99 297.59,44.41 295.97,42.8 295.97,39.7 296.25,39.42 297.01,39.42 297.26,39.18 297.26,39.03 v1(297.54,38.75)
  BOTTOM w0.102: v1(297.54,38.75) 297.22,39.08 297.22,39.46 297.46,39.7 CN20.2
SATA_PTX_DRX_N1_RP_C: length 9.3
  BOTTOM w0.102: JSATA1.3 304,40.51 303.88,40.38 303.88,39.93 303.49,39.55 299.66,39.55 v3(299.41,39.8) 298.69,40.51 298.66,40.51 298.24,40.93 298.24,40.96 298,41.21 297.37,41.21 297.29,41.14 297.29,40.95 CN20.1
SATA_PTX_DRX_P1: length 166.7
  TOP w0.102: v1(275.02,68.12) 274.79,67.9 274.79,67.82 274.97,67.64 275.09,67.64 275.21,67.76 277.36,67.76 277.38,67.78 277.94,67.78 277.96,67.76 284.68,67.76 289.88,62.57 289.88,58.45 290.07,58.26 290.32,58.26 290.45,58.38 290.45,58.7 CN23.1
  IN4 w0.086: v1(158.82,70.44) 158.82,70.56 158.63,70.75 158.56,70.75 158.36,70.55 158.36,70.27 159.24,69.39 159.7,69.39 160.72,68.37 160.72,65.17 161.16,64.72 164.3,64.72 164.47,64.89 165.13,64.89 165.38,65.13 165.38,68.11 165.84,68.57 167.47,68.57 167.96,68.09 169.15,68.09 170.25,68.09 170.48,68.32 170.48,68.32 170.64,68.48 170.64,68.48 170.65,68.49
  IN4 w0.089: 170.65,68.49 170.68,68.53 170.69,68.53 170.99,68.83 171.68,68.83 177.79,74.93 177.93,74.93 180.63,74.93 185.54,79.84 194.49,79.84 199.78,85.12 231.35,85.12 231.35,85.12 231.49,85.12 231.95,84.66 243.89,84.66 244.71,83.84 248.37,83.84 250.17,82.04 255.32,82.04 255.5,81.85 256.45,81.85 256.45,81.85 257.8,81.85 261.3,78.36 261.99,78.36 262.55,77.8 262.55,76.92 262.89,76.58 262.89,75.68 263.17,75.4 263.17,72.96 263.53,72.6 264.68,72.6 266.3,70.98 269.91,70.98 270.59,70.29 272.99,70.29 273.17,70.47 273.92,70.47 274.6,69.78 274.6,68.54 v1(275.02,68.12)
  BOTTOM w0.076: v1(158.82,70.44) 158.82,70.45 158.82,70.45 158.82,69.71 UC1.B17
SATA_PTX_DRX_P1_C: length 2.5
  TOP w0.102: UN2.1 292.93,58.72 292.79,58.58 292.23,58.58 291.97,58.31 291.75,58.31 CN23.2
SATA_PTX_DRX_P1_RP: length 27.9
  TOP w0.102: v1(299.98,58.94) 299.77,58.73 299.32,58.73 299.14,58.55 298.1,58.55 297.93,58.72 UN2.15
  IN4 w0.089: v1(299.98,58.94) 299.98,58.93 299.71,58.66 299.28,58.66 299.1,58.47 297.83,58.47 297.42,58.06 297.42,44.49 295.8,42.87 295.8,39.63 296.18,39.25 296.94,39.25 297.09,39.11 297.09,38.94 v1(296.91,38.76)
  BOTTOM w0.102: CN19.2 297.01,39.4 297.01,38.86 v1(296.91,38.76)
SATA_PTX_DRX_P1_RP_C: length 9.3
  BOTTOM w0.102: JSATA1.2 303.5,40.48 303.67,40.31 303.67,40.02 303.4,39.75 299.77,39.75 299.36,40.17 299.33,40.17 v3(298.62,40.88) 298.08,41.42 297.28,41.42 297.09,41.22 297.09,40.99 CN19.1
SATACLK_REQ#: length 152.8
  TOP w0.102: v1(239.92,95.05) 240.78,95.91 244.69,95.91 245.35,96.57 248.18,96.57 v2(249.2,95.56) 249.44,95.32 258.89,95.32 259.5,95.93 273.65,95.93 274.23,95.34 282.37,95.34 v1(283.32,96.29)
  IN3 w0.086: 171.77,61.7 171.4,61.7 v1(171.39,61.71)
  IN3 w0.122: 171.77,61.7 172.96,62.89 175.72,62.89 176.55,62.06 176.55,61.63 176.8,61.38 179.16,61.38 179.31,61.53 179.31,61.87 179.31,62.34 181.07,64.1 185.75,64.1 v1(186.32,64.67)
  IN4 w0.089: v1(186.32,64.67) 187.57,63.42 190.9,63.42 192.41,64.92 192.41,71.46 203.45,82.51 207.6,82.51 208.4,83.31 221.23,83.31 221.51,83.03 230.13,83.03 231.78,81.38 238.73,81.38 239.89,82.54 v1(240.94,82.54)
  BOTTOM w0.076: v1(171.39,61.71) 170.89,62.21 169.78,62.21 169.38,61.81 168.87,61.81 168.57,61.51 UC1.T2
  BOTTOM w0.102: RC68.2 187.17,63.82 v1(186.32,64.67) ; v1(283.32,96.29) 283.34,96.29 283.39,96.35 JNGFF2.44 ; v1(239.92,95.05) 239.94,95.02 239.98,95.02 240.32,94.68 240.32,93.03 240.74,92.61 240.74,90.66 239.26,89.18 239.26,86.54 240.97,84.83 240.97,82.57 v1(240.94,82.54)
SD/MMCCD#: length 18.2
  TOP w0.102: v1(310.49,59.9) 310.66,60.07 UR1.21 ; v1(302.25,57.65) 302.81,57.09 303.95,57.09 RR11.1 CR35.1
  BOTTOM w0.102: JSD1.18 299.06,56.4 299.25,56.21 301,56.21 302.25,57.46 v1(302.25,57.65) 302.78,57.65 303.01,57.88 308.42,57.88 310.44,59.9 v1(310.49,59.9)
SD/MMCCLK: length 24.1
  TOP w0.102: v1(304.36,70.89) 304.57,70.68 304.57,70.67 304.81,70.44 304.81,70.44 304.89,70.36 305.35,70.36 305.71,70.73 307.28,70.73 307.68,70.32 308.41,70.32 CR23.1 RR1.2
  IN2 w0.122: v1(304.36,70.89) 304.13,70.89 301.73,68.49 301.73,64 300.34,62.61 300.34,60.44 301.04,59.74 301.04,58.65 v1(300.65,58.26)
  BOTTOM w0.102: JSD1.5 300.19,57.8 v1(300.65,58.26)
SD/MMCCLK_R: length 2.3
  TOP w0.102: RR1.1 308.9,68.12 v2(309.07,67.95) 309.46,67.56 UR1.43
SD/MMCCMD: length 28.4
  TOP w0.102: UR1.45 308.66,67.6 v1(308.43,67.83)
  BOTTOM w0.102: JSD1.2 299.06,63.5 299.17,63.39 299.17,61.27 299.3,61.14 299.55,61.14 299.68,61.27 299.68,63.11 299.83,63.26 300.04,63.26 300.19,63.11 300.19,61.37 300.31,61.24 300.57,61.24 300.69,61.37 300.69,62.65 300.8,62.76 301.13,62.76 301.26,62.63 301.26,60.52 301.38,60.39 301.56,60.39 301.71,60.54 301.71,62.65 301.81,62.76 302.07,62.76 302.77,63.45 302.77,63.6 302.4,63.96 302.4,64.17 302.55,64.32 302.76,64.32 303.13,63.96 303.27,63.96 303.76,64.44 303.99,64.44 304.09,64.55 304.09,65.27 304.2,65.37 304.5,65.37 304.6,65.27 304.6,64.55 304.7,64.44 305.04,64.44 v1(308.43,67.83)
SD/MMCDAT0: length 30.8
  TOP w0.102: v1(311.59,67.83) 311.46,67.7 UR1.38 ; UR1.30 313.37,63.62 313.84,63.15 v1(313.97,63.15)
  IN2 w0.122: v1(313.97,63.15) 311.73,65.38 311.73,67.69 v1(311.59,67.83)
  IN4 w0.089: v1(313.97,63.15) 313.97,62.87 313.26,62.16 309.77,62.16 307.45,59.84 307.45,57.09 304.01,53.65 v1(300.19,53.65)
  BOTTOM w0.102: v1(300.19,53.65) 299.5,53.65 299.38,53.52 299.38,53.19 299.25,53.06 299.02,53.06 298.89,53.19 298.89,53.47 298.77,53.6 JSD1.7
SD/MMCDAT1: length 31.3
  TOP w0.102: UR1.37 311.86,67.46 v1(312.19,67.78) ; UR1.29 313.26,63.22 313.91,62.58 v1(314.27,62.58)
  IN2 w0.122: v1(314.27,62.58) 314.41,62.72 314.41,63.32 312.19,65.55 v1(312.19,67.78)
  IN4 w0.089: v1(300.18,53.05) 300.3,53.18 304.1,53.18 307.85,56.92 307.85,59.64 309.88,61.67 313.37,61.67 v1(314.27,62.58)
  BOTTOM w0.102: v1(300.18,53.05) 299.97,52.85 299.72,52.85 299.07,52.2 JSD1.8
SD/MMCDAT2: length 2.4
  TOP w0.102: UR1.48 307.46,67.77 v2(307.25,67.99) 307.25,68.32 RR4.1
SD/MMCDAT2_R: length 25.2
  TOP w0.102: RR4.2 305.83,69.08 303.92,69.08 303.8,69.2 v1(303.8,69.71)
  IN4 w0.089: v1(303.8,69.71) 303.8,69.95 303.73,70.02 301.41,70.02 301.28,69.89 301.28,69.35 301.38,69.25 302.88,69.25 302.98,69.15 302.98,68.84 302.88,68.74 301.65,68.74 301.52,68.61 301.52,67.55 301.4,67.43 300.98,67.43 300.85,67.55 300.85,69.19 300.72,69.32 300.43,69.32 300.3,69.19 300.3,67.54 300.18,67.41 299.87,67.41 299.75,67.54 299.75,69.15 299.62,69.28 299.31,69.28 299.19,69.15 299.19,67.57 299.06,67.44 298.69,67.44 298.56,67.57 v1(298.56,68.24)
  BOTTOM w0.102: v1(298.56,68.24) 298.81,68 298.81,66.61 298.49,66.3 JSD1.9
SD/MMCDAT3: length 2.2
  TOP w0.102: RR3.1 307.86,68.72 UR1.47
SD/MMCDAT3_R: length 30.3
  TOP w0.102: v1(304.36,70.12) 304.84,69.64 v2(305.21,69.64) 305.4,69.64 306.07,70.31 307,70.31 307.44,69.87 RR3.2
  IN4 w0.089: v1(304.36,70.12) 304.36,69.53 304.48,69.4 305.16,69.4 305.3,69.26 305.3,69.05 305.16,68.9 303.58,68.9 303.48,68.79 303.48,68.49 303.58,68.39 306.16,68.39 306.31,68.24 306.31,68.03 306.16,67.88 303.58,67.88 303.48,67.78 303.48,67.47 303.58,67.37 304.63,67.37 304.74,67.27 304.74,66.97 304.63,66.86 303.58,66.86 303.48,66.76 303.48,66.46 303.58,66.36 304.63,66.36 304.74,66.25 304.74,65.89 304.42,65.57 302.82,65.57 301.37,67.02 298.54,67.02 297.35,65.83 v1(296.85,65.83)
  BOTTOM w0.102: JSD1.1 297.12,64.9 296.85,65.17 v1(296.85,65.83)
SD_REXT: length 2.3
  TOP w0.102: RR5.1 314.4,60.77 313.15,62.02 UR1.26
SD_UHS2_D0N: length 27.1
  TOP w0.094: UR1.34 313.18,65.22 313.79,65.83 v1(313.87,65.83)
  IN4 w0.081: v1(313.87,65.83) 314,65.96 315.56,65.96 315.83,66.23 315.83,68.35 315.96,68.48 316.4,68.48 316.52,68.35 316.52,65.93 316.8,65.65 317.52,65.65 317.79,65.93 317.79,68.3 317.92,68.43 318.47,68.43 318.59,68.3 318.59,65.99 318.87,65.71 319.51,65.71 319.78,65.99 319.78,67.81 319.97,67.99 320.31,67.99 322.67,70.35 322.67,71.15 322.67,71.15 v1(322.78,71.26)
  BOTTOM w0.094: JSD1.12 323.05,73.47 322.72,73.14 322.72,71.32 v1(322.78,71.26)
SD_UHS2_D0P: length 27.1
  TOP w0.094: v1(313.83,66.46) 313.83,66.37 313.08,65.62 UR1.35
  IN4 w0.081: v1(313.83,66.46) 314.08,66.21 315.46,66.21 315.58,66.33 315.58,68.46 315.86,68.73 316.5,68.73 316.77,68.46 316.77,66.03 316.9,65.9 317.41,65.9 317.54,66.03 317.54,68.41 317.81,68.68 318.57,68.68 318.84,68.41 318.84,66.09 318.97,65.97 319.41,65.97 319.53,66.09 319.53,67.91 319.86,68.24 320.21,68.24 322.41,70.45 322.41,71.04 v1(322.2,71.26)
  BOTTOM w0.094: JSD1.11 321.95,73.38 322.08,73.26 322.21,73.26 322.34,73.13 322.34,71.41 v1(322.2,71.26)
SD_UHS2_D1N: length 27.1
  TOP w0.094: UR1.33 313.21,64.82 313.4,65.01 313.7,65.01 v1(313.82,65.13)
  IN4 w0.081: v1(313.82,65.13) 313.97,64.97 316.98,64.97 319.2,62.75 319.2,52.31 322.7,48.81 322.7,46.63 322.7,46.63 v1(322.82,46.52)
  BOTTOM w0.094: v1(322.82,46.52) 322.82,45.73 323.05,45.5 JSD1.15
SD_UHS2_D1P: length 27.1
  TOP w0.094: v1(313.82,64.54) 313.73,64.63 313.56,64.63 313.37,64.44 313.34,64.44 313.32,64.42 UR1.32
  IN4 w0.081: v1(322.23,46.52) 322.45,46.74 322.45,48.71 318.95,52.21 318.95,62.65 316.88,64.72 313.99,64.72 v1(313.82,64.54)
  BOTTOM w0.094: v1(322.23,46.52) 322.44,46.31 322.44,45.77 322.31,45.65 322.08,45.65 321.95,45.52 JSD1.16
SDWP: length 24.8
  TOP w0.102: UR1.20 310.26,60.32 v1(309.84,59.9)
  IN4 w0.089: v1(310.31,49.44) 310.31,56.64 309.7,57.25 309.7,59.76 v1(309.84,59.9)
  BOTTOM w0.102: JSD1.19 299.05,50.8 299.35,50.5 309.26,50.5 v1(310.31,49.44)
SIO_EXT_SCI#: length 120.3
  TOP w0.102: UE2.A33 252.04,63.25 v1(251.69,63.6)
  IN2 w0.122: v1(190.84,65.57) 190.55,65.57 190.05,66.07 187.63,66.07 187.54,65.98 184.89,65.98 183.91,65 181.5,65 179.19,62.68 178.35,62.68 v1(178.01,63.02)
  IN3 w0.086: v1(166.66,63.39) 169.05,63.39 169.62,63.96 171.77,63.96
  IN3 w0.122: v1(178.01,63.02) 177.84,63.19 177.69,63.19 176.91,63.96 171.77,63.96
  IN4 w0.089: v1(247.46,81.21) 247.07,80.82 245.9,80.82 243.62,83.1 239.73,83.1 238.48,81.85 231.97,81.85 230.33,83.5 221.82,83.5 221.54,83.78 203.7,83.78 191.41,71.49 191.41,66.14 v1(190.84,65.57) ; v1(251.69,63.6) 251.75,63.67 251.75,63.95 252.39,64.58 252.39,68.53 251.73,69.19 251.73,70.32 252.35,70.93 252.35,71.65 252.06,71.94 252.06,72.44 249.64,74.86 249.64,78.77 v1(248.18,80.24)
  BOTTOM w0.076: v1(166.66,63.39) 166.66,63.31 166.35,63 UC1.N5
  BOTTOM w0.102: v1(248.18,80.24) 248.18,80.41 247.46,81.13 v1(247.46,81.21) ; v1(251.69,63.6) 251.88,63.8 v2(251.88,64.07) ; RC156.1 178.42,62.55 178.01,62.96 v1(178.01,63.02)
SIO_EXT_SMI#: length 151.5
  TOP w0.102: v2(181.81,56.43) v1(182.33,56.95) ; UE2.A6 264.17,58.25 v1(264.64,57.77)
  IN1 w0.089: v1(261.73,79.86) 261.71,79.83 259.89,79.83 258.67,81.06 251.73,81.06 251.57,80.9 249.69,80.9 249.59,80.79 246.12,80.79 v1(245,79.67)
  IN4 w0.086: 171.77,56.81 169.91,56.81 169.27,56.16 166.87,56.16 v1(166.51,55.8)
  IN4 w0.089: 171.77,56.81 175.01,56.81 175.62,57.42 179.41,57.42 180.31,56.52 181.91,56.52 v1(182.33,56.95) 182.42,56.86 182.43,56.86 182.76,56.52 184.36,56.52 185.11,55.77 186.64,55.77 186.67,55.75 188.69,55.75 188.91,55.97 192.58,55.97 193.98,57.37 194.61,57.37 196.26,59.03 198.04,59.03 199.73,60.71 199.73,64.72 200.18,65.17 200.18,73.17 203.76,76.75 203.76,79.57 204.72,80.53 218.03,80.53 218.42,80.92 220.56,80.92 220.94,80.54 229.59,80.54 230.59,79.54 244.6,79.54 244.73,79.67 244.73,79.67 v1(245,79.67)
  BOTTOM w0.076: v1(166.51,55.8) 166.51,55.68 166.35,55.52 UC1.AG5
  BOTTOM w0.102: v1(264.64,57.77) 265.06,58.19 266.45,58.19 267.13,58.87 267.13,60.97 268.33,62.17 268.33,64.07 268.59,64.33 268.93,64.33 269.16,64.57 269.16,64.9 268.93,65.14 268.84,65.14 268.39,65.59 268.39,66.5 268.33,66.56 268.33,67.35 265.7,69.98 265.7,72.09 265.05,72.74 265.05,73.17 264.69,73.52 263.06,73.52 262.7,73.89 262.7,76.05 261.3,77.45 261.3,79.14 261.73,79.57 v1(261.73,79.86) ; RPC9.6 182.86,57.47 v1(182.33,56.95)
SIO_EXT_WAKE#: length 130.4
  TOP w0.076: v1(170.49,48.78) 170.49,46.51 170.65,46.34
  TOP w0.102: RPC1.6 174.02,41.62 173.82,41.82 v1(173.82,41.94) v2(173.82,42.47) 173.82,43.17 170.65,46.34 ; UE2.B5 261.44,57.5 v1(261.1,57.17)
  IN2 w0.122: v1(173.82,41.94) 174.45,41.94 176.62,39.77 176.62,39.09 177.08,38.62 178.01,38.62 178.46,38.17 178.46,37.15 179.25,36.36 179.26,36.36 185.71,29.91 196.13,29.91 197.35,28.69 198.11,28.69 202.6,24.2 v1(203.42,24.2)
  IN3 w0.122: v1(261.1,57.17) 260.82,57.44 255.59,57.44 255.3,57.73 253.81,57.73 252.7,56.63 252.7,56.43 251.69,55.41 249.9,55.41 249.62,55.69 246.56,55.69 246.02,55.16 246.02,54.8 244.98,53.76 244.98,52.66 244.4,52.09 244.4,49.11 241.95,46.66 241.95,45.71 240.33,44.09 240.33,42.96 238.81,41.44 229.17,41.44 227.55,39.82 227.55,34.81 226.3,33.57 212.83,33.57 203.46,24.2 v1(203.42,24.2)
  BOTTOM w0.076: UC1.AU2 168.66,49.91 169.35,49.91 170.18,49.08 170.25,49.08 170.49,48.85 v1(170.49,48.78)
SIO_PWRBTN#: length 259.7
  TOP w0.102: JXDP1.41 94.93,26.53 v1(95.21,26.81) ; UE2.B58 v1(256.85,55.57)
  IN1 w0.086: 171.77,49.68 170.73,49.68 169.1,51.32 169.1,52.99 169.33,53.22 169.33,53.92 168.78,54.47 166.86,54.47 166.75,54.36 165.96,54.36 165.5,53.9 v1(165.5,53.87)
  IN1 w0.089: 171.77,49.68 173.41,49.68 174.94,48.15 174.94,46.48 177.13,44.3 181.5,44.3 184.16,46.97 184.48,46.97 185.33,47.82 187.33,47.82 187.99,48.48 189.59,48.48 191.74,46.32 191.74,41.17 192.37,40.55 192.37,39.71 193.51,38.57 195.11,38.57 197.95,35.73 200.3,35.73 200.58,35.45 212.5,35.45 215.01,32.93 226.48,32.93 230.33,36.78 231.02,36.78 237.54,43.3 238.05,43.3 238.42,43.67 239.66,43.67 242.82,46.83 247.45,46.83 248.43,45.85 258.75,45.85 259.17,46.27 v1(259.23,46.27) ; v1(177.23,38.12) v1(177.23,26.47)
  IN2 w0.086: v1(165.5,53.87) 165.06,53.43 165.06,49.86 164.38,49.18 164.38,48.49 163.88,48 163.47,48 162.33,46.85 162.33,45.48 168.72,39.09 169.08,39.09 169.42,39.44 169.42,39.73 169.65,39.96 170.65,39.96
  IN2 w0.122: v1(177.23,38.12) 175.2,38.12 175.07,38.24 172.01,38.24 171.44,38.81 171.27,38.81 171.02,39.05 171.02,39.4 171.03,39.4 171.03,39.66 170.74,39.96 170.65,39.96
  IN4 w0.089: v1(259.23,46.27) 259.23,46.28 256.51,48.99 256.51,49.66 256.51,50.93 256.72,51.14 256.72,51.88 256.56,52.04 256.56,53.76 256.85,54.05 v1(256.85,55.57)
  BOTTOM w0.076: v1(165.5,53.87) 165.25,53.61 UC1.AL7
  BOTTOM w0.102: v1(177.23,26.47) 175.54,28.16 112.16,28.16 108.42,24.42 103.24,24.42 102.5,23.69 97.57,23.69 96.3,24.96 96.3,25.72 v1(95.21,26.81)
SIO_RCIN#: length 145.5
  TOP w0.102: UE2.A27 256.6,65.24 256.39,65.46 256.39,65.7 v1(255.87,66.22)
  IN1 w0.089: v1(255.87,66.22) 255.27,66.22 254.42,67.07 252.94,67.07 252.25,67.76 250.48,67.76 249.75,67.03 237.03,67.03 v1(236.66,67.39)
  IN2 w0.122: v1(239.48,74.08) 238.23,75.34 237.37,75.34 235.29,77.42 235.29,78.06 221.34,92.01 210.46,92.01 210.12,92.35 199.15,92.35 198.34,91.53 198.31,91.53 195.36,88.59 v1(194.95,88.59) ; v1(195.63,63.44) 195.1,62.91 194.4,62.91 193.38,61.88 188.67,61.88 188.46,62.09 185.16,62.09 183.24,60.17 183.14,60.17 v1(182.92,59.95)
  IN4 w0.086: v1(166.66,59.61) 166.78,59.61 167.2,59.2 171.77,59.2
  IN4 w0.089: v1(182.92,59.95) 182.92,59.57 182.77,59.41 181.52,59.41 180.92,60.02 176.2,60.02 175.9,59.72 173.18,59.72 172.66,59.2 171.77,59.2 ; v1(239.48,74.08) 238.42,73.01 238.42,71.14 236.66,69.38 v1(236.66,67.39)
  BOTTOM w0.076: v1(166.66,59.61) 167.03,59.98 UC1.V4
  BOTTOM w0.102: v1(182.92,59.95) 182.99,60.02 RPC3.5 ; v1(195.63,63.44) 195.08,63.44 193.74,64.78 193.74,66.93 192.82,67.84 192.82,70.39 191.43,71.78 191.43,81.66 194.75,84.99 194.75,88.17 194.95,88.36 v1(194.95,88.59)
SIO_SLP_A#: length 174.6
  TOP w0.102: v1(210.85,34.94) 210.85,35.39 211.65,36.19 211.65,36.21 215.43,40 224.59,40 225.78,41.19 236.09,41.19 237.47,42.57 238.19,42.57 243.07,47.45 243.07,48.85 v1(243.13,48.91) ; v1(256.87,63.44) 256.85,63.45 UE2.B28 ; UC6.1 189.18,47.93 v1(190.84,46.27)
  IN1 w0.086: v1(166.05,53.94) 166.29,54.18 166.97,54.18 167.08,54.3 168.71,54.3 169.15,53.85 169.15,53.29 168.82,52.96 168.82,49.88 169.48,49.22 170.65,49.22
  IN1 w0.089: 170.65,49.22 173.22,49.22 174.37,48.06 174.37,46.25 176.82,43.8 181.67,43.8 183.29,45.42 185.6,45.42 188.04,47.87 189.24,47.87 v1(190.84,46.27) 191.27,45.84 191.27,40.95 191.85,40.38 191.85,39.5 193.5,37.85 194.34,37.85 196.93,35.26 200.11,35.26 200.55,34.81 208.31,34.81 208.8,34.32 210.22,34.32 v1(210.85,34.94) ; v1(228.65,78.12) 229.21,78.68 232.7,78.68 235.92,75.47 235.92,68.09 v1(236.11,67.9) 248.65,67.9 249.5,68.74 251.93,68.74 253.13,67.54 255.72,67.54 256.47,66.79 256.47,63.84 v1(256.87,63.44)
  IN4 w0.089: v1(243.13,48.91) 242.53,48.91 241.78,48.16 240.08,48.16 238.39,49.85 238.39,57.08 238.99,57.67 238.99,64.47 236.18,67.27 236.18,67.82 v1(236.11,67.9)
  BOTTOM w0.076: UC1.AL5 166.08,53.89 166.05,53.92 v1(166.05,53.94)
  BOTTOM w0.102: JAPS1.6 228.69,78.16 v1(228.65,78.12)
SIO_SLP_LAN#: length 173.5
  TOP w0.102: v1(270.05,71.71) 269.98,71.71 269.17,72.51 UZ2.5 ; UE2.B37 253.99,62.5 254.57,61.92 v1(254.57,61.88)
  IN1 w0.089: v1(254.24,69.28) 254.32,69.28 256.77,71.73 257.98,71.73 258.91,72.67 261.58,72.67 263.02,71.22 266.98,71.22 267.17,71.03 269.38,71.03 v1(270.05,71.71)
  IN2 w0.086: 169.65,38.35 169.32,38.68 168.63,38.68 161.98,45.34 161.98,48.05 163.59,49.66 164.29,49.66 164.69,50.07 164.69,54.7 v1(164.79,54.79)
  IN2 w0.122: 169.65,38.35 170.09,37.91 170.75,37.91 171.42,37.24 172.95,37.24 174.08,36.11 179.16,36.11 185.74,29.53 195.36,29.53 201.59,23.31 219.11,23.31 231.25,35.45 231.98,35.45 237.72,41.19 237.72,42.19 238.78,43.25 238.78,43.26 239.82,44.3 240.06,44.3 242.62,46.86 243.2,46.86 243.62,47.28 244.49,47.28 246.87,49.65 250.05,49.65 252,47.7 255.88,47.7 v1(256.54,47.04)
  IN4 w0.089: v1(254.57,61.88) 254.57,61.89 255.09,61.37 255.09,57.77 255.42,57.44 255.42,53.46 255.88,53 255.88,50.98 256.01,50.85 256.01,47.58 v1(256.54,47.04)
  BOTTOM w0.076: v1(164.79,54.79) 165.05,54.53 UC1.AJ7
  BOTTOM w0.102: v1(254.24,69.28) 253.01,68.05 v2(253.01,67.5) 253.01,65.34 254.36,64 254.36,62.65 254.57,62.43 v1(254.57,61.88)
SIO_SLP_S0#: length 130.1
  IN2 w0.122: v1(187.49,37.04) 187.2,37.04 186.65,37.59 186,37.59 179.76,43.84 177.28,43.84 174.98,46.14 174.98,50.31 175.21,50.54 v1(175.21,51.36)
  IN3 w0.086: v1(170.76,56.2) 171.66,55.3 171.95,55.3 172.84,54.4 172.84,53.73
  IN3 w0.122: v1(175.21,51.36) 172.84,53.73
  BOTTOM w0.076: UC1.AF3 167.94,55.98 169.77,55.98 169.95,55.79 170.28,55.79 170.47,55.98 170.54,55.98 v1(170.76,56.2)
  BOTTOM w0.102: JAPS1.15 233.19,78.53 233.4,78.32 233.65,78.32 236.23,75.74 236.23,73.12 239.15,70.2 v2(239.15,68.01) 239.15,61.34 239.57,60.92 239.57,59.83 239.57,56.62 237.44,54.49 237.44,48.94 235.25,46.75 233.54,46.75 231.09,44.3 231.09,44.02 230.23,43.16 230.23,42.55 227.91,40.24 227.91,35.94 225.4,33.43 221.67,33.43 221.35,33.11 208.45,33.11 207.35,34.2 198.07,34.2 195.45,31.59 192.56,31.59 190.78,33.36 190.78,35.37 189.12,37.04 v1(187.49,37.04)
