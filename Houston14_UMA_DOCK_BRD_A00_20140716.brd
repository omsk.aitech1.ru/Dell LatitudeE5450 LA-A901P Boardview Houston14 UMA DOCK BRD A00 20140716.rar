# Allegro board Houston14_UMA_DOCK_BRD_A00_20140716.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N75599: length 2.1
  BOTTOM w0.102: QZ9.1 RZ33.1 v2(304.53,84.1)
N525777: length 4.7
  TOP w0.102: UZ8.10 186.05,38.87 CZ42.1 186.16,38.99 185.7,39.45 185.7,41.2 v2(185.84,41.34)
N588510: length 2.1
  TOP w0.102: UZ8.12 185.25,37.91 v2(185.14,38.02) CZ41.1
N5261056: length 86.8
  TOP w0.102: RD13.1 RD12.1 201.97,2.06 v1(201.63,1.72) ; v1(136.75,1.65) 135.82,2.59 QD1.3 ; v2(126.53,1.59) 126.38,1.74 v1(125.77,1.74) RD10.1 RD11.1
  IN3 w0.122: v1(201.63,1.72) 201.63,2.26 201.14,2.75 163.26,2.75 161.07,4.93 157.04,4.93 155.03,2.92 138.02,2.92 v1(136.75,1.65) 135.47,2.94 126.4,2.94 125.77,2.3 v1(125.77,1.74)
N10757881: length 2.5
  TOP w0.102: v2(91.22,13.66) 90.64,13.07 RD7.1 CD21.2
N15438178: length 30.3
  TOP w0.508: PD705.1 PD704.1 PD702.1 93.28,61.79 v3(93.26,61.81) ; v3(89.45,79.14) 88.51,80.08 88.51,81.74 v2(87.76,82.49) PR708.1
  IN4 w0.508: v3(93.26,61.81) 90.22,64.85 90.22,78.36 v3(89.45,79.14)
N15438627: length 5.8
  TOP w0.203: PU700.6 77.72,80.16 77.43,80.46 77.42,80.46 v3(77.28,80.6)
  BOTTOM w0.102: v2(80.2,79.44) 79.08,79.44 PC711.1
  BOTTOM w0.254: PR710.1 77.28,81.32 v3(77.28,80.6) 78.02,79.86 PR711.1 PC711.1
N15439163: length 2
  TOP w0.254: PU700.5 78.12,80.3 77.94,80.48 77.94,81.09 PR714.2
N15439291: length 5.2
  TOP w0.203: v3(76.01,80.29) 76.01,80.24 76.21,80.04 77.01,80.04 77.32,79.73 PU700.7
  TOP w0.254: PR716.2 76.75,81.03 v3(76.01,80.29)
  BOTTOM w0.102: PC718.2 74.92,79.39 v2(74.84,79.31)
  BOTTOM w0.254: v3(76.01,80.29) 75.98,80.27 PC718.2
N15439295: length 4.5
  TOP w0.102: v2(74.71,81.22) 74.41,80.91 PR718.2
  TOP w0.203: PU700.8 76.08,78.61
  TOP w0.254: PR718.2 PC719.2 74.42,79.17 75.51,79.17 76.08,78.61
N15439512: length 3.4
  TOP w0.203: PU700.9 75.97,78.21 75.63,78.55 v2(75.35,78.55) 74.79,78.55 74.41,78.17
  TOP w0.254: PR720.2 PR788.2 74.41,78.17
N15440461: length 6.5
  TOP w0.102: PR717.2 73.85,76.7 72.55,76.7 v2(72.07,77.17)
  TOP w0.203: 74.9,76.48 74.9,76.64 74.89,76.65 74.89,77.87 75.07,78.04 75.62,78.04 75.86,77.81 PU700.10
  TOP w0.254: 74.9,76.48 74.56,76.14 PR717.2
N15441413: length 5.2
  TOP w0.102: v3(80.43,73.18) 80.59,73.35 v2(81.06,73.35)
  TOP w0.203: PU700.18 78.52,74.64 79.46,73.7 80.05,73.7 80.43,73.32 v3(80.43,73.18)
  BOTTOM w0.254: PR722.1 80.3,73.05 v3(80.43,73.18)
N15441884: length 6.8
  TOP w0.102: v2(79.54,72.08) 79.77,72.3 v3(79.77,73.22)
  TOP w0.203: PU700.17 78.12,74.57 79.48,73.22 v3(79.77,73.22)
  BOTTOM w0.254: PR723.1 PC729.1 79.16,72.61 v3(79.77,73.22)
N15442134: length 32.3
  TOP w0.102: v3(102.97,77.98) 103.05,77.98 103.8,78.73 v2(103.8,78.88)
  TOP w0.203: v3(82.11,72.89) 81.95,73.04 81.95,73.09 81.9,73.14 81.9,73.54 81.08,74.36 79.84,74.36 79.32,74.88 PU700.20
  IN1 w0.254: v3(102.97,77.98) 102.84,78.11 99.26,78.11 98.98,78.39 93.31,78.39 88.38,73.46 82.48,73.46 82.11,73.09 v3(82.11,72.89)
  BOTTOM w0.254: v3(102.97,77.98) 102.72,77.98 102.4,78.3 PR721.3 ; PC726.2 82.11,72.25 v3(82.11,72.89) 82.28,73.07 PC727.1
N15442185: length 33.6
  TOP w0.102: v2(101.23,79.19) 101.8,78.62 v3(102.97,78.62)
  TOP w0.203: v3(81.47,72.89) 81.57,72.99 81.57,73.4 80.94,74.03 79.65,74.03 78.92,74.76 PU700.19
  IN1 w0.254: v3(81.47,72.89) 81.47,72.99 82.32,73.84 88.23,73.84 93.17,78.78 99.17,78.78 99.47,78.49 102.84,78.49 v3(102.97,78.62)
  BOTTOM w0.254: PC728.1 81.47,72.18 v3(81.47,72.89) 81.37,72.99 PC727.2 ; PR721.2 103.37,78.3 103.06,78.62 v3(102.97,78.62)
N17156946: length 12.6
  TOP w0.102: v1(56.81,88.47) 56.44,88.84 v2(56.3,88.84)
  TOP w0.508: PR14.2 57.7,88.41 PR18.1 PR17.1 56.68,88.34 v1(56.81,88.47)
  IN1 w0.508: v3(57,92.59) 57.35,92.59 57.96,91.98 57.96,89.63 v1(56.81,88.47)
  BOTTOM w0.356: v3(57,92.59) 57,92.59 PQ4.4
  BOTTOM w0.508: PQ6.4 56.81,88.13 v1(56.81,88.47) 55.51,88.47 PC5.1
N17156948: length 3.4
  BOTTOM w0.254: PQ6.2 61.13,86.55 61.29,86.39 v2(61.29,86.05) 61.29,85.75 61.14,85.6 PQ6.1
N17639884: length 3.7
  BOTTOM w0.203: PU500.2 101.28,69.74
  BOTTOM w0.254: 101.28,69.74 100.56,69.03 PR519.2 PC505.2
N17640254: length 7
  BOTTOM w0.127: PR535.1 v2(112.15,67.33)
  BOTTOM w0.203: 106.06,68.14 106.01,68.19 PU500.25
  BOTTOM w0.254: PR535.1 PR523.1 PC506.1 107.54,67.33 106.72,68.14 106.06,68.14
N17640267: length 3.6
  BOTTOM w0.127: v2(112.43,63.39) 112,63.82 112,65.09 PC512.1
  BOTTOM w0.254: PC512.1 111.75,65.7 PR535.2
N17640270: length 9.1
  BOTTOM w0.127: v2(111.56,64.33) 111.31,64.33 110.83,64.81 PC512.2
  BOTTOM w0.203: 105.93,67.76 105.61,68.08 PU500.26
  BOTTOM w0.254: 105.93,67.76 106.57,67.76 107.45,66.87 108.29,66.87 108.75,66.41 PC506.2 PR523.2 110.02,65.39 PR521.1 PC512.2
N17645088: length 6.3
  BOTTOM w0.254: PL500.3 122.92,81.85 123.25,81.52 123.25,77.36 PR512.2
N17680637: length 5.3
  BOTTOM w0.102: v2(99.07,75.4) 99.71,75.4 100.32,74.79 PR536.2
  BOTTOM w0.203: PU500.8 102.2,72.14 101.89,72.46
  BOTTOM w0.254: PR536.2 101.83,72.72 101.83,72.52 101.89,72.46
N17680665: length 6
  BOTTOM w0.102: 100.32,71.14 99.86,70.68 v2(97.83,70.68)
  BOTTOM w0.203: PU500.3 101.41,70.14
  BOTTOM w0.254: 101.41,70.14 101.38,70.17 PR516.1 PR539.1
N18325201: length 4.9
  TOP w0.127: CL16.1 306.17,91.16 v2(306.68,91.67)
  TOP w0.508: CL16.1 306.17,88.77 v1(306.32,88.62)
  BOTTOM w0.508: TL1.3 306.85,89.15 v1(306.32,88.62)
N18325205: length 4.7
  TOP w0.127: CL17.1 305.03,91.44 v2(304.83,91.65)
  TOP w0.508: v1(305.29,88.6) 305.03,88.86 CL17.1
  BOTTOM w0.508: v1(305.29,88.6) 305.58,88.88 TL1.4
N18325209: length 5
  TOP w0.127: CL20.1 298.81,90.81 299.24,91.24 v2(299.24,91.58)
  TOP w0.508: CL20.1 298.81,88.46 v1(298.8,88.46)
  BOTTOM w0.508: v1(298.8,88.46) 299.23,88.88 TL1.9
N18325213: length 4.8
  TOP w0.127: v2(297.23,91.54) 297.41,91.37 CL21.1
  TOP w0.508: CL21.1 297.41,89.52 297.96,88.98 v1(297.96,88.49)
  BOTTOM w0.508: TL1.10 v1(297.96,88.49)
N18339814: length 1.1
  BOTTOM w0.254: RA25.2 21.88,92.55 DA5.1
N18339816: length 2.7
  BOTTOM w0.102: DA4.1 20.07,95.98 20.5,96.41 v2(20.5,96.79)
  BOTTOM w0.254: RA24.2 20.87,94.77 DA4.1
N18364501: length 3.6
  BOTTOM w0.102: UV7.20 136.45,91.08 135.93,90.57 135.55,90.57 v2(135.04,90.06) RV50.1
N18366912: length 3
  BOTTOM w0.102: CV60.1 136.18,89.18 137.65,90.65 UV7.17
N18431888: length 8.3
  BOTTOM w0.508: RA1.2 18.97,87.84 18.67,87.53 18.17,87.53 17.56,88.14 17.26,88.14 17.11,88.29 16.42,88.29 16.42,88.62 14.97,90.07 v1(14.19,90.07) JHP1.5
N18490882: length 3.2
  TOP w0.102: v2(304.97,81.35) 305.02,81.4 RI14.2 306.12,81.38 UI3.16
N18609334: length 10.3
  BOTTOM w0.254: QV8.2 RV6.2 109.44,95.96 109.7,96.23 v2(109.7,97.83) 108.59,98.95 108.59,100.23 109.47,101.12 QV7.1
N18749305: length 3.5
  BOTTOM w0.102: v2(92.66,98.3) LV1.1 91.54,99.03 91.39,99.18 JEDP1.21
N18754440: length 3.4
  BOTTOM w0.102: RA27.2 32.75,97.48 33.4,98.13 v2(33.77,98.13) 34.01,98.13 34.56,97.58 QA3.3
N18754442: length 7.7
  BOTTOM w0.102: QA3.6 35.9,96.04 35.9,96.48 35.81,96.57 35.81,97.54 35.57,97.78 34.68,97.78 34,98.47 v2(32.4,98.47) 32.27,98.47 31.84,98.03 RA28.2
N18779977: length 2.2
  BOTTOM w0.102: C319.1 R273.2 v2(179.3,105.53)
N18779979: length 2.3
  BOTTOM w0.102: v2(169.08,104.33) 169.08,105.4 R41.2 C43.1
N18779981: length 2.2
  BOTTOM w0.102: v2(166.92,104.33) C42.1 R6.2
N19516037: length 1
  TOP w0.102: CZ9.1 RZ35.1
N19544058: length 2.3
  TOP w0.102: v2(191.94,55.95) 192.2,55.68 RC62.1 CC10.2
N19544059: length 1
  TOP w0.102: RC61.1 CC9.2
N19638635: length 4.6
  TOP w0.102: PR114.1 221.23,58.87 v2(221.27,58.87)
  TOP w0.203: PU100.19 218.82,61.86 219.21,61.47 219.37,61.47
  TOP w0.254: 219.37,61.47 220.16,60.68 PR114.1
N19651849: length 2.2
  TOP w0.102: RE27.2 CE9.1 v2(243.88,78.68)
N19651850: length 8
  TOP w0.102: RE24.1 245.99,82.54 246.16,82.36 v1(246.67,82.36) 246.67,82.53 246.93,82.78 v2(247.76,82.78) ; UE1.B19 250.15,82.94 v1(250.52,83.31)
  IN3 w0.122: v1(246.67,82.36) 247.09,81.95 248.29,81.95 249.09,82.74 249.95,82.74 v1(250.52,83.31)
N19891055: length 2.3
  TOP w0.102: UV16.8 v2(178.89,91.11) 178.89,90.72 178.85,90.68 RV121.2
N20360585: length 5.2
  TOP w0.102: v2(19.14,91.76) 19.37,91.76 19.84,92.23 CA49.2
  TOP w0.203: UA1.34 23.31,93.41 23.24,93.34 23.18,93.34 23.12,93.28 22.94,93.28 22.88,93.22 22.87,93.22 22.72,93.07
  TOP w0.254: CA49.2 20.47,92.23 21.04,92.8 22.45,92.8 22.72,93.07
N20361305: length 6.1
  TOP w0.102: CA35.2 21.58,99.05 20.61,100.02 v2(20.19,100.02)
  TOP w0.254: CA35.2 23.61,98.62 23.94,98.29 23.94,97.7 23.66,97.42 UA1.25
N20363962: length 3
  TOP w0.203: UA1.21 25.71,99.63 RA44.1
  TOP w0.254: RA44.1 CA51.1
N20363967: length 4.9
  TOP w0.203: UA1.39 25.31,91.33 25.24,91.26 25.24,91.23 25.17,91.16 25.17,91.14 24.45,90.42 24.45,90.39 24.42,90.36
  TOP w0.254: CA52.1 22.02,88.9 v2(23.19,90.07) 23.48,90.36 24.42,90.36
N20363972: length 4.2
  TOP w0.102: UA1.7 31,95.01 32.32,96.33 CA53.1
N20571750: length 3.4
  TOP w0.102: v2(270.07,77.18) 269.71,76.82 CZ23.1 268.97,76.51 269.43,76.05 269.43,75.66 269.17,75.4 UZ2.10
N20571754: length 2
  TOP w0.102: UZ2.12 268.37,76.01 267.96,76.43 CZ49.1
N20572359: length 2.1
  TOP w0.102: UZ3.12 275.01,59.01 275.12,58.91 v2(275.12,58.4) CZ37.1
N20572446: length 2.3
  TOP w0.102: UZ3.10 274.21,59.1 273.84,58.73 v2(273.84,58.5) 273.84,58.16 274.1,57.89 CZ62.1
N20576488: length 1.6
  TOP w0.102: CZ64.1 180.95,79.72 180.8,79.57 UZ7.6
N20670193: length 7.3
  BOTTOM w0.102: SW1.2 v1(230.6,71.49) 230.6,73.76 RC2.2
N20711035: length 2.5
  TOP w0.102: v1(217.58,45.16) 217.21,45.53 v2(217.21,45.66)
  TOP w0.254: v1(217.58,45.16) 218.17,44.57 PR309.1
  BOTTOM w0.254: v1(217.58,45.16) 218.17,44.57 PC304.2
N20813044: length 11
  TOP w0.508: PR822.1 133.88,99.09 133.7,99.27 PD813.1 133.77,101.35 133.77,102.73 PC809.2 PR818.1 132.25,102.86 v2(131.48,103.62) v1(131.48,104.59)
  BOTTOM w0.508: PQ826.4 131.02,105.05 131.07,105 131.07,104.96 131.42,104.61 131.46,104.61 v1(131.48,104.59) 132.12,103.95 PQ815.4
N20813052: length 3.3
  TOP w0.102: PC809.1 v2(134.99,103.77)
  TOP w0.508: PC809.1 PR818.2 132.63,104.22 v1(132.94,104.54)
N20813067: length 9.8
  TOP w0.254: v1(54.43,87.35) 54.43,92.83 53.1,94.16 PQ832.2
  BOTTOM w0.102: PR828.2 v2(54.7,85.69)
  BOTTOM w0.254: PR828.2 54.7,87.09 v1(54.43,87.35)
N20813069: length 5.9
  TOP w0.102: PR830.2 v2(50.03,92.47)
  TOP w0.254: PQ829.2 PR830.2 51.12,93.12 50.55,93.69 PQ832.1
N20813073: length 4
  TOP w0.102: v2(57.47,94.17) 56.63,94.17 PD815.2
  TOP w0.254: PD815.2 56.61,93.22 55.46,92.06 PQ829.1
N20813075: length 4.2
  TOP w0.102: PR895.2 v2(51.32,89.5)
  TOP w0.254: PR830.1 51.12,91.18 51.32,90.97 PR895.2 52.16,90.49 52.21,90.54 PQ829.3
N20813085: length 5.3
  TOP w0.102: v3(120.24,100.23) 120.58,99.89 v2(120.82,99.89)
  TOP w0.508: PC807.2 119,99.77 PR811.1 119.91,99.89 v3(120.24,100.23)
  BOTTOM w0.508: PQ810.4 120.07,100.02 120.24,100.19 v3(120.24,100.23)
N20813089: length 3.3
  BOTTOM w0.102: PR853.2 93.17,67.17 93.47,67.48 v2(93.47,67.5)
  BOTTOM w0.254: PQ813.5 92.19,66.87 PR853.2
N20826302: length 5.9
  TOP w0.508: PR204.1 261.67,31.77 v1(261.68,31.75)
  BOTTOM w0.203: 259.88,34.41 259.26,35.02 PU200.12
  BOTTOM w0.508: v1(261.68,31.75) PC209.2 261.19,32.62 v2(259.88,33.92) 259.88,34.41
N20857922: length 68
  TOP w0.254: PR816.1 v1(101.82,43.55) 88.14,43.55 85,46.69 84.86,46.69 83.25,48.3 83.25,53.08 81.5,54.83 81.5,56.39 79.18,58.7 79.18,60.99 74.03,66.14 74.03,72.79 71.65,75.16 v2(69.48,75.16) 67.98,75.16 v1(65.23,77.9)
  BOTTOM w0.254: PQ806.3 v1(65.23,77.9) ; PR815.2 v1(101.82,43.55)
N20862119: length 3.9
  TOP w0.102: PR525.1 106.86,76.23 106.24,76.85 v2(106.24,77.16)
  TOP w0.254: PR524.1 106.13,74.79 106.26,74.92 PR518.2 PR525.1
N20935195: length 4.3
  TOP w0.102: PR799.1 82.54,74.07 v2(82.72,73.89)
  TOP w0.203: PU700.21 79.72,75 79.98,74.74 81.76,74.74 81.86,74.84 PR799.1
N20987678: length 5.7
  BOTTOM w0.254: PR827.2 93.51,66.59 PQ814.3 95.5,68.58 v2(95.5,69.92) 95.5,70.57 PD817.1
N20987955: length 65.5
  BOTTOM w0.254: PR813.2 91.08,44.08 87.97,47.2 86.49,47.2 83.13,50.56 83.13,54.92 79.41,58.65 79.41,60.73 74.02,66.13 74.02,73.36 72.64,74.74 64.15,74.74 v2(63.23,75.66) 63.23,78.31 62.99,78.55 PQ806.5 62.3,78.55 62.19,78.66 62.19,79.02 62.37,79.2 PQ806.6
N20988471: length 7.2
  TOP w0.254: v1(94.15,75.4) 93.84,75.71 PR819.1
  BOTTOM w0.254: PU806.1 90.21,72.06 90.09,72.18 90.09,73.12 90.35,73.37 PQ817.6 91.43,73.37 v2(93.15,75.1) 93.46,75.4 v1(94.15,75.4)
N22492653: length 3
  TOP w0.102: v2(302.27,49.34) 302.73,49.8 CN4.1 303.7,50.29 303.94,50.54 UN3.6
N23549436: length 3.3
  TOP w0.203: UA1.22 25.31,99.05 v1(25.24,99.11)
  BOTTOM w0.102: v2(24.35,100.55) 25.16,99.74 RA45.1
  BOTTOM w0.203: v1(25.24,99.11) 25.39,99.25 RA45.1
N24544483: length 17.4
  BOTTOM w0.254: PQ2.1 46.94,83.59 PR7.1 47.14,83.63 48.13,82.65 ; PL3.1 55.38,84.04 55.35,84.01 PD5.3 PD5.2 54.66,81.31 54.06,81.9 54.06,83.01 52.92,84.15 v2(52.46,84.15) 49.63,84.15 48.13,82.65 ; 48.13,82.65 PR10.2
N24606174: length 5.4
  BOTTOM w0.102: PC309.1 219.56,44.52 v2(221.02,44.52)
  BOTTOM w0.254: PU300.5 216.72,45.89 216.95,45.66 217.78,45.66 218.26,45.18 218.76,45.18 PC309.1
N25271873: length 2.8
  TOP w0.102: RE70.2 249.67,68.67 QE4.2 248.19,68.03 v2(247.76,68.46)
N48705653: length 5.1
  BOTTOM w0.127: v2(47.94,84.57) 47.03,84.57 46.09,83.63 PR7.2
  BOTTOM w0.254: PQ2.3 44.85,82.94 44.95,83.04 PR9.1 PR7.2
N48705663: length 3.4
  BOTTOM w0.102: PR12.2 50.76,82.67 v2(51.09,83)
  BOTTOM w0.254: PQ3.2 50.19,82.56 PR12.2 50.03,82.62 PR10.1
N48705665: length 9.2
  BOTTOM w0.102: PQ3.1 50.97,79.51 v2(50.97,78.55)
  BOTTOM w0.254: PQ3.1 50.82,79.62 PR13.1 46.33,79.62 45.94,80.02 PQ2.2 43.11,80.02 PR11.2
N48708367: length 5.3
  BOTTOM w0.102: PR210.2 262.34,40.25 v2(263.18,41.09)
  BOTTOM w0.203: PU200.7 261.23,37.42 261.4,37.59
  BOTTOM w0.254: PR210.2 262.34,39.04 261.79,38.48 261.79,37.98 261.4,37.59
N48708425: length 6.4
  BOTTOM w0.102: v2(264.91,33.57) 263.94,34.53 262.7,34.53 262.34,34.89 PR206.2
  BOTTOM w0.203: 261.09,36.39 260.85,36.62 PU200.9
  BOTTOM w0.254: PR206.2 261.47,35.12 261.21,35.37 261.21,36.26 261.09,36.39
N48716673: length 4
  BOTTOM w0.254: PU800.28 98.56,55.22 98.5,55.16 PR838.1 97.8,53.63 97.98,53.46 v2(97.98,52.97)
N48716693: length 4.7
  BOTTOM w0.102: v2(100.6,50.15) 100.6,51.88 100.14,52.34 PR845.1
  BOTTOM w0.254: PU800.26 100.9,53.69 100.11,52.9 PR845.1
N49522072: length 9.7
  TOP w0.102: PR702.2 62.95,87.57 v2(62.01,87.57)
  TOP w0.254: PQ701.2 68.92,88.83 68.34,89.41 66.59,89.41 65.35,88.18 PQ702.2 64.1,88.18 63.56,87.65 PR702.2 PC700.2
N49522215: length 12.2
  TOP w0.102: v2(174.05,118.11) 174.19,117.97 PR706.2 PR707.2 ; PR709.2 PR707.2 ; PR707.2 175.58,116.88 176.3,116.88 v1(176.32,116.86) 176.32,116.75 176.89,116.18 PQ703.1 ; v1(179.46,115.18) 179.46,114.95 179.19,114.68 178.92,114.68 178.79,114.8 PQ703.3
  IN2 w0.122: v1(179.46,115.18) 179.46,115.77 178.91,116.33 177.25,116.33 176.71,116.86 v1(176.32,116.86)
N49522242: length 4.9
  TOP w0.254: PU700.1 79.72,79.78 80.07,80.13 v1(80.07,81.46) 80.07,81.73 80.25,81.9 PC702.2 80.25,83.12 PR705.2 81.09,83.17 PC703.1
N49522275: length 5.9
  TOP w0.102: v2(77.64,84.27) 78.73,83.17 PR704.2
  TOP w0.254: PU700.2 79.32,79.88 79.34,79.89 79.34,79.94 79.45,80.04 79.45,80.4 79.45,80.4 79.45,80.99 PC701.2 79.35,82.22 PC702.1 79.34,83.12 PR704.2
N49522729: length 10.1
  TOP w0.102: v2(68.75,95.57) 68.24,96.08 v3(67.98,96.08)
  TOP w0.254: PQ701.1 68.21,90.26 67.92,90.55 67.92,96.01 v3(67.98,96.08)
  BOTTOM w0.254: PR701.2 67.6,96.59 67.98,96.21 v3(67.98,96.08)
N49522731: length 9.6
  TOP w0.102: v2(66.71,96.71) v3(67.35,96.08)
  TOP w0.254: PQ702.1 67.06,90.26 67.48,90.68 67.48,95.95 v3(67.35,96.08)
  BOTTOM w0.254: PR701.3 67.6,95.63 67.35,95.89 v3(67.35,96.08)
N49522780: length 3.6
  BOTTOM w0.102: v2(63.16,90.62) 62.85,90.62 PR700.1
  BOTTOM w0.508: PR700.1 61.89,91.58 PQ700.4
N61500733: length 3.1
  BOTTOM w0.203: PU500.4 101.71,70.54
  BOTTOM w0.254: 101.71,70.54 v2(101.42,70.84) 101.07,71.19 101.07,71.45 PR513.1
N61500909: length 4.1
  BOTTOM w0.203: PU500.28 104.81,67.68 v2(105.12,67.38)
  BOTTOM w0.254: PC510.2 PR526.1 105.12,66.12 v2(105.12,67.38)
N61500999: length 5.9
  TOP w0.102: v2(121.32,77.03) 121.32,77 v1(121.82,76.51)
  IN4 w0.254: v1(121.82,76.51) 122.44,75.89 124.27,75.89 v1(124.96,76.57)
  BOTTOM w0.254: PR515.1 v1(124.96,76.57) ; PH501.2 122.26,76.06 v1(121.82,76.51)
N61501245: length 47.2
  TOP w0.102: v3(132.58,89.23) v2(133.38,89.23)
  TOP w0.254: PR505.2 106.46,73.85 v3(106.85,74.23)
  IN4 w0.254: v3(132.58,89.23) 133.36,88.45 133.36,76.74 133.07,76.45 133.07,76.43 131.64,75 107.61,75 v3(106.85,74.23)
  BOTTOM w0.203: PU500.14 105.21,73.34 105.98,74.11 106.72,74.11 v3(106.85,74.23)
  BOTTOM w0.254: v3(106.85,74.23) 107.23,74.62 PC501.1 ; v3(132.58,89.23) 132.28,89.52 PH500.2
N61501462: length 5
  BOTTOM w0.203: PU500.16 106.01,73.12 106.24,73.35 106.59,73.35
  BOTTOM w0.254: 106.59,73.35 108.62,73.35 v2(109.07,73.79) 109.26,73.98 PR511.2
N66971793: length 6
  TOP w0.102: PR105.2 221.83,66.03 222.14,66.33 224.24,66.33 v2(224.73,66.82)
  TOP w0.203: PU100.5 220.32,64.65 220.57,64.9 220.57,65.15
  TOP w0.254: 220.57,65.15 221.27,65.85 PR105.2
N66972075: length 3.7
  TOP w0.102: PR106.2 221.78,61.74 v2(221.78,60.77)
  TOP w0.203: PU100.1 220.52,63.05 220.64,62.93
  TOP w0.254: PR106.2 221.4,61.79 220.64,62.55 220.64,62.93
N78957489: length 4.2
  TOP w0.102: PQ816.1 132.12,94.63 v2(132.65,94.1)
  TOP w0.254: PR822.2 133.88,96.13 133.1,95.34 PQ816.1
N78967043: length 67.1
  TOP w0.254: v1(133.17,96.34) 132.77,96.75 PQ816.2
  IN2 w0.254: v1(89.45,70.98) 90.3,70.13 94.63,70.13 95.92,71.43 95.92,73.06 98.37,75.5 98.75,75.5 100.18,76.94 104.38,76.94 105.22,77.78 105.22,81.8 106.9,83.48 106.9,90.62 v1(108.32,92.04)
  IN3 w0.254: v1(108.32,92.04) 109.72,93.44 109.72,94.22 110.59,95.1 116.34,95.1 117.64,96.4 123.96,96.4 125.22,95.14 130.42,95.14 130.59,95.32 132.14,95.32 v1(133.17,96.34)
  BOTTOM w0.102: v2(88.91,69.61) 88.69,69.84 PU806.4
  BOTTOM w0.254: PU806.4 89.23,70.76 v1(89.45,70.98)
N78985854: length 7.4
  BOTTOM w0.254: PR812.2 65.49,76.29 68.77,76.29 69.05,76.01 v2(69.51,76.01) 69.52,76.03 PR810.2 69.24,77.5 PU804.2
N79002827: length 5.6
  BOTTOM w0.102: PQ806.2 64.2,78.55 63.97,78.78 v2(63.97,80.63)
  BOTTOM w0.254: PU804.4 66.05,76.85 65.72,77.19 65.72,78.1 65.27,78.55 PQ806.2
N79023703: length 5.2
  BOTTOM w0.102: v2(106.16,50.08) 106.39,50.31 106.39,51.78 105.83,52.34 PR863.1
  BOTTOM w0.254: PR863.1 104.4,53.64 PU800.19
N79030038: length 5.2
  BOTTOM w0.254: PQ813.3 87.69,67.52 v2(87.23,67.99) 86.75,67.99 86.6,67.83 PR829.2 PQ813.2
N79030087: length 2.1
  BOTTOM w0.254: PR826.2 92.33,66.22 v2(91.53,66.22) PQ813.6
N79030091: length 4.5
  BOTTOM w0.102: v2(92.49,63.95) PR826.1
  BOTTOM w0.254: PR826.1 PR827.1 93.99,65.14 PQ814.2
N79030745: length 65.5
  TOP w0.102: v2(97.45,68.9) 97.45,68.33 v3(97.38,68.27)
  TOP w0.254: v3(130.52,99.38) 130.52,99.6 131.3,100.38 PD813.2
  IN1 w0.254: v3(97.38,68.27) 97.94,68.82 97.94,74.64 99.67,76.37 106.48,76.37 107.26,75.58 117.87,75.58 118.66,76.37 118.66,96.28 120.09,97.72 125.6,97.72 126.99,99.1 130.24,99.1 v3(130.52,99.38)
  BOTTOM w0.254: v3(97.38,68.27) 97.35,68.23 PQ814.1
N79114795: length 4.2
  TOP w0.102: PC4.1 88.86,3.7 v2(89.19,3.37) ; PC4.1 88.18,3.83 PR6.2 ; PC4.1 86.83,3.7 PQ1.2
N79114801: length 14.4
  TOP w0.254: PD4.2 78.23,2.8 78.54,2.49 v2(82.8,2.49) 83.43,2.49 84.21,3.28 PQ1.1
N80905978: length 6.4
  BOTTOM w0.127: v2(230.92,62.02) 230.92,60.57 PR401.1
  BOTTOM w0.254: PR401.1 PC402.1 PR400.2 233.46,59.76 233.08,59.38 PU400.8
N80906026: length 5.4
  BOTTOM w0.102: v2(233.81,51.11) 233.51,50.82 PR403.1
  BOTTOM w0.254: PU400.2 231.81,51.04 PC403.2 ; PR403.1 232.65,50.87 PC403.2 ; PC403.2 PR402.2

## Copper pours and planes (outline as drawn)
0.675V_DDR_VTT_ON on TOP (solid shape): 141.47,5.77 141.47,4.69 141.63,4.52 141.96,4.52 142.06,4.42 142.06,3.63 141.92,3.5 140.86,3.5 140.67,3.69 140.67,4.45 140.33,4.78 140.33,5.93 140.5,6.1 141.14,6.1
0.675V_DDR_VTT_ON on TOP (solid shape): 136.54,6.73 136.54,4.1 136.25,3.81 134.81,3.81 134.3,3.3 132.58,3.3 132.5,3.38 132.5,4.64 132.88,5.02 133.72,5.02 134.15,4.59 134.77,4.59 135.03,4.85 135.03,6.8 135.24,7.01 136.26,7.01
0.675V_DDR_VTT_ON on IN2 (solid shape): 141.14,10.72 141.14,4.96 141.01,4.83 140.25,4.83 140.08,5.01 140.08,9.81 139.85,10.04 136.73,10.04 136.51,9.82 136.51,8.38 136.47,8.35 136.47,6.4 136.1,6.03 135.25,6.03 135.16,6.12 135.16,10.55 135.62,11.01 140.84,11.01
1.5VSP on BOTTOM (solid shape): 231.05,53.66 231.05,49.66 230.86,49.47 230.16,49.47 229.72,49.91 227.69,49.91 227.36,50.24 227.36,50.26 227.34,50.26 227.32,50.28 226.95,50.28 226.95,50.82 226.52,50.82 226.52,50.28 226.14,50.28 226.02,50.4 226.02,53.65 226.23,53.85 230.86,53.85
1.35V_B+ on TOP (solid shape): outline of 176 points within 241.64,34.36 249.85,38.55
1.35V_FB on BOTTOM (solid shape): 261.47,42.74 261.47,42.48 261.66,42.29 261.66,38.86 261.47,38.67 261.47,38.04 261.15,37.72 260.07,37.72 260.01,37.79 260.01,37.91 260.13,38.04 260.58,38.04 260.71,38.17 260.71,38.8 260.96,39.06 260.96,39.94 260.58,40.33 260.58,42.8 260.64,42.87 261.34,42.87
+0.9V_LAN on TOP (solid shape): 269.16,88.23 269.16,87.02 269.51,86.68 269.93,86.68 270.56,86.05 270.8,86.05 270.93,85.92 270.93,84.78 270.83,84.67 268.36,84.67 267.68,85.36 267.14,85.36 267.07,85.44 267.07,86.2 267.13,86.26 268.02,86.26 268.15,86.39 268.15,87.91 268.53,88.29 269.1,88.29
+0.9V_LAN on TOP (solid shape): 277.15,91.63 277.15,90.93 277.09,90.87 276.58,90.87 276.45,90.74 276.45,90.3 276.58,90.17 276.64,90.17 276.77,90.04 276.77,89.94 277.37,89.35 277.37,88.43 277.29,88.36 276.83,88.36 276.77,88.42 276.77,89.47 276.53,89.72 276.12,89.72 275.62,90.22 275.62,91.53 275.84,91.76 277.03,91.76
+0.9V_LAN on IN3 (solid shape): 276.38,90.64 276.46,90.61 276.48,90.53 276.56,90.26 276.89,90.1 276.91,90.02 277.1,89.67 277.51,89.72 277.57,89.74 277.64,89.72 277.99,89.68 278.2,89.96 278.24,90.02 278.3,90.05 278.5,90.11 278.63,90.28 278.64,90.31 280.95,90.31 281.19,90.07 281.19,89.6 281.01,89.42 279.4,89.42 278.86,88.88 276.16,88.88 275.83,88.56 275.83,84.81 276.26,84.38 280.28,84.38 280.68,83.97 280.68,81.74 280.48,81.54 279.93,81.54 279.69,81.78 279.69,82.55 279.5,82.74 278.63,82.74 278.47,82.59 278.47,81.93 277.88,81.33 277.5,81.33 277.3,81.52 277.3,82.81 277.01,83.1 275.13,83.1 274.54,83.7 274.54,84.28 274.07,84.75 270.45,84.75 270.29,84.9 270.29,85.66 270.55,85.92 271.04,85.92 271.06,85.93 273.6,85.93 274.22,86.55 274.22,89.13 275.73,90.64
+0.675V_DDR_VTT on TOP (solid shape): 154.9,5.15 154.9,3.44 154.79,3.33 151.88,3.33 151.61,3.6 151.61,5.03 151.89,5.31 154.74,5.31
+0.675V_DDR_VTT on TOP (solid shape): 154.98,10.91 154.98,9.44 154.75,9.21 152.06,9.21 151.82,9.45 151.82,11 151.87,11.05 154.84,11.05
+0.675V_DDR_VTT on TOP (solid shape): 230.68,5.76 230.68,3.94 230.48,3.74 229.07,3.74 228.64,3.3 227.11,3.3 227.01,3.41 227.01,5.32 227.55,5.86 230.58,5.86
+0.675V_DDR_VTT on BOTTOM (solid shape): 254.42,41.98 254.42,41.28 254.99,41.28 254.99,41.15 254.42,41.15 254.42,40.33 254.29,40.2 252.7,40.2 252.58,40.33 252.58,41.98 252.7,42.1 254.29,42.1
+0.675V_DDR_VTT on BOTTOM (solid shape): 152.46,11.98 154.13,11.98 154.14,11.99 154.37,11.99 154.52,11.84 154.52,9.4 154.39,9.27 152.03,9.27 151.79,9.51 151.79,12.28 151.87,12.36 152.08,12.36
+0.675V_DDR_VTT on BOTTOM (solid shape): 154.89,5.2 154.89,4.19 154.77,4.08 152.58,4.08 152.45,3.95 152.45,2.19 152.39,2.12 152.2,2.12 152.11,2.21 152.11,4.5 152.56,4.95 152.89,4.95 153.25,5.31 154.77,5.31
+0.675V_DDR_VTT on BOTTOM (solid shape): outline of 188 points within 227.77,1.73 237.13,12.83
+0.675V_DDR_VTT on IN2 (solid shape): outline of 2248 points within 151.59,1.95 231.5,11.03
+0.675V_DDR_VTT on IN4 (solid shape): 232.7,5.67 232.7,4.65 232.37,4.32 229.51,4.32 229.21,4.63 229.21,5.53 229.81,6.12 232.24,6.12
+0.675V_DDR_VTT on IN4 (solid shape): 253.89,42.1 253.89,40.57 253.75,40.43 251.18,40.43 250.42,41.19 250.42,42.06 250.83,42.48 253.51,42.48
+0.675V_P on BOTTOM (solid shape): 256.34,41.65 256.34,41.61 256.59,41.35 256.59,41.34 256.66,41.25 256.76,41.18 256.77,41.18 256.82,41.12 256.86,41.12 256.9,41.09 258,41.09 258.55,40.54 258.55,38.23 258.48,38.17 258.42,38.17 258.36,38.23 258.36,39.5 258.29,39.56 257.85,39.56 257.59,39.31 256.96,39.31 256.71,39.06 256.71,39.02 256.59,38.9 256.59,38.7 256.58,38.6 256.59,38.46 256.62,38.42 256.69,38.33 256.78,38.26 256.79,38.25 257.05,38 257.63,38 257.72,37.91 257.72,37.79 257.66,37.72 256.96,37.72 256.58,38.1 256.07,38.1 255.82,38.36 255.82,39.82 255.63,40.01 254.86,40.01 254.67,40.2 254.67,40.96 255.18,40.96 255.18,41.53 254.67,41.53 254.67,41.98 254.74,42.04 255.94,42.04
+1.2V_LDO on TOP (solid shape): 313.92,69.29 313.92,68.81 313.58,68.47 311.96,68.47 311.66,68.77 311.24,68.77 311.15,68.68 310.66,68.68 310.62,68.72 310.62,69.17 310.67,69.22 311.18,69.22 311.45,69.49 313.71,69.49
+1.2V_LDO on TOP (solid shape): 307.06,67.67 307.06,65.98 307.01,65.93 306.21,65.93 306.12,66.02 306.12,67.54 305.97,67.69 304.72,67.69 304.66,67.63 304.66,67.16 304.6,67.1 304.01,67.1 303.89,67.22 303.89,68.6 303.97,68.68 306.04,68.68
+1.2V_LDO on IN1 (solid shape): outline of 1079 points within 306.23,60.92 318.86,70.96
+1.05V_M on TOP (solid shape): 178.14,80.69 178.14,79.96 178.05,79.87 176.92,79.87 176.57,79.52 176.57,78.56 176.86,78.27 178.65,78.27 178.74,78.18 178.74,76.47 178.66,76.39 177.46,76.39 177.08,76.02 176.7,76.02 176.07,75.39 175.98,75.33 175.82,75.2 175.66,75.07 175.59,75 172.76,75 172.25,75.51 172.24,75.51 171.7,76.05 171.7,78.71 173.19,78.71 173.19,78.65 173.2,78.6 173.21,78.55 173.24,78.5 173.27,78.46 173.3,78.42 173.34,78.38 173.39,78.36 173.44,78.34 173.49,78.33 173.55,78.32 173.6,78.33 173.65,78.34 173.7,78.36 173.75,78.38 173.79,78.42 173.82,78.46 173.85,78.5 173.88,78.55 173.89,78.6 173.9,78.65 173.9,78.71 173.89,78.76 173.88,78.81 173.85,78.86 173.82,78.9 173.79,78.94 173.75,78.97 173.7,79 173.65,79.02 173.6,79.03 173.55,79.04 173.49,79.03 173.44,79.02 173.39,79 173.34,78.97 173.3,78.94 173.27,78.9 173.24,78.86 173.21,78.81 173.2,78.76 173.19,78.71 171.7,78.71 171.7,79.35 171.92,79.57 175.51,79.57 176.21,80.27 176.21,80.72 176.31,80.83 178,80.83
+1.05V_M on BOTTOM (solid shape): 202.68,49.47 202.98,49.47 203.11,49.34 203.11,48.83 202.64,48.83 202.64,47.95 203.11,47.95 203.11,47.69 202.64,47.69 202.64,46.8 203.11,46.8 203.11,45.53 199.99,42.41 196.25,42.41 195.75,42.92 195.75,43.22 198.49,43.22 198.49,43.17 198.5,43.12 198.51,43.06 198.54,43.02 198.57,42.97 198.6,42.93 198.64,42.9 198.69,42.87 198.74,42.85 198.79,42.84 198.84,42.84 198.9,42.84 198.95,42.85 199,42.87 199.04,42.9 199.09,42.93 199.12,42.97 199.15,43.02 199.18,43.06 199.19,43.12 199.2,43.17 199.2,43.22 199.19,43.27 199.18,43.33 199.15,43.37 199.12,43.42 199.09,43.46 199.04,43.49 199,43.52 198.95,43.54 198.9,43.55 198.84,43.55 198.79,43.55 198.74,43.54 198.69,43.52 198.64,43.49 198.6,43.46 198.57,43.42 198.54,43.37 198.51,43.33 198.5,43.27 198.49,43.22 195.75,43.22 195.75,48.45 196.16,48.87 197.39,48.87 198.96,50.43 201.51,50.43 201.53,50.46 201.69,50.46
+1.05V_M on VCC: 182.13,40.33 180.23,42.23 168.8,42.23 160.19,50.84 160.19,54.19 160.57,54.57 160.57,55.92 160.19,56.31 160.19,57.87 160.29,57.98 160.71,57.98 162.11,56.58 163.64,56.58 164.27,55.95 168.67,55.95 169.43,56.71 174.05,56.71 174.54,56.22 174.54,53.81 176.21,52.14 183.32,52.14 184.08,51.37 186.2,51.37 187.49,52.67 187.49,64.31 184.42,67.38 181.92,67.38 181.16,66.61 177.44,66.61 174.41,69.64 174.41,79.46 174.77,79.82 181.92,79.82 184.97,76.77 188.53,76.77 197.52,67.78 197.52,50.89 199.3,49.11 199.3,41.32 198.31,40.33
+1.05V_MODPHY on TOP (solid shape): outline of 307 points within 164.02,78.06 178.96,87.3
+1.05V_MODPHY_PCH on TOP (solid shape): 161.62,63.16 161.62,62.65 161.32,62.35 161.32,61.67 161.2,61.56 160.72,61.56 160.58,61.42 160.06,61.42 160.02,61.46 160.02,62.04 160.1,62.12 160.22,62.12 160.99,62.88 160.99,63.1 161.07,63.19 161.59,63.19
+1.05V_MODPHY_PCH on TOP (solid shape): 169.42,76.93 169.42,76.77 169.52,76.67 169.95,76.67 170.08,76.55 170.08,75.39 169.9,75.21 168.54,75.21 168.29,75.47 168.29,76.04 167.82,76.51 167.82,77.36 167.87,77.41 168.94,77.41
+1.05V_MODPHY_PCH on BOTTOM (solid shape): 164.13,64.47 164.13,63.34 164.03,63.24 163.37,63.24 163.32,63.19 163.08,63.19 162.22,62.32 162.22,62.04 161.66,61.48 160.72,61.48 160.52,61.69 160.52,62.7 161.2,63.39 162.38,63.39 163.56,64.57 164.03,64.57
+1.05V_MODPHY_PCH on IN2 (solid shape): outline of 1457 points within 160.58,61.56 170.92,76.72
+1.05V_MP on TOP (solid shape): 206.22,51.37 206.22,49.98 206.1,49.85 202.79,49.85 202.67,49.98 202.67,51.44 202.73,51.5 206.1,51.5
+1.05V_MP on BOTTOM (solid shape): 208.89,51.31 208.89,45.66 208.64,45.41 203.56,45.41 203.37,45.6 203.37,47.06 202.86,47.06 202.86,47.44 203.37,47.44 203.37,48.26 202.86,48.26 202.86,48.58 203.37,48.58 203.37,49.47 202.67,50.17 202.67,51.44 202.79,51.56 208.64,51.56
+1.05V_RUN on TOP (solid shape): 166.53,87.89 166.53,86.21 166.37,86.04 166.37,85.3 166.57,85.09 166.57,83.76 166.22,83.4 165.01,83.4 164.81,83.61 164.81,87.99 164.91,88.09 166.33,88.09
+1.05V_RUN on TOP (solid shape): 158.6,40.66 158.6,37.99 158.42,37.81 156.17,37.81 155.7,38.27 155.7,39.51 155.72,39.54 156.24,39.54 156.27,39.56 156.27,40.09 155.76,40.09 155.72,40.13 155.72,40.61 155.83,40.72 158.54,40.72
+1.05V_RUN on TOP (solid shape): 153.62,80.36 153.62,78.04 153.34,77.76 151.59,77.76 151.17,77.35 150.72,77.35 149.95,78.12 149.95,80.48 150.03,80.56 150.44,80.56 150.47,80.53 150.47,80.04 150.51,80 150.93,80 150.95,80.03 150.95,80.56 150.98,80.58 153.39,80.58
+1.05V_RUN on TOP (solid shape): 187.49,85 187.49,77.14 186.77,76.42 180.28,76.42 180.12,76.57 180.12,77.98 180.37,78.22 181.28,78.22 181.71,77.79 183.64,77.79 183.98,78.13 183.98,78.78 184.05,78.84 184.48,78.84 184.53,78.89 184.53,79.56 184.49,79.59 184.04,79.59 184,79.63 184,80 184.05,80.05 184.49,80.05 184.54,80.1 184.54,80.75 184.49,80.8 184.02,80.8 183.98,80.84 183.98,83.62 182.58,85.03 176.06,85.03 175.96,85.04 175.86,85.03 175.67,85.03 175.45,85.24 175.45,85.98 175.65,86.18 186.31,86.18
+1.05V_RUN on TOP (solid shape): outline of 159 points within 158.23,64.07 162.32,66.3
+1.5V_RUN on BOTTOM (solid shape): 226.82,50.66 226.82,50.18 226.87,50.13 227.23,50.13 227.39,49.96 227.39,49.22 227.22,49.04 226.38,49.04 226.17,49.24 226.17,50.1 226.2,50.13 226.58,50.13 226.64,50.19 226.64,50.65 226.68,50.69 226.8,50.69
+1.05V_RUN on BOTTOM (solid shape): outline of 1072 points within 146.98,76.7 187.9,87.95
+1.05V_RUN on IN1 (solid shape): outline of 1653 points within 155.93,54.94 165.21,66.34
+1.05V_RUN on IN2 (solid shape): outline of 1127 points within 150.56,75.55 187.92,82.73
+1.05V_RUN on VCC: 159.93,54.65 156.86,57.72 154.22,57.72 154.22,73.83 149.14,78.91 149.14,81.62 149.62,82.11 158.17,82.11 168.95,71.33 168.95,63.93 168.08,63.06 163.25,63.06 162.34,62.15 162.34,60.54 165.9,56.98 165.9,56.45 164.48,56.45 163.85,57.09 162.32,57.09 160.93,58.49 160.08,58.49 159.68,58.08 159.68,56.09 160.06,55.71 160.06,54.78
+1.5V_RUN_AUDIO on TOP (solid shape): 25.82,92.22 25.82,91.23 25.32,90.73 25.32,90.71 25.01,90.39 25.01,89.77 24.86,89.63 24.86,88.55 24.82,88.51 22.77,88.51 22.69,88.59 22.69,89.22 23.29,89.81 23.3,89.81 23.39,89.88 23.45,89.97 23.46,89.98 24.27,89.98 24.4,90.11 24.42,90.11 24.57,90.15 24.66,90.27 24.68,90.29 24.68,90.33 25.4,91.05 25.4,91.07 25.47,91.14 25.47,91.16 25.54,91.23 25.54,91.25 25.62,91.33 25.62,92.19 25.67,92.24 25.79,92.24
+1.05V_RUN_UZ7 on TOP (solid shape): 183.85,81.35 183.85,80.7 183.9,80.65 184.34,80.65 184.38,80.61 184.38,80.24 184.33,80.19 183.9,80.19 183.85,80.14 183.85,79.48 183.88,79.44 184.34,79.44 184.39,79.39 184.39,79.09 184.3,79 183.9,79 183.85,78.95 183.85,78.35 183.72,78.22 182.61,78.22 182.18,78.65 182.18,80.05 182.12,80.11 181.01,80.11 180.82,79.92 180.2,79.92 180.19,79.92 179.61,79.92 179.48,80.05 179.48,80.83 179.68,81.03 181.94,81.03 182.31,81.4 183.79,81.4
+1.05V_RUN_VMM on TOP (solid shape): 154.37,83.97 154.37,81.1 153.97,80.71 153.44,80.71 150.92,80.71 150.85,80.71 150.8,80.66 150.8,80.16 150.79,80.15 150.63,80.15 150.62,80.16 150.62,80.69 150.6,80.71 150.18,80.71 150.06,80.83 150.06,82.34 150.23,82.5 150.23,83.97 150.29,84.04 151.02,84.04 151.12,83.94 151.12,83.14 151.3,82.96 153.15,82.96 153.24,83.05 153.24,83.99 153.31,84.06 154.28,84.06
+1.05V_VCCST on TOP (solid shape): outline of 491 points within 153.45,38.8 157.08,58.07
+1.05V_VCCST on IN3 (solid shape): outline of 329 points within 117.13,56.26 119.51,65
+1.5V_VIN on BOTTOM (solid shape): 227.46,61.18 229.44,61.18 229.59,61.03 229.59,59.77 229.59,59.26 229.59,59.23 229.59,57.15 229.97,56.77 232.7,56.77 232.83,56.64 232.83,54.23 232.77,54.17 227.05,54.17 226.73,54.49 226.73,60.96 226.23,60.96 226.23,61.09 226.73,61.09 226.73,61.6 226.8,61.66 226.97,61.66
+1.05V_VMM_VDD on TOP (solid shape): 155.93,86.57 155.93,84.9 155.78,84.75 154.69,84.75 154.19,84.25 153.34,84.25 153.14,84.46 153.14,85.75 154.18,86.79 154.6,86.79 154.61,86.81 155.69,86.81
+1.05V_VMM_VDD on IN1 (solid shape): outline of 1230 points within 151.05,92.69 164.85,98.98
+1.05V_VMM_VDD on IN4 (solid shape): outline of 273 points within 149.93,83.73 160.58,96.42
+1.05V_VMM_VDDTX on TOP (solid shape): 152.9,85.97 152.9,84.85 152.81,84.76 151.69,84.76 151.18,84.25 150.25,84.25 150.16,84.34 150.16,85.84 150.61,86.29 152.58,86.29
+1.05V_VMM_VDDTX on BOTTOM (solid shape): 158.09,96.93 158.09,96.53 158.05,96.45 157.95,96.44 157.47,96.11 157.95,95.77 158.05,95.76 158.09,95.68 158.09,94.59 158.05,94.5 157.95,94.49 157.47,94.16 157.95,93.83 158.05,93.81 158.09,93.73 158.09,93.29 158.05,93.2 157.95,93.19 157.81,93.22 157.67,93.18 157.66,93.18 157.34,93.18 156.84,92.68 156.84,91.89 156.24,91.89 156.23,91.93 156.21,92.04 156.15,92.13 156.15,93.49 156.44,93.78 156.44,96.72 156.71,97 158.02,97
+1.05V_VMM_VDDTX on IN2 (solid shape): outline of 1304 points within 156.34,91.72 165.29,100
+1.05V_VMM_VDDTX on IN4 (solid shape): outline of 171 points within 151.73,85.52 158.1,93.79
+1.8V_RUN_CARD on TOP (solid shape): 313.6,60.16 313.6,58.41 313.42,58.23 312.6,58.23 312.5,58.33 312.5,59.65 311.76,60.39 311.76,61.15 311.85,61.24 312.52,61.24
+1.8V_RUN_CARD on BOTTOM (solid shape): 324.98,46.22 324.98,44.35 324.79,44.16 323.91,44.16 323.77,44.31 323.77,46.13 323.96,46.33 324.87,46.33
+1.8V_RUN_CARD on IN3 (solid shape): 314.06,59.5 314.06,58.16 313.86,57.96 312.57,57.96 312.46,58.07 312.46,59.61 312.62,59.78 313.78,59.78
+1.8V_RUN_CARD on IN4 (solid shape): 314.98,59.82 314.98,58.73 314.68,58.43 312.69,58.43 312.36,58.76 312.36,59.93 312.48,60.05 314.74,60.05
+1.8V_RUN_CARD on IN4 (solid shape): 325.27,46.16 325.27,45.11 325,44.84 323.73,44.84 323.55,45.01 323.55,46.12 323.87,46.43 325,46.43
+1.35V_MEM on TOP (solid shape): outline of 9265 points within 112.37,1.34 227.5,57.47
+1.35V_MEM on BOTTOM (solid shape): outline of 980 points within 110.4,1.27 239.92,33.92
+1.35V_MEN_P on BOTTOM (solid shape): 255.44,39.88 255.5,39.82 255.5,39.12 255.44,39.06 254.86,39.06 254.86,38.55 254.74,38.55 254.74,39.06 253.66,39.06 253.53,39.18 253.53,39.82 253.59,39.88 254.81,39.88
+1.35V_MEN_P on BOTTOM (solid shape): 260.39,42.74 260.39,40.26 260.59,40.06 260.59,40.05 260.6,40.05 260.77,39.88 260.77,39.56 260.64,39.44 259.82,39.44 259.5,39.75 259.5,40.2 259.5,42.74 259.56,42.8 260.32,42.8
+1.35V_MEN_P on BOTTOM (solid shape): outline of 333 points within 235.31,25.78 251.63,38.8
+1.35V_MEN_P on IN2 (solid shape): 255.65,39.88 255.65,39.14 255.44,38.93 253.15,38.93 253.09,38.99 253.09,40.01 253.15,40.07 255.46,40.07
+1.35V_MEN_P on IN2 (solid shape): 246.42,37.23 246.42,36.87 246.43,36.85 246.43,35.65 246.3,35.52 245.33,35.52 245.3,35.55 245.3,37.15 245.66,37.51 246.14,37.51
+3.3V_ALW on TOP (solid shape): 251.27,89.44 251.27,88.74 250.82,88.29 249.81,88.29 249.71,88.39 249.71,88.9 249.78,88.98 250.18,88.98 250.71,89.51 251.19,89.51
+3.3V_ALW on TOP (solid shape): 273.91,62.02 273.91,61.2 273.86,61.15 273.27,61.15 272.97,60.86 272.39,60.86 272.24,61.01 272.24,62.33 272.42,62.51 273.42,62.51
+3.3V_ALW on TOP (solid shape): 85.62,93.27 85.62,92.15 85.46,91.99 81.08,91.99 80.8,92.28 80.8,93.22 80.91,93.33 83.1,93.33 83.26,93.5 85.39,93.5
+3.3V_ALW on TOP (solid shape): 184.95,35.18 184.95,34.52 184.87,34.44 184.87,33.48 184.67,33.28 184.26,33.28 183.91,33.63 183.91,35 184.18,35.27 184.86,35.27
+3.3V_ALW on TOP (solid shape): 277.51,62.87 277.51,61.36 277.43,61.28 276.12,61.28 276,61.15 275.36,61.15 275.31,61.2 275.31,62.66 275.83,63.19 277.19,63.19
+3.3V_ALW on TOP (solid shape): 245.22,88.29 245.22,87.47 245.73,86.96 245.73,86.07 245.69,86.03 245.21,86.03 245.17,85.99 245.17,85.58 245.2,85.55 245.71,85.55 245.73,85.52 245.73,85.3 245.61,85.17 243.9,85.17 243.76,85.31 243.76,88.17 244.01,88.41 245.11,88.41
+3.3V_ALW on TOP (solid shape): 268.07,73.29 268.07,72.63 268.19,72.51 268.19,72.37 268.3,72.26 268.3,71.48 267.99,71.17 267.75,71.17 267.73,71.15 267.16,71.15 266.81,71.49 266.81,72.93 266.82,72.98 266.83,73.03 266.83,73.16 267.03,73.36 268.01,73.36
+3.3V_ALW on TOP (solid shape): 270.55,72.86 271.83,72.86 272.01,72.68 272.01,70.68 271.88,70.54 270.63,70.54 270.56,70.61 270.56,71.3 270.55,71.31 270.55,71.8 270.24,72.11 269.87,72.11 269.47,72.51 269.47,73.27 269.53,73.33 270.08,73.33
+3.3V_ALW on TOP (solid shape): 246.1,64.59 246.1,64.34 246.08,64.32 245.61,64.32 245.55,64.26 245.55,63.87 245.59,63.83 246.06,63.83 246.11,63.78 246.11,63.62 246.06,63.57 245.99,63.57 245.91,63.49 245.91,61.71 245.78,61.58 245.78,60.51 245.73,60.47 244.73,60.47 244.48,60.72 244.48,63.74 244.51,63.84 244.53,63.95 244.53,64.47 244.68,64.62 246.08,64.62
+3.3V_ALW on TOP (solid shape): 191.42,39.26 191.42,38.61 189.8,36.99 188.89,36.99 187.81,35.91 187.81,35.59 187.62,35.39 187.45,35.01 187.59,34.63 187.62,34.59 187.48,34.44 186.42,34.44 186.35,34.52 186.35,35.21 186.4,35.26 186.92,35.26 186.97,35.31 187.02,35.31 187.02,35.36 187.11,35.45 187.11,36.44 187.23,36.56 187.23,36.61 187.27,36.69 187.37,36.7 187.79,36.84 187.75,37.28 187.73,37.35 187.76,37.42 188.06,37.72 188.8,37.72 189.81,38.74 189.81,39.47 189.9,39.56 191.12,39.56
+3.3V_ALW on TOP (solid shape): outline of 319 points within 196.78,85.09 227.69,114.05
+3.3V_ALW on TOP (solid shape): outline of 1172 points within 100.58,91.81 169.88,120.67
+3.3V_ALW on BOTTOM (solid shape): 291.11,38.88 291.11,35.58 290.96,35.42 288.61,35.42 288.57,35.46 288.57,36.53 288.67,36.63 289.12,36.63 289.36,36.87 289.36,39.11 289.42,39.17 290.82,39.17
+3.3V_ALW on BOTTOM (solid shape): 224.89,79.19 224.89,76.27 224.76,76.14 223.88,76.14 223.88,76.65 223.81,76.71 223.05,76.71 223.05,76.14 222.73,76.14 222.73,76.71 221.84,76.71 221.84,76.14 220.94,76.14 220.64,76.45 220.64,78.93 220.95,79.25 224.83,79.25
+3.3V_ALW on BOTTOM (solid shape): 219.56,48.34 219.56,46.81 219.36,46.61 219.08,46.61 219.08,46.61 218.49,46.61 218.31,46.8 218.17,46.8 218.16,46.8 216.52,46.8 216.5,46.86 216.51,46.88 216.51,47.18 217.96,47.18 218.1,47.18 218.29,47.37 218.29,47.51 218.29,48.2 218.48,48.39 219.51,48.39
+3.3V_ALW on IN1 (solid shape): outline of 391 points within 81.29,91.52 102.76,94.46
+3.3V_ALW on IN1 (solid shape): outline of 850 points within 167.45,112.42 198.42,120.28
+3.3V_ALW on IN2 (solid shape): 268.35,72.38 268.35,72.14 268.34,72.13 268.34,71.22 268.54,71.02 270.47,71.02 270.61,71.16 270.61,72.77 270.8,72.96 271.75,72.96 271.82,72.9 271.82,69.41 271.74,69.33 271.68,69.38 271.69,69.41 271.35,69.81 270.98,69.44 270.95,69.36 270.88,69.33 268.74,69.33 268.73,69.37 268.39,69.64 268.04,69.37 268.03,69.33 267.18,69.33 266.71,69.8 266.71,72.79 266.77,72.89 266.8,72.99 266.8,73.04 267.69,73.04
+3.3V_ALW on IN2 (solid shape): outline of 726 points within 190.35,35.23 237.2,48.4
+3.3V_ALW on VCC: 274.34,39.69 267.48,46.55 255.29,46.55 253.66,48.18 253.66,49.83 253,50.49 245.8,50.49 244.39,49.07 244.39,46.42 223.28,46.42 215.05,54.65 215.05,84.29 215.41,84.65 216.42,84.65 217.46,85.69 217.46,87.21 217.82,87.57 223.71,87.57 224.45,86.83 224.45,62.15 222.92,60.62 222.92,55.21 223.58,54.55 236.49,54.55 241.72,59.78 241.72,76.41 244.64,79.34 244.64,82.59 244.01,83.23 244.01,87.21 244.62,87.82 247.92,87.82 251.22,91.13 255.2,91.13 256.73,89.6 262.19,89.6 264.2,87.59 264.2,80.86 272.58,72.48 272.58,68.16 276.79,63.95 277.43,63.95 277.91,63.46 277.91,56.48 284.54,49.85 293.05,49.85 294.57,48.33 311.59,48.33 317.16,42.76 317.16,40.94 315.91,39.69
+3.3V_ALW2 on TOP (solid shape): 94.02,74.86 94.02,72.14 93.89,72.01 92.26,72.01 91.89,72.38 91.89,74.57 92.03,74.71 93.01,74.71 93.33,75.03 93.84,75.03
+3.3V_ALW_PCH on TOP (solid shape): 190.23,40.97 190.23,39.94 190.08,39.79 189.08,39.79 189.04,39.75 189.04,39.25 189.03,39.23 188.87,39.23 188.86,39.25 188.86,39.73 188.8,39.79 188.25,39.79 187.87,40.17 187.87,40.96 188.11,41.2 190,41.2
+3.3V_ALW_PCH on BOTTOM (solid shape): 189.52,48.17 189.52,47.65 189.84,47.34 190.42,47.34 190.45,47.31 190.45,46.8 190.23,46.59 187.81,46.59 187.66,46.74 187.66,48.59 187.76,48.69 189,48.69
+3.3V_ALW_PCH on BOTTOM (solid shape): outline of 233 points within 171.13,34.58 190.33,41.28
+3.3V_ALW_PCH on IN3 (solid shape): outline of 1868 points within 180,40.36 193.31,62.82
+3.3V_ALW_PCH_UZ8 on TOP (solid shape): 188.71,39.61 188.71,39.12 188.75,39.08 189.14,39.08 189.19,39.13 189.19,39.61 189.23,39.65 189.47,39.65 189.69,39.44 189.69,38.79 188.75,37.85 187.54,37.85 187.1,37.41 187.1,36.61 186.97,36.48 186.42,36.48 186.35,36.55 186.35,38.2 186.82,38.67 186.82,39.11 186.94,39.23 187.49,39.23 187.91,39.65 188.67,39.65
+3.3V_ALW_UE1 on TOP (solid shape): 249.35,85.5 249.35,83.15 249.25,83.05 248.69,83.05 248.6,83.14 248.6,83.61 248.48,83.73 247.94,83.73 247.71,83.51 247.69,83.51 247.69,83.12 247.56,83 246.55,83 246.42,83.12 246.42,83.61 246.29,83.73 245.78,83.73 245.73,83.78 245.73,84.38 245.88,84.53 245.88,85.66 245.85,85.7 245.35,85.7 245.33,85.73 245.33,85.85 245.35,85.88 245.85,85.88 245.88,85.92 245.88,86.25 245.94,86.3 248.55,86.3
+3.3V_ALW_UE1 on IN2 (solid shape): outline of 420 points within 244.07,76.97 247.88,84.38
+3.3V_ALW_UE1 on IN4 (solid shape): outline of 336 points within 250.19,71.71 255.09,77.8
+3.3V_ALW_UE2 on TOP (solid shape): 266.31,60.99 266.31,59.83 266.22,59.74 265.26,59.74 265.16,59.84 265.16,60.3 264.86,60.61 263.03,60.61 262.94,60.7 262.94,60.84 263,60.9 264.5,60.9 264.68,61.08 266.22,61.08
+3.3V_ALW_UE2 on TOP (solid shape): 248.69,64.39 249.22,64.39 249.25,64.37 249.25,63.83 248.91,63.49 246.33,63.49 246.27,63.55 246.27,63.95 246.23,63.99 245.73,63.99 245.71,64.01 245.71,64.14 245.73,64.16 246.2,64.16 246.27,64.23 246.27,64.65 246.34,64.72 246.56,64.72 246.74,64.54 247.18,64.54 247.42,64.79 248.3,64.79
+3.3V_ALW_UE2 on IN2 (solid shape): outline of 1426 points within 247.36,54.36 266.26,67.33
+3.3V_ALWP on BOTTOM (solid shape): 220.26,79.57 220.26,76.65 220.95,75.95 222.1,75.95 222.1,76.52 222.42,76.52 222.42,75.95 223.24,75.95 223.24,76.52 223.62,76.52 223.62,75.95 224.57,75.95 224.64,75.89 224.64,73.6 224.26,73.22 219.11,73.22 218.86,73.47 218.78,73.47 216.19,73.47 213.91,73.47 211.37,76.01 207.68,76.01 207.56,76.14 207.56,79.06 207.9,79.4 208.25,79.4 209.05,80.2 219.62,80.2
+3.3V_CAM on TOP (solid shape): 96.32,99.57 96.32,97.31 96.05,97.04 95.02,97.04 94.89,97.17 94.89,99.23 95.5,99.84 96.05,99.84
+3.3V_HDD on TOP (solid shape): 306.95,51.54 306.95,48.36 306.83,48.24 305.88,48.24 305.74,48.38 305.74,48.96 305.17,48.96 305.17,49.13 305.74,49.13 305.74,50.27 305.75,50.28 305.75,51.51 305.83,51.6 306.9,51.6
+3.3V_HDD on BOTTOM (solid shape): 307.9,42.26 307.9,41.86 307.64,41.61 307.64,40.48 307.59,40.43 306.9,40.43 306.87,40.45 306.87,41.68 306.67,41.89 306.67,42.23 306.74,42.31 307.85,42.31
+3.3V_HDD on BOTTOM (solid shape): 294.51,37.8 294.51,37.33 294.59,37.25 295.39,37.25 295.82,37.68 296.43,37.68 296.65,37.47 296.65,35.88 296.43,35.66 294.91,35.66 294.82,35.75 294.82,36.16 294.65,36.32 293.95,36.32 293.79,36.49 293.79,37.15 293.9,37.26 294.28,37.26 294.34,37.32 294.34,37.75 294.41,37.82 294.49,37.82
+3.3V_HDD on IN1 (solid shape): outline of 474 points within 294.04,50.88 307.62,55.33
+3.3V_HDD on IN2 (solid shape): 307.92,51.39 307.92,41.85 307.64,41.57 306.58,41.57 306.32,41.82 306.32,49.96 305.79,50.5 305.79,51.59 305.9,51.7 307.61,51.7
+3.3V_HDD on IN4 (solid shape): outline of 1097 points within 290.61,35.77 308.01,61.3
+3.3V_LAN on TOP (solid shape): 286.3,81.8 287.03,81.8 287.25,81.59 287.25,80.24 287.03,80.02 285.96,80.02 285.95,80.01 285.09,80.01 284.99,80.11 284.99,82.22 285.15,82.39 285.71,82.39
+3.3V_LAN on TOP (solid shape): 268.73,89.99 268.73,89.23 268.41,88.92 267.84,88.92 267.56,88.63 266.93,88.63 266.67,88.88 266.67,89.47 267.32,90.12 268.61,90.12
+3.3V_LAN on TOP (solid shape): 290.16,108.32 290.16,104.24 290.11,104.19 288.56,104.19 288.11,104.64 288.11,108.4 288.54,108.83 289.65,108.83
+3.3V_LAN on TOP (solid shape): 272.41,78.43 272.41,78.42 273.73,77.1 274.11,77.1 274.38,76.83 274.38,75.63 274.35,75.61 274.14,75.61 274.09,75.66 274.09,76.13 274.07,76.15 273.56,76.15 273.55,76.14 273.55,75.64 273.51,75.61 273.33,75.61 273.3,75.63 273.3,76.14 273.29,76.15 272.77,76.15 272.76,76.16 272.73,76.13 272.73,75.81 272.75,75.8 272.75,75.64 272.69,75.59 272.42,75.59 272.32,75.69 272.32,75.92 272.25,75.99 272.24,75.99 269.63,78.59 268.96,78.59 268.82,78.73 268.82,79.94 268.88,80 270.83,80
+3.3V_LAN on BOTTOM (solid shape): outline of 860 points within 239.61,97.56 251.74,108.66
+3.3V_LAN on IN2 (solid shape): 252.82,105.78 252.82,105.29 252.62,105.08 250.8,105.08 250.42,105.46 250.42,105.84 250.67,106.1 252.5,106.1
+3.3V_LAN on IN2 (solid shape): outline of 108 points within 285.5,79.97 290.25,88.14
+3.3V_LAN on IN3 (solid shape): outline of 106 points within 287.57,87.06 292.77,105.98
+3.3V_LAN on IN3 (solid shape): outline of 399 points within 264.76,78.53 286.12,92.87
+3.3V_LAN_OUT on TOP (solid shape): 270.83,89.93 270.83,88.38 270.7,88.25 269.47,88.25 269.3,88.42 269.3,89.99 269.37,90.06 270.7,90.06
+3.3V_LAN_OUT on TOP (solid shape): 273.86,88.7 273.86,87.84 274.47,87.23 274.47,87.2 274.64,87.04 276.17,87.04 276.26,86.95 276.26,86.49 276.19,86.41 274.24,86.41 273.47,87.19 273.47,87.2 273.37,87.3 273.37,87.96 273.15,88.18 272.52,88.18 272.45,88.24 272.45,89.03 272.52,89.09 273.47,89.09
+3.3V_LAN_OUT on IN3 (solid shape): outline of 176 points within 269.35,80.18 282.85,88.79
+3.3V_LAN_UZ2 on TOP (solid shape): 273.14,75.99 273.14,75.45 273.16,75.43 273.64,75.43 273.69,75.48 273.69,75.96 273.71,75.99 273.91,75.99 273.94,75.96 273.94,75.47 273.96,75.45 274.4,75.45 274.4,73.65 274.4,73.18 274.28,73.06 272.65,73.06 272.55,73.15 272.55,73.59 272.5,73.65 270.46,73.65 270.23,73.88 270.23,74.49 270.09,74.63 269.52,74.63 269.47,74.68 269.47,75.34 269.7,75.57 271.74,75.57 271.89,75.42 272.34,75.42 272.36,75.44 272.86,75.44 272.9,75.48 272.9,75.99 272.91,76 273.13,76
+3.3V_M on TOP (solid shape): 195.12,56.12 195.12,55.63 195.16,55.59 195.57,55.59 195.61,55.63 195.61,56.1 195.66,56.15 195.88,56.15 196.15,55.88 196.15,54.26 195.15,53.25 194.49,53.25 194.34,53.41 194.34,54.02 194.55,54.23 194.55,56.03 194.67,56.15 195.1,56.15
+3.3V_M on TOP (solid shape): 184.53,40.99 184.53,40.48 184.38,40.33 183.69,40.33 183.64,40.27 183.64,39.65 183.62,39.63 182.64,39.63 182.38,39.37 181.46,39.37 181.24,39.59 181.24,40.69 181.47,40.92 181.84,40.92 181.85,40.93 183.29,40.93 183.52,41.16 184.35,41.16
+3.3V_M_TPM on TOP (solid shape): outline of 128 points within 192.51,54.23 195.87,57.3
+3.3V_M_UZ8 on TOP (solid shape): 184.4,39.17 184.4,37.86 184.95,37.32 184.95,36.57 184.91,36.53 182.85,36.53 182.41,36.97 182.41,38.86 182.52,38.98 183.52,38.98 183.77,39.23 184.34,39.23
+3.3V_MMI on TOP (solid shape): 305.52,60.14 305.52,59.31 305.36,59.15 304.25,59.15 304.17,59.24 304.17,60.21 304.24,60.29 305.37,60.29
+3.3V_MMI on TOP (solid shape): 315.98,63.21 315.98,62.5 315.67,62.19 315.43,62.19 315.3,62.07 315.3,61.41 315.28,61.38 314.83,61.38 314.69,61.52 314.69,63.19 314.82,63.31 315.87,63.31
+3.3V_MMI on TOP (solid shape): 311.56,61.18 311.56,60.24 312.22,59.58 312.22,57.84 312.04,57.66 311.4,57.66 311.32,57.75 311.32,58.21 310.91,58.61 310.91,59.07 311.37,59.53 311.37,61.17 311.42,61.22 311.52,61.22
+3.3V_MMI on TOP (solid shape): 306.65,57.51 307.22,57.51 307.4,57.33 307.4,56.18 308.44,55.14 308.44,54.27 308.28,54.11 308.01,54.11 308.01,54.67 307.99,54.7 307.47,54.7 307.44,54.67 307.44,54.11 307.22,54.11 307.22,54.7 307.2,54.71 306.65,54.71 306.63,54.7 306.63,54.11 306.27,54.11 305.97,54.41 305.97,57.33 306.24,57.6 306.55,57.6 306.56,57.6
+3.3V_MMI on IN1 (solid shape): outline of 640 points within 303.64,56.14 318.29,64.43
+3.3V_RUN on TOP (solid shape): 174.59,89.6 174.59,88.51 174.38,88.31 173.16,88.31 173.06,88.41 173.06,88.66 173.13,88.72 173.56,88.72 173.62,88.79 173.62,89.14 173.56,89.21 173.13,89.21 173.06,89.27 173.06,89.63 173.14,89.7 174.49,89.7
+3.3V_RUN on TOP (solid shape): 305.71,54.46 306.22,53.95 308.21,53.95 308.22,53.94 308.83,53.94 308.94,53.83 308.94,52.39 308.77,52.22 305.67,52.22 305.01,52.87 304.34,52.87 304.29,52.92 304.29,55.02 304.86,55.59 305.71,55.59
+3.3V_RUN on TOP (solid shape): 238.04,32.77 238.04,31.05 237.91,30.93 236.69,30.93 236.56,31.05 236.56,31.54 236.6,31.57 237.08,31.57 237.13,31.63 237.13,32.01 237.08,32.06 236.61,32.06 236.56,32.11 236.56,32.6 236.92,32.96 237.85,32.96
+3.3V_RUN on TOP (solid shape): 223.49,96.46 223.49,92.97 223.3,92.78 222.67,92.78 222.67,93.28 221.84,93.28 221.84,92.78 221.46,92.78 221.46,93.28 220.64,93.28 220.64,92.71 219.36,92.71 219.14,92.94 219.14,94.6 218.58,95.15 218.58,96.39 218.84,96.65 223.3,96.65
+3.3V_RUN on TOP (solid shape): 240.36,15.97 240.36,15.12 240.27,15.03 239.83,15.03 239.51,15.34 238.63,15.34 238.34,15.64 236.66,15.64 236.6,15.69 236.6,15.89 236.66,15.95 239.02,15.95 239.41,16.33 239.99,16.33
+3.3V_RUN on TOP (solid shape): 94.48,101.96 95.1,101.96 95.46,101.6 95.93,101.6 96.14,101.39 96.14,100.59 96.46,100.27 97.18,100.27 97.43,100.02 97.43,98.52 97.23,98.31 96.72,98.31 96.51,98.53 96.51,99.6 96.06,100.04 93.93,100.04 93.08,100.89 93.08,102.17 93.17,102.26 94.17,102.26
