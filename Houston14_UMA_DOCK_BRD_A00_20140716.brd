# Allegro board Houston14_UMA_DOCK_BRD_A00_20140716.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_B_MA15: length 99.7
  IN4 w0.086: 139.71,40.92 140.03,41.24 140.03,43.53 140.47,43.96 140.47,45.35 139.95,45.86 139.95,49.23 140.53,49.81 140.75,49.81 141.1,50.16 141.1,50.76 v1(140.69,51.17)
  IN4 w0.145: v1(189.47,5.64) 189.47,5.76 189.9,6.19 189.9,9.66 189.67,9.89 189.27,9.89 188.79,10.37 164.12,10.37 163.99,10.24 163.99,9.57 163.86,9.44 163.4,9.44 163.27,9.57 163.27,10.24 163.14,10.37 162.71,10.37 162.19,10.88 161.99,10.88 161.42,10.32 161.25,10.32 160.91,10.65 160.91,10.83 161.48,11.39 161.48,11.6 161.2,11.88 160.99,11.88 160.41,11.3 160.21,11.3 159.9,11.6 159.9,11.81 160.48,12.39 160.48,12.59 160.14,12.94 159.93,12.94 159.33,12.34 159.13,12.34 158.82,12.65 158.82,12.85 159.42,13.45 159.42,13.65 159.11,13.96 158.91,13.96 158.31,13.36 158.11,13.36 157.8,13.67 157.8,13.88 158.4,14.47 158.4,14.68 158.09,14.99 157.88,14.99 157.29,14.39 157.08,14.39 156.77,14.69 156.77,14.9 157.37,15.5 157.37,15.7 157.06,16.01 156.86,16.01 156.26,15.41 156.06,15.41 139.26,32.21 139.26,40.33 139.71,40.77 139.71,40.92
  BOTTOM w0.076: UC1.AP46 140.99,51.17 v1(140.69,51.17)
  BOTTOM w0.168: JDIMM2.78 190.46,4.18 190.35,4.29 190.35,4.77 v1(189.47,5.64)
DDR_B_RAS#: length 101.6
  IN4 w0.086: v1(147.86,52.34) 147.49,51.96 147.49,50.12 147.94,49.66 147.94,41.83 148.61,41.17 148.61,40.92
  IN4 w0.145: 148.61,40.92 148.61,36.07 162,22.68 163.3,22.68 163.42,22.56 163.42,21.37 163.55,21.25 164.02,21.25 164.17,21.39 164.17,22.59 164.31,22.73 164.75,22.73 164.89,22.59 164.89,21.39 165.04,21.25 165.47,21.25 165.62,21.39 165.62,22.59 165.76,22.73 166.2,22.73 166.34,22.59 166.34,21.39 166.48,21.25 166.92,21.25 167.06,21.39 167.06,21.88 167.19,22.01 167.66,22.01 167.79,21.88 167.79,21.39 167.93,21.25 180.14,21.25 180.29,21.1 180.29,20.65 180.43,20.51 180.87,20.51 181.01,20.65 181.01,21.1 181.16,21.25 181.65,21.25 181.82,21.08 181.82,19.75 182.01,19.56 182.37,19.56 182.5,19.69 182.5,20.15 182.63,20.27 183.02,20.27 183.15,20.15 183.15,19.69 183.27,19.56 193.66,19.56 199.14,14.08 199.14,13.79 199.27,13.67 199.55,13.67 199.73,13.48 199.73,13.21 199.63,13.11 199.42,13.11 199.29,12.98 199.29,12.66 199.42,12.54 199.58,12.54 199.73,12.38 199.73,12.22 202.25,9.7 202.25,7.34 202.07,7.17 v1(201.82,7.17)
  BOTTOM w0.076: UC1.AM35 148.19,52.67 v1(147.86,52.34)
  BOTTOM w0.168: JDIMM2.110 200.06,4.18 200.53,4.64 200.53,5.09 201.06,5.62 201.06,6.82 201.4,7.17 v1(201.82,7.17)
DDR_B_WE#: length 101
  IN4 w0.086: 148.18,40.92 148.18,41.28 147.76,41.7 147.76,49.14 147.31,49.6 147.31,53.11 v1(147.84,53.64)
  IN4 w0.145: 148.18,40.92 148.18,35.9 163.26,20.82 163.75,20.82 163.88,20.7 163.88,20.2 164,20.08 164.39,20.08 164.53,20.23 164.53,20.7 164.66,20.82 165.13,20.82 165.25,20.7 165.25,20.23 165.4,20.08 165.83,20.08 165.98,20.23 165.98,20.7 166.11,20.82 166.58,20.82 166.7,20.7 166.7,20.23 166.85,20.08 167.28,20.08 167.43,20.23 167.43,20.7 167.55,20.82 168.02,20.82 168.15,20.7 168.15,20.21 168.28,20.08 168.75,20.08 168.87,20.21 168.87,20.7 169,20.82 169.47,20.82 169.6,20.7 169.6,20.23 169.74,20.08 170.18,20.08 170.32,20.23 170.32,20.7 170.45,20.82 170.92,20.82 171.05,20.7 171.05,20.23 171.19,20.08 171.63,20.08 171.77,20.23 171.77,20.7 171.9,20.82 172.37,20.82 172.49,20.7 172.49,20.23 172.64,20.08 173.07,20.08 173.22,20.23 173.22,20.7 173.34,20.82 173.81,20.82 173.94,20.7 173.94,20.23 174.09,20.08 174.5,20.08 174.65,20.23 174.65,20.7 174.77,20.82 175.24,20.82 175.37,20.7 175.37,20.23 175.51,20.08 175.95,20.08 176.09,20.23 176.09,20.7 176.22,20.82 176.69,20.82 176.82,20.7 176.82,20.23 176.96,20.08 177.4,20.08 177.54,20.23 177.54,20.7 177.67,20.82 178.14,20.82 178.26,20.7 178.26,20.23 178.41,20.08 178.84,20.08 178.99,20.23 178.99,20.65 179.12,20.78 179.59,20.78 179.71,20.65 179.71,20.23 179.86,20.08 180.89,20.08 181.83,19.14 193.48,19.14 198.71,13.91 198.71,12.62 201.27,10.05 201.27,9.24 v1(201.82,8.69)
  BOTTOM w0.076: v1(147.84,53.64) 148.17,53.97 UC1.AK35
  BOTTOM w0.168: JDIMM2.113 200.96,9.55 v1(201.82,8.69)
DDR_CKE0_DIMMA: length 61.7
  IN1 w0.086: 138.87,40.92 138.87,41.8 139.17,42.1 139.17,42.15 142.67,45.64 142.67,48.85 v1(142.26,49.26)
  IN1 w0.145: v1(112.21,7.11) 111.98,7.11 111.78,7.31 111.78,11.77 111.98,11.97 111.98,13.12 119.23,20.37 120.38,20.37 138.87,38.86 138.87,40.92
  BOTTOM w0.076: UC1.AU43 142.41,49.26 v1(142.26,49.26)
  BOTTOM w0.168: JDIMM1.73 112.96,10.5 112.59,10.12 112.31,10.12 111.77,9.58 111.77,7.55 v1(112.21,7.11)
DDR_CKE1_DIMMA: length 59.8
  IN1 w0.086: 138.4,40.92 138.4,41.66 141.67,44.93 141.67,47.38 v1(142.25,47.96)
  IN1 w0.145: 138.4,40.92 138.4,38.99 120.28,20.87 119.13,20.87 111.55,13.29 111.55,12.14 111.35,11.94 111.35,6.18 111.92,5.6 v1(112.2,5.6)
  BOTTOM w0.076: UC1.AW43 142.55,48.26 v1(142.25,47.96)
  BOTTOM w0.168: JDIMM1.74 113.26,4.12 112.98,4.4 112.98,4.82 v1(112.2,5.6)
DDR_CKE2_DIMMB: length 85
  IN4 w0.086: 138.33,40.92 139.55,42.14 139.55,43.7 139.61,43.76 v1(139.61,44.53)
  IN4 w0.145: v1(188.07,8.69) 186.51,7.13 186.51,4.85 185.81,4.15 164.04,4.15 158.32,9.88 158.32,11.62 138.19,31.75 138.19,40.77 138.33,40.92
  BOTTOM w0.089: v1(139.61,44.53) 139.51,44.63 139.51,47.6 UC1.AY49
  BOTTOM w0.168: v1(188.07,8.69) 188.96,9.58 JDIMM2.73
DDR_CKE3_DIMMB: length 85.6
  IN4 w0.086: 137.76,40.92 137.76,40.95 139.14,42.33 139.14,43.69 139.15,43.69 v1(139.15,44.07)
  IN4 w0.145: v1(188.07,5.64) 186.15,3.72 163.87,3.72 157.83,9.76 157.83,11.51 138.01,31.33 137.76,31.58 137.76,40.92
  BOTTOM w0.076: v1(139.15,44.07) 139.15,46.26 138.35,47.07 138.35,49.33 UC1.AU50
  BOTTOM w0.168: JDIMM2.74 189.26,4.46 v1(188.07,5.64)
DDR_CS0_DIMMA#: length 61.5
  IN1 w0.086: v1(148.82,51.11) 149.29,50.63 149.29,49.78 150.07,49 150.07,41.77 150.82,41.02 150.82,38.35
  IN1 w0.145: v1(126.02,5.64) 127.2,5.64 128.96,7.41 128.96,9.7 129.4,10.15 130.8,10.15 133.83,13.18 133.83,13.59 135.17,14.92 135.17,17.23 150.82,32.88 150.82,38.35
  BOTTOM w0.076: v1(148.82,51.11) 149.08,51.37 UC1.AP33
  BOTTOM w0.168: JDIMM1.114 125.26,4.13 125.58,4.45 125.58,5.2 v1(126.02,5.64)
DDR_CS1_DIMMA#: length 63.5
  IN1 w0.086: 151.24,38.35 151.24,39.66 151.07,39.83 151.07,41.02 150.24,41.85 150.24,49.14 149.71,49.67 v1(149.71,50.39)
  IN1 w0.145: 151.24,38.35 151.24,32.71 137.95,19.41 137.95,19.21 138.61,18.55 138.61,18.37 138.38,18.14 138.2,18.14 137.54,18.8 137.33,18.8 137.13,18.59 137.13,18.39 138.22,17.3 138.22,17.09 138.02,16.89 137.81,16.89 136.72,17.98 136.52,17.98 136.23,17.7 136.23,17.21 137.04,16.4 137.04,16.2 136.83,15.99 136.63,15.99 136.21,16.41 136,16.41 135.8,16.21 135.8,16.01 136.22,15.58 136.22,15.38 134.26,13.42 134.26,13 129.95,8.69 v1(129.44,8.69)
  BOTTOM w0.076: UC1.AR32 150.03,50.72 v1(149.71,50.39)
  BOTTOM w0.168: JDIMM1.121 127.36,10.37 127.83,9.91 128.05,9.91 v1(129.44,8.69)
DDR_CS2_DIMMB#: length 91.7
  IN4 w0.086: 150.57,38.35 150.57,39.73 150.38,39.91 150.38,41.2 149.87,41.71 149.87,44.52 150.08,44.72 150.08,51.87 149.7,52.25 v1(149.7,52.25)
  IN4 w0.145: 150.57,38.35 150.57,36.87 162.78,24.66 171.96,24.66 173.45,23.17 190.22,23.17 191.21,22.18 193.13,22.18 193.58,21.73 194.83,21.73 198.88,17.69 198.88,17.07 202.13,13.82 202.13,12.73 204.63,10.23 204.63,6.73 v1(203.55,5.64)
  BOTTOM w0.076: UC1.AM32 150.11,52.67 149.7,52.25 v1(149.7,52.25)
  BOTTOM w0.168: JDIMM2.114 201.26,4.3 202.61,5.64 v1(203.55,5.64)
DDR_CS3_DIMMB#: length 90.6
  IN4 w0.086: v1(149.75,53.64) 150.26,53.12 150.26,44.58 150.1,44.41 150.1,41.75 150.57,41.28 150.57,40.01 151.05,39.54 151.05,38.35
  IN4 w0.145: 151.05,38.35 151.05,36.99 162.95,25.08 172.14,25.08 173.62,23.6 190.39,23.6 191.38,22.61 193.31,22.61 193.76,22.16 195.01,22.16 199.41,17.76 199.41,17.14 202.56,13.99 202.56,12.93 205.88,9.6 205.88,8.5 205.74,8.36 205.5,8.36 v1(205.16,8.69)
  BOTTOM w0.076: v1(149.75,53.64) 150.07,53.97 UC1.AK32
  BOTTOM w0.168: JDIMM2.121 203.36,10.23 203.53,10.06 203.8,10.06 v1(205.16,8.69)
DDR_PG_CTRL: length 83.8
  TOP w0.102: v1(143.18,5.7) 143.18,4.82 144.03,3.96 144.03,3.32 143.83,3.11 UD1.2 ; v1(118.34,39.06) v2(117.51,39.06)
  IN2 w0.122: v1(143.18,5.7) 142.47,6.42 142.47,9.95 140.98,11.43 117.37,11.43 114.27,14.53 114.27,34.48 118.34,38.55 v1(118.34,39.06)
  BOTTOM w0.076: 129.82,49.23 130.85,49.23 130.89,49.27 131.6,49.27 UC1.AV61
  BOTTOM w0.102: 129.82,49.23 127.22,46.62 126.1,46.62 121.93,42.45 121.93,40.97 120.02,39.06 v1(118.34,39.06)
DDR_XDP_WAN_SMBCLK: length 420.7
  TOP w0.102: RN4.2 287.82,61.72 284.34,65.2 276.12,65.2 276.01,65.09 275.5,65.09 275.39,65.2 274.73,65.2 274.18,65.75 274.18,66.87 273.65,67.4 273.65,68.2 273.25,68.6 270.44,68.6 269.46,69.59 269.46,69.66 268.82,70.3 267.47,70.3 267.4,70.3 265.26,72.43 265.26,72.51 265.26,80.34 264.77,80.84 264.77,83.91 264.4,84.28 264.4,84.31 264.02,84.68 264,84.68 v1(263.97,84.71) ; v1(176.35,63.08) 176.69,63.42 QC1.1 ; v1(91.27,22.84) 91.3,22.84 91.99,23.53 JXDP1.53 ; v1(194.46,42.67) 194.46,47.98 197.85,51.37 197.85,52.25 197.85,52.25 197.85,55.45 199.3,56.9 199.3,62.77 198.49,63.59 198.49,66.76 197.39,67.86 196.82,67.86 196.19,68.5 195.7,68.5 v1(194.83,69.37)
  TOP w0.305: UN1.4 287.57,59.24 RN4.2
  IN1 w0.089: v1(194.25,40.1) 194.14,40.2 194.14,42.38 194.44,42.67 v1(194.46,42.67) ; v1(91.27,22.84) 91.79,22.84 92.48,22.15 92.48,19.36 86.14,13.02 86.14,9.2 85.03,8.08 85.03,5.75 87.3,3.48 101.43,3.48 101.85,3.06 111.16,3.06 111.64,2.58 125.2,2.58 125.25,2.54 125.4,2.69 150.48,2.69 152.98,5.19 152.98,5.95 v1(153.15,6.11) 153.56,5.7 159.41,5.7 162.83,2.29 227.23,2.29 v1(227.75,1.77) ; v1(176.35,63.08) 175.2,64.24 175.2,65.57 175.84,66.22 177.1,66.22 178.18,65.14 179.16,65.14 179.64,65.62 179.64,66.44 182.75,69.55 183.82,69.55 186.3,72.02 191.21,72.02 193.87,69.37 v1(194.83,69.37) 194.91,69.45 194.91,70.36 204.97,80.43 215.48,80.43 216.5,81.46 220.07,81.46 221.13,80.39 234.85,80.39 234.85,80.39 237.14,80.39 237.93,81.18 241.41,81.18 241.62,80.97 243.12,80.97 246.48,84.33 250.57,84.33 256.23,84.33 256.84,84.94 261.24,84.94 261.68,85.38 263.3,85.38 v1(263.97,84.71)
  IN4 w0.089: v1(227.75,1.77) 227.75,2.49 228.28,3.03 228.28,14.77 211.15,31.9 208.96,31.9 201.15,39.72 198.98,39.72 198.79,39.91 194.44,39.91 v1(194.25,40.1)
  BOTTOM w0.102: JDIMM2.202 227.66,1.86 v1(227.75,1.77) ; v1(153.15,6.11) 152.55,5.51 151.94,5.51 151.66,5.23 JDIMM1.202
DDR_XDP_WAN_SMBDAT: length 416.2
  TOP w0.102: v1(92.06,24.07) 92.11,24.03 JXDP1.51 ; RN3.2 282.4,64.72 276.32,64.72 276.21,64.61 275.3,64.61 275.19,64.72 274.45,64.72 273.02,66.14 273.02,67.62 272.68,67.97 269.81,67.97 268.95,68.82 268.95,69.48 268.62,69.81 267.67,69.81 267.27,69.81 267.2,69.81 264.78,72.23 264.78,72.71 264.78,80.14 264.29,80.64 264.29,83.71 263.92,84.08 263.92,84.11 263.68,84.34 263.66,84.34 263.49,84.51 263.49,84.57 v1(263.39,84.67) ; v1(194.84,68.57) 195.4,68.01 195.99,68.01 196.62,67.38 197.19,67.38 198.01,66.56 198.01,63.39 198.82,62.57 198.82,57.1 197.37,55.65 197.37,52.45 197.37,52.45 197.37,51.57 193.98,48.19 193.98,43.91 v1(193.51,43.44) ; v1(175.74,65.37) 175.62,65.24 QC1.4
  TOP w0.254: UN1.6 285.27,61.83 RN3.2
  IN1 w0.089: v1(193.51,43.44) 193.37,43.3 193.37,40.13 v1(193.47,40.03) ; v1(175.74,65.37) 176.12,65.75 176.91,65.75 177.99,64.67 179.35,64.67 180.11,65.43 180.11,66.24 182.95,69.08 184.01,69.08 186.46,71.53 190.92,71.53 193.88,68.57 v1(194.84,68.57) 195.38,69.1 195.38,70.17 205.17,79.96 215.68,79.96 216.7,80.99 219.88,80.99 220.94,79.92 234.65,79.92 234.66,79.92 237.33,79.92 238.12,80.71 241.21,80.71 241.43,80.5 243.31,80.5 246.68,83.86 250.38,83.86 256.43,83.86 257.04,84.47 261.43,84.47 261.83,84.87 263.19,84.87 v1(263.39,84.67) ; v1(226.81,1.7) 227.18,1.34 227.98,1.34 228.22,1.57 228.22,1.96 227.42,2.76 163.02,2.76 159.61,6.17 153.75,6.17 153.48,6.44 153.4,6.53 152.74,6.53 v1(152.4,6.19) 152.51,6.07 152.51,5.39 150.29,3.16 125.2,3.16 125.09,3.05 111.84,3.05 111.35,3.53 102.05,3.53 101.63,3.95 87.49,3.95 87.13,4.31 85.5,5.95 85.5,7.89 86.61,9.01 86.61,12.83 92.95,19.16 92.95,22.34 92.06,23.23 v1(92.06,24.07)
  IN4 w0.089: v1(193.47,40.03) 193.52,40.03 194.05,40.57 194.44,40.57 194.63,40.38 198.98,40.38 199.17,40.19 201.34,40.19 209.07,32.46 211.34,32.46 228.83,14.98 228.83,2.58 228.27,2.02 228.27,1.62 227.98,1.32 227.09,1.32 226.81,1.6 v1(226.81,1.7)
  BOTTOM w0.102: JDIMM2.200 227.06,1.96 v1(226.81,1.7) ; v1(152.4,6.19) 151.83,6.19 151.06,5.42 JDIMM1.200
DEW1: length 4.5
  TOP w0.102: RN21.2 RN20.2 v2(296.95,61.06) 296.95,60.69 296.44,60.18 UN2.16
DEW2: length 4.9
  TOP w0.102: v2(292.01,54.68) 292.01,53.74 RN19.2 RN18.2 294.44,54.9 UN2.6
DGPU_PWROK: length 26.1
  IN4 w0.086: v1(166.57,62.46) 166.57,62.79 167.07,63.29 168.73,63.29 169.24,63.79 171.77,63.79
  IN4 w0.089: v1(186.98,61.13) 186.16,61.95 185.62,61.95 184.45,63.11 184.45,63.89 183.15,65.2 180.72,65.2 180.37,64.86 177.49,64.86 176.83,64.2 174.06,64.2 173.65,63.79 171.77,63.79
  BOTTOM w0.076: UC1.P4 166.8,62.23 v1(166.57,62.46)
  BOTTOM w0.102: v2(186.32,60.57) 186.47,60.57 186.98,61.07 v1(186.98,61.13) 187.04,61.13 187.13,61.04 RPC18.5
DH_1.35V: length 3.6
  IN1 w1.016: 254.83,36.29 253.5,37.61 253.48,37.61
  BOTTOM w0.102: v2(250.66,39.54) 250.88,39.54 v3(251.93,38.48)
  vias: v3(251.96,37.85) v3(255.71,36.24) v3(256.32,36.49)
DIMM_DET: length 8.6
  TOP w0.076: v1(166.56,60.58) v2(167.7,60.58) 170.14,60.58 170.35,60.78 171.77,60.78
  TOP w0.102: RC302.2 173.02,61.28 RC303.1 172.5,60.78 171.77,60.78
  BOTTOM w0.076: UC1.U4 166.71,60.73 v1(166.56,60.58)
DIS_BAT_PROCHOT#: length 258.3
  TOP w0.102: v1(86.74,49.15) 86.74,48.67 v2(86.4,48.33) ; v1(258.71,73.84) 258.71,74.2 258.42,74.49 UE1.B51
  IN3 w0.122: v1(86.74,49.15) 86.84,49.05 86.84,36.1 90.63,32.31 98.29,32.31 99.12,31.48 103.99,31.48 105.51,29.96 119.22,29.96 119.26,29.99 196.96,29.99 207.65,40.68 223,40.68 229.14,46.82 235.35,46.82 237.17,48.64 237.17,54.12 239.17,56.12 239.17,63.53 244.82,69.18 245.32,69.18 250.39,74.25 258.31,74.25 v1(258.71,73.84)
  BOTTOM w0.254: v1(86.74,49.15) 86.69,49.2 85.03,49.2 83.63,50.6 83.63,54.97 79.79,58.8 79.79,60.89 74.4,66.28 74.4,73.52 72.8,75.12 64.81,75.12 64.08,75.85 PR812.1
DISP_ON: length 4.6
  BOTTOM w0.102: JEDP1.22 90.89,99 RV2.1 89.77,98.38 89.48,98.67 v2(89.18,98.67) 88.78,98.27 DV2.1
DK_AC_OFF: length 76
  TOP w0.102: v3(101,53.03) v2(101,53.79)
  TOP w0.254: PD815.3 v1(56.61,96.22)
  IN3 w0.254: v3(101,53.03) 100.14,53.03 98.21,54.96 98.21,58.7 93.95,62.96 89.95,62.96 89.38,63.53 79.77,63.53 79.75,63.54 79.38,63.54 74.84,68.07 74.84,72.49 72.23,75.1 69.33,75.1 68.11,76.32 68.11,77.63 68.11,81.5 66.03,83.58 64.74,83.58 61.76,86.57 61.21,86.57 57.68,90.1 57.68,95.15 v1(56.61,96.22)
  BOTTOM w0.254: v3(101,53.03) 101.4,53.42 PU800.25
DK_AC_OFF_EN: length 4.5
  BOTTOM w0.102: PR850.1 103.19,52.34 103.7,51.83 103.7,51.09 103.54,50.94 v2(103.54,50.26)
  BOTTOM w0.254: PU800.22 102.9,53.24 102.91,53.24 102.91,52.59 PR850.1
DK_CSS_GC: length 225.1
  TOP w0.102: v2(106.97,58.61) 106.46,59.12 v3(106.4,59.12)
  TOP w0.254: PR709.1 173.9,115.81 172.95,114.86 172.95,114.31 173.33,113.93 v1(173.5,113.93)
  IN3 w0.254: v1(173.5,113.93) 173.01,113.93 171.22,115.72 169.82,115.72 169.13,116.42 168.52,116.42 167.93,115.84 167.14,115.84 166.69,116.3 161.1,116.3 160.34,115.53 155.53,115.53 153.64,117.41 146.41,117.41 144.31,119.51 139.1,119.51 132.45,112.85 132.45,112.13 124.79,104.47 105.01,104.47 104.52,104.96 99.23,104.96 97.95,106.24 78.99,106.24 78.18,107.05 57.92,107.05 v1(56.64,105.77) ; v1(64.48,85.71) 65.36,84.83 66.22,84.83 69.13,81.93 69.13,79.03 69.79,78.37 71.43,78.37 71.93,77.87 71.93,76.83 75.86,72.91 75.86,69.67 77,68.53 77,67.78 80.14,64.63 90.11,64.63 90.64,64.1 95.35,64.1 100.05,59.4 106.12,59.4 v3(106.4,59.12)
  IN4 w0.254: v1(56.64,105.77) 55.87,106.54 53.37,106.54 52.67,105.84 52.67,100.31 54.09,98.88 54.09,88.94 56.57,86.46 62.87,86.46 63.62,85.71 v1(64.48,85.71)
  BOTTOM w0.254: v3(106.4,59.12) 106,58.72 PU800.11
DK_PWRBAR: length 3.3
  BOTTOM w0.254: PU800.33 v2(97.89,57.72) 96.99,58.61 PR832.1
DL_1.35V: length 9.3
  TOP w0.102: v2(257.47,36.13) 257.47,35.58 v3(257.54,35.5)
  IN4 w1.016: 256.96,33.92 256.04,33.92 254.01,31.89 249.49,31.89 249.24,31.64
  vias: v3(247.64,31.46) v3(248.32,31.44) v3(257.54,34.86)
DMIC0: length 88.8
  TOP w0.102: v1(29.86,90.57) 29.38,91.05 28.96,91.05 28.88,91.13 28.78,91.13 28.51,91.4 UA1.47
  IN2 w0.122: v1(29.86,90.57) 29.86,90.59 32.64,93.37 35.69,93.37 36.92,94.6 37.59,94.6 38.84,95.85 38.84,97.61 44.27,103.05 49.54,103.05 49.7,102.89 59.17,102.89 59.58,102.49 74.13,102.49 74.5,102.86 80.24,102.86 84.68,98.41 93.73,98.41 96.05,96.09 97.85,96.09 v1(99.31,94.63)
  BOTTOM w0.102: JEDP1.7 98.39,98.52 CA6.1 99.16,97.75 99.16,94.78 v1(99.31,94.63) 99.34,94.6 v2(99.34,93.69)
DMIC1: length 242.8
  TOP w0.102: v1(32.07,93.77) 32.02,93.72 30.66,93.72 30.57,93.81 UA1.4 ; v1(229.3,92.31) 229.16,92.45 229.16,96.84 229.98,97.67 v2(229.98,97.98) 229.98,99.7 235.06,104.78 238.9,104.78 241.29,107.17 242.14,107.17 246.1,111.13 MIC1.5
  IN3 w0.122: v1(229.3,92.31) 229.11,92.12 225.43,92.12 224.33,93.23 208.74,93.23 196.75,105.22 188,105.22 187.89,105.11 180.1,105.11 180.07,105.14 155.35,105.14 154.8,104.6 134.76,104.6 134.04,105.32 128.28,105.32 125.99,103.02 105.23,103.02 104.1,104.15 98.85,104.15 97.86,105.14 78.48,105.14 77.44,106.17 74.63,106.17 74.26,105.81 58.06,105.81 56.88,104.63 44.19,104.63 36.43,96.87 34.3,96.87 33.03,95.6 33.03,93.97 32.83,93.77 v1(32.07,93.77)
DMIC_CLK0: length 79.7
  TOP w0.102: v2(36.49,91.89) 36.49,92.45 CA54.1 35.38,93.03 v1(35.18,92.83) 34.98,93.03 RA14.2
  IN2 w0.122: v1(98.65,94.59) 97.47,95.77 95.97,95.77 93.64,98.11 84.58,98.11 82.7,99.99 75.17,99.99 74.16,101.01 65.92,101.01 65.37,100.45 60.78,100.45 60.02,99.69 50.36,99.69 49.28,98.61 47.14,98.61 40.78,92.26 36.35,92.26 35.78,92.83 v1(35.18,92.83)
  BOTTOM w0.102: v1(98.65,94.59) 98.11,95.14 98.11,97.78 CA5.1 97.39,98.5 JEDP1.9
DMIC_CLK1: length 241.7
  TOP w0.102: v1(228.99,99.24) v2(230.15,100.4) 234.96,105.21 238.85,105.21 241.03,107.39 241.92,107.39 244.58,110.05 MIC1.4 ; RA40.2 v1(35.06,94.05) CA30.1
  IN2 w0.122: v1(228.99,99.24) 228.71,98.96 226.05,98.96 223.72,101.3 202.02,101.3 199.02,104.3 198.76,104.3 196.59,106.46 183.25,106.46 182,107.71 180.7,107.71 178.03,110.38 176.48,110.38 175.15,111.72 175.15,112.33 174.27,113.21 173.56,113.21 171.2,115.57 170.73,115.57 169.22,117.08 160.67,117.08 159.98,116.39 156.12,116.39 154.08,114.34 153.07,114.34 151.94,113.22 151.94,112.2 149.61,109.87 147.49,109.87 145.57,107.95 128.48,107.95 124.81,104.28 111.73,104.28 110.02,105.98 105.69,105.98 103.33,108.35 91.54,108.35 90.68,107.49 79.07,107.49 78.53,108.03 71.46,108.03 71.3,107.87 53.48,107.87 52.93,107.32 52.76,107.32 51.94,106.5 v1(49.82,106.5)
  IN4 w0.089: v1(35.06,94.05) 39.28,98.26 39.28,102.83 40.04,103.6 40.04,104.31 41.03,105.3 48.62,105.3 v1(49.82,106.5)
DMIC_CLK_L: length 6.2
  TOP w0.102: RA14.1 33.29,93.11 32.61,93.11 32.05,92.55 30.59,92.55 30.13,93.01 UA1.2 ; RA14.1 RA40.1 ; RA14.1 33.69,92.7 v2(33.69,92.01)
DOCK_AC_OFF: length 116.4
  TOP w0.102: v1(54.9,95.48) 54.9,96.36 v2(54.55,96.71)
  TOP w0.254: PR844.1 54.19,94.6 54.39,94.81 PD815.1 54.76,95.34 v1(54.9,95.48)
  IN1 w0.089: v1(148.48,112.44) 148.48,112.38 147.99,111.9 147.99,111.89 146.76,110.65 145.89,110.65 144.35,109.11 127.86,109.11 124.71,105.97 123.3,105.97 122.9,105.57 106.79,105.57 106.2,106.16 101.8,106.16 101.45,106.52 101.45,107.18 100.28,108.35 98.18,108.35 96.98,107.14 76.86,107.14 74.28,104.56 71.91,104.56 67.92,100.57 59.99,100.57 v1(54.9,95.48)
  BOTTOM w0.102: JDOCK1.2 145.9,117.02 147.43,115.5 148.25,115.5 148.68,115.06 149.54,115.06 150.38,114.23 150.38,113.77 149.38,112.77 148.81,112.77 v1(148.48,112.44)
DOCK_AC_OFF_EC: length 326.2
  TOP w0.102: v1(93.31,60.06) 92.67,60.06 v2(92.62,60.01)
  TOP w0.254: UE1.A63 260.88,82.69 261.28,82.3 v1(261.28,82.15)
  IN2 w0.254: v3(103.11,50.7) 103.11,50.79 102.22,51.68 95.02,51.68 93.31,53.39 v1(93.31,60.06)
  IN3 w0.254: v1(261.28,82.15) 261.15,82.02 261.15,81.99 260.87,81.71 260.84,81.71 260.84,81.71 259.74,81.71 259.4,81.37 252.89,81.37 251.28,79.75 246.63,79.75 245.62,80.76 241.08,80.76 236.7,85.14 234.04,85.14 233.96,85.06 233.35,85.06 233.27,85.14 224.21,85.14 221.91,87.44 211.42,87.44 210.83,86.85 195.12,86.85 191.91,83.63 175.16,83.63 173.19,85.6 168.43,85.6 167.07,86.96 156.29,86.96 155.53,87.72 155.53,89.39 149.86,95.05 147.4,95.05 146.29,93.94 143.75,93.94 142.03,95.66 139.44,95.66 137.85,97.25 137.85,99.2 135.48,101.56 133.34,101.56 133,101.9 127.98,101.9 126.91,100.82 108.51,100.82 106.05,98.36 102.26,98.36 101.08,97.18 96.95,97.18 96.25,96.48 89.46,96.48 88.35,95.38 76.28,95.38 74.5,97.16 74.5,99.82 74.18,100.14 60.32,100.14 58.86,98.68 57.12,98.68 56.12,97.68 53.2,97.68 52.48,96.95 v1(51.66,96.95)
  IN4 w0.254: v1(93.31,60.06) 92.14,58.89 89.01,58.89 88.74,59.17 88.74,61.44 85.98,64.21 85.96,64.21 85.64,64.53 81.42,64.53 77.62,68.33 77.62,68.52 76.09,70.05 76.09,74 74.01,76.08 74.01,76.46 73.83,76.63 72.82,77.65 71.49,77.65 70.92,78.22 68.55,78.22 65.89,80.89 60.3,80.89 59.78,81.41 52.97,81.41 52.2,82.18 52.2,93.46 51.04,94.62 51.04,96.33 v1(51.66,96.95)
  BOTTOM w0.254: v3(103.11,50.7) 103.16,50.75 PR850.2 PR858.1
DOCK_DCIN_IS+: length 9.5
  TOP w0.094: PQ703.6 176.89,117.21 177.48,116.61 178.61,116.61 178.69,116.69 180.92,116.69 181.08,116.53 181.08,116.42 v1(181.88,115.62)
  BOTTOM w0.094: v1(181.88,115.62) 181.88,115.64 181.74,115.78 181.46,115.78 181.13,116.11 181.13,117.06 180.9,117.29 JDOCK1.134
DOCK_DCIN_IS-: length 6.8
  TOP w0.094: PQ703.4 178.79,117.13 178.85,117.07 v3(180.3,117.07) 181.08,117.07 181.46,116.69 181.46,116.58 181.8,116.24 181.91,116.24 v1(181.93,116.25)
  BOTTOM w0.094: JDOCK1.136 181.4,117.32 181.51,117.22 181.51,116.26 181.62,116.16 181.84,116.16 v1(181.93,116.25)
DOCK_DET#: length 347.4
  TOP w0.102: v3(93.19,68.07) v2(92.62,67.5)
  TOP w0.254: v1(253.79,76.15) 253.74,76.15 253.31,75.72 253.31,75.32 253.38,75.25 253.38,74.89 UE1.B41
  IN1 w0.254: v3(84.52,69.33) 85.78,68.07 v3(93.19,68.07)
  IN2 w0.254: v1(52.78,107.81) 53.15,108.18 71.11,108.18 71.3,108.37 77.66,108.37 79.24,109.95 80.23,109.95 80.63,109.54 85.15,109.54 85.43,109.82 87.27,109.82 87.53,109.57 104.1,109.57 106.24,107.43 111.18,107.43 113.12,105.48 124.31,105.48 128.01,109.18 144.72,109.18 146.46,110.92 146.46,112.31 147.07,112.92 149.59,112.92 150.24,113.57 150.24,114.84 149.66,115.42 148.84,115.42 148.49,115.78 148.49,118.67 149.11,119.29 154.28,119.29 155.54,120.55 160.38,120.55 162.32,118.61 168.92,118.61 170.76,120.45 189.27,120.45 191.44,118.28 191.44,114.07 v1(195.87,109.64) 199.26,109.64 205.26,103.65 223.91,103.65 225.73,105.47 241.13,105.47 241.78,104.83 251.45,104.83 253.12,103.15 253.12,102.03 253.33,101.83 v1(253.33,101.53) ; v3(72.21,79.11) 72.21,79.12 70.96,80.36 69.06,80.36 63.13,86.3 54.18,86.3 53.84,85.96 v1(53.84,85.98)
  IN3 w0.254: v3(72.21,79.11) 72.25,79.07 72.25,78.67 72.73,78.19 72.73,77.11 76.27,73.57 77.01,73.57 77.77,72.81 77.77,72.41 79.21,70.97 83.25,70.97 84.52,69.7 v3(84.52,69.33)
  IN4 w0.254: v1(52.78,107.81) 52.78,107.17 51.88,106.26 51.88,98.52 53.05,97.35 53.05,95.33 53.7,94.68 53.7,86.12 v1(53.84,85.98)
  BOTTOM w0.254: v1(253.33,101.53) 253.23,101.42 253.23,93.73 253.3,93.65 253.3,89.16 253.82,88.64 253.82,84.41 253.43,84.02 253.43,82.9 253.68,82.64 253.68,76.26 v1(253.79,76.15) ; D19.2 189.7,107.83 191.21,109.34 195.57,109.34 v1(195.87,109.64) ; PR853.1 93.18,68.09 v3(93.19,68.07) ; PQ817.2 R272.1 86.86,74.02 84.52,71.68 v3(84.52,69.33)
DOCK_DET_R#: length 27.1
  IN3 w0.122: v1(190.64,112.74) 190.64,117.78 189.01,119.41 185.52,119.41 184.06,117.95 v1(184.06,117.59)
  BOTTOM w0.102: v1(190.64,112.74) 190.64,109.31 188.3,106.97 D19.1 v2(186.98,105.98) ; v1(184.06,117.59) 184.06,117.27 183.87,117.08 183.5,117.08 183.4,117.19 JDOCK1.144 183.4,119.27 183.3,119.37 182.99,119.37 182.9,119.28 JDOCK1.142
DOCK_HP_DET: length 251.3
  TOP w0.102: v1(255.15,85.95) 255.15,84.91 UE1.A7
  IN2 w0.122: v1(35.41,97.36) 37.2,97.36 43.39,103.55 49.97,103.55 50.09,103.43 59.3,103.43 59.9,104.03 70.72,104.03 71.26,104.57 73.55,104.57 74.47,103.65 79.27,103.65 79.44,103.83 97.7,103.83 99.74,101.79 100.54,101.79 102.16,100.18 102.16,99.42 103.42,98.16 105.24,98.16 106.51,99.43 108.18,99.43 110.41,97.2 116.55,97.2 117.07,97.72 125.08,97.72 127.58,100.23 129.65,100.23 130.18,100.75 131.93,100.75 132.5,100.18 133.11,100.18 133.64,100.71 135.75,100.71 137.45,99.01 137.45,92.88 138.11,92.22 138.11,90.18 138.92,89.37 143.97,89.37 147.12,86.22 150.41,86.22 150.73,86.55 166.95,86.55 168.03,85.47 169.3,85.47 169.49,85.66 178.49,85.66 178.69,85.47 188.35,85.47 190.27,87.38 194.9,87.38 199.29,91.77 209.93,91.77 210.22,91.49 220.48,91.49 v1(223.65,88.32)
  IN3 w0.122: v1(255.15,85.95) 255.15,85.94 253.94,84.73 248.56,84.73 248.07,85.22 241.54,85.22 240.06,86.71 234.42,86.71 234.07,87.05 226.73,87.05 225.83,87.95 224.02,87.95 v1(223.65,88.32)
  BOTTOM w0.102: v1(35.41,97.36) 35.41,96.9 34.63,96.13 QA3.2 34.34,96.13 34.07,96.4 34.07,96.73 RA29.2
DOCK_LOM_ACTLED_YEL#: length 90.5
  TOP w0.102: UL4.19 251.24,102.54 251.51,102.81 v1(251.61,102.81) ; v1(172.4,116.27) v2(172.4,116.88)
  IN2 w0.122: v1(172.4,116.27) 172.74,115.93 173.6,115.93 176.71,112.82 180.73,112.82 185.03,108.52 199.31,108.52 204.88,102.95 224.57,102.95 226.39,104.77 240.38,104.77 241.02,104.13 249.13,104.13 250.46,102.81 v1(251.61,102.81)
  BOTTOM w0.102: v1(172.4,116.27) JDOCK1.100
DOCK_LOM_SPD10LED_GRN#: length 117.8
  TOP w0.102: v1(241.11,106.29) v2(239.74,104.92) 239.38,104.56 239.38,103.53 239.87,103.04 UL4.40
  IN3 w0.122: v1(192.89,107.7) 190.99,105.8 181.8,105.8 181.25,106.35 147.36,106.35 146.89,106.82 146.85,106.82 v1(146.71,106.96)
  IN4 w0.089: v1(198.86,114.51) 198.86,113.48 200.13,112.21 200.13,110.09 204.84,105.37 221.88,105.37 223.47,106.96 225.29,106.96 225.97,107.65 240.16,107.65 241.11,106.7 v1(241.11,106.29)
  BOTTOM w0.102: JDOCK1.3 146.4,107.27 v1(146.71,106.96) ; v1(198.86,114.51) 198.86,109.08 197.69,107.91 193.1,107.91 v1(192.89,107.7)
DOCK_LOM_SPD100LED_ORG#: length 124.8
  TOP w0.102: v2(252.13,104.08) 252.13,103.93 v1(251.6,103.39) 251.16,102.95 250.72,102.95 250.63,103.04 UL4.20
  IN2 w0.122: v1(153.97,113.52) 154.51,114.05 154.81,114.05 155.31,113.55 157.06,113.55 157.68,112.93 159.64,112.93 161.32,114.61 167.47,114.61 168.68,113.4 168.68,112.78 169.08,112.38 169.08,109.68 171.68,107.08 172.62,107.08 v1(172.66,107.11)
  IN3 w0.122: v1(172.66,107.11) 172.66,107.09 173.14,106.6 181.35,106.6 181.9,106.05 190.49,106.05 192.57,108.13 194.7,108.13 204.75,98.08 238.37,98.08 241.21,100.93 247.51,100.93 248.84,102.26 250.47,102.26 v1(251.6,103.39)
  BOTTOM w0.102: JDOCK1.4 146.4,116.85 147.52,115.72 148.34,115.72 148.77,115.29 150.72,115.29 150.88,115.14 152.35,115.14 v1(153.97,113.52)
DOCK_LOM_TRD0+: length 83.9
  TOP w0.094: UL4.36 242.55,105.41 v1(242.46,105.5)
  IN4 w0.081: v1(178.75,114.1) 178.75,113.6 179.03,113.32 181.29,113.32 185.33,109.29 185.33,108.92 185.81,108.44 188.8,108.44 189.61,109.25 199.47,109.25 205.06,103.66 221.51,103.66 224.2,106.35 225.85,106.35 226.52,107.01 239.71,107.01 241.68,105.04 242.36,105.04 242.46,105.13 v1(242.46,105.5)
  BOTTOM w0.094: JDOCK1.104 173.4,117.2 173.52,117.09 173.52,115.21 173.94,114.78 173.94,113.77 175.41,112.31 177.41,112.31 178.65,113.55 178.65,114 v1(178.75,114.1)
DOCK_LOM_TRD0-: length 83.9
  TOP w0.094: UL4.35 243.05,105.04 242.91,105.17 242.91,105.37 v1(243.04,105.5)
  IN4 w0.081: v1(178.1,114.14) 178.5,113.74 178.5,113.5 178.93,113.07 181.19,113.07 185.08,109.18 185.08,108.81 185.71,108.18 188.9,108.18 189.71,108.99 199.36,108.99 204.95,103.41 221.62,103.41 224.31,106.1 225.96,106.1 226.62,106.76 239.61,106.76 241.58,104.79 242.47,104.79 242.71,105.03 242.71,105.17 v1(243.04,105.5)
  BOTTOM w0.094: JDOCK1.106 173.9,115.36 174.33,114.94 174.33,113.93 175.56,112.69 177.25,112.69 178.27,113.71 178.27,113.97 v1(178.1,114.14)
DOCK_LOM_TRD1+: length 85.4
  TOP w0.094: v1(244.5,105.54) 244.55,105.5 UL4.32
  IN4 w0.081: v1(177.14,113.65) 176.98,113.5 176.98,113.3 177.85,112.44 180.96,112.44 181.89,111.51 183.91,109.49 183.91,107.41 184.2,107.11 188.71,107.11 189.96,108.37 198.77,108.37 204.61,102.53 221.79,102.53 224.66,105.4 240.1,105.4 241.42,104.08 244.42,104.08 244.69,104.35 244.69,105.35 v1(244.5,105.54)
  BOTTOM w0.094: JDOCK1.110 174.9,117.12 174.96,117.06 174.96,114.48 175.94,113.5 176.76,113.5 176.91,113.65 v1(177.14,113.65)
DOCK_LOM_TRD1-: length 85.4
  TOP w0.094: v1(245.08,105.54) 245.05,105.51 UL4.31
  IN4 w0.081: v1(176.63,114) 176.73,113.9 176.73,113.19 177.74,112.18 180.86,112.18 181.71,111.33 183.65,109.39 183.65,107.3 184.1,106.86 188.81,106.86 190.07,108.12 198.67,108.12 204.51,102.28 221.9,102.28 224.76,105.15 239.99,105.15 241.31,103.83 244.53,103.83 244.94,104.24 244.94,105.4 v1(245.08,105.54)
  BOTTOM w0.094: JDOCK1.112 175.4,117.12 175.34,117.06 175.34,114.64 176.1,113.88 176.51,113.88 v1(176.63,114)
DOCK_LOM_TRD2+: length 91.2
  TOP w0.094: UL4.27 247.05,105.04 247.17,105.16 247.17,105.25 246.93,105.49 v1(246.93,105.69)
  IN4 w0.081: v1(246.93,105.69) 246.93,105.49 247.26,105.16 247.26,104.82 246.21,103.77 245.49,103.77 244.09,102.38 241.29,102.38 240.46,103.2 223.73,103.2 221.81,101.27 202.21,101.27 196.19,107.29 191.31,107.29 190.27,106.25 183.7,106.25 183.06,106.89 183.06,108.96 180.8,111.21 180.73,111.28 177.74,111.28 175.91,113.12 175.91,114.27 176.22,114.58 176.5,114.58 176.76,114.84 176.76,115.45 176.47,115.75 176.19,115.75 176.06,115.88 176.06,116.12 v1(176.1,116.16)
  BOTTOM w0.094: JDOCK1.122 177.9,117.12 178.02,117 178.02,116.44 177.34,115.76 176.2,115.76 176.07,115.89 176.07,116.13 v1(176.1,116.16)
DOCK_LOM_TRD2-: length 91.2
  TOP w0.094: UL4.26 247.55,105.45 247.51,105.49 v1(247.51,105.69)
  IN4 w0.081: v1(247.51,105.69) 247.51,104.71 246.32,103.52 245.59,103.52 244.2,102.13 241.18,102.13 240.36,102.95 223.84,102.95 221.91,101.02 202.11,101.02 196.09,107.04 191.41,107.04 190.37,106 183.59,106 182.8,106.78 182.8,108.85 180.63,111.03 177.64,111.03 175.66,113.01 175.66,114.38 176.11,114.83 176.4,114.83 176.51,114.95 176.51,115.35 176.36,115.5 176.27,115.5 v1(176.12,115.36)
  BOTTOM w0.094: JDOCK1.124 178.4,117.16 178.4,117.16 178.4,116.28 177.5,115.38 176.15,115.38 v1(176.12,115.36)
DOCK_LOM_TRD3+: length 100.6
  TOP w0.094: UL4.23 249.05,104.99 248.91,105.13 248.91,105.35 248.78,105.48 v1(248.78,105.49)
  IN4 w0.081: v1(180.48,115.59) 180.48,115.67 180.2,115.96 178.33,115.96 177.01,117.27 175.83,117.27 175.05,116.5 175.05,111.89 176.51,110.44 177.62,110.44 177.8,110.26 180.52,110.26 181.71,109.07 181.71,106.97 181.83,106.85 183.38,105.31 190.97,105.31 192.02,106.37 195.92,106.37 202.34,99.95 222,99.95 224.34,102.3 225.66,102.3 226.42,101.54 246.95,101.54 249.02,103.61 249.02,105.24 v1(248.78,105.49)
  BOTTOM w0.094: v1(180.48,115.59) 180.16,115.59 180.1,115.65 180.1,116.26 179.52,116.84 179.52,117.22 179.4,117.34 JDOCK1.128
DOCK_LOM_TRD3-: length 100.6
  TOP w0.094: UL4.22 249.55,105.03 249.29,105.29 249.29,105.4 v1(249.36,105.48)
  IN4 w0.081: v1(180.52,116.21) 178.44,116.21 177.12,117.53 175.73,117.53 174.8,116.6 174.8,111.79 176.4,110.19 177.52,110.19 177.7,110.01 180.41,110.01 181.46,108.97 181.46,106.87 181.65,106.68 183.27,105.06 191.07,105.06 192.13,106.11 195.82,106.11 202.23,99.7 222.1,99.7 224.45,102.05 225.55,102.05 226.31,101.29 247.05,101.29 249.28,103.51 249.28,105.39 v1(249.36,105.48)
  BOTTOM w0.094: JDOCK1.130 179.9,117 180.48,116.42 180.48,116.25 v1(180.52,116.21)
DOCK_MIC_DET: length 252.8
  TOP w0.102: UE1.B8 v1(254.92,83.35)
  IN2 w0.122: v1(37.69,95.32) 37.69,97.13 43.86,103.3 49.74,103.3 49.86,103.18 59.42,103.18 60.03,103.79 70.83,103.79 71.37,104.33 73.43,104.33 74.37,103.38 79.64,103.38 79.82,103.56 87.46,103.56 88.29,102.73 89.67,102.73 90.5,103.56 97.59,103.56 99.6,101.54 100.44,101.54 101.91,100.07 101.91,99.32 103.31,97.91 105.34,97.91 106.54,99.11 108.1,99.11 110.26,96.95 116.65,96.95 117.17,97.47 125.18,97.47 127.69,99.98 129.75,99.98 130.28,100.5 131.8,100.5 132.36,99.93 133.21,99.93 133.75,100.46 135.64,100.46 137.16,98.95 137.16,92.82 137.86,92.12 137.86,90.08 138.82,89.12 143.86,89.12 147.02,85.97 151.13,85.97 151.46,86.3 163.52,86.3 164.77,85.04 169.37,85.04 169.58,85.26 177.17,85.26 177.21,85.22 188.46,85.22 190.37,87.13 195.01,87.13 199.4,91.52 209.83,91.52 210.12,91.24 220.12,91.24 223.46,87.9 224.23,87.9 v1(225.21,86.92)
  IN3 w0.122: v1(254.92,83.35) 254.04,84.24 248.35,84.24 247.86,84.72 243.28,84.72 241.9,83.34 241.38,83.34 239.23,85.49 233.94,85.49 233.83,85.37 233.48,85.37 233.37,85.49 226.9,85.49 225.47,86.92 v1(225.21,86.92)
  BOTTOM w0.102: v2(36.5,93.49) 36.96,93.94 RA26.2 36.96,94.58 v1(37.69,95.32) 37.69,95.44 37.01,96.13 QA3.5
DOCK_POR_RST#: length 132.4
  TOP w0.102: UE2.A21 259.61,64.96 v1(259.61,65.71) ; v1(182.4,116.93) 182.4,118.79 183.62,120 189.78,120 191.48,118.3 191.48,110.68 208.17,93.99 208.17,91.23 210.3,89.09 212.38,89.09 212.89,88.59 212.89,85.13 213.53,84.5 220.93,84.5 222.34,83.09 228,83.09 v2(229.64,81.45) 231.23,79.86 231.23,75.71 230.8,75.28 230.34,75.28 v1(229.93,75.68) ; v1(258.67,73.24) 258.94,72.98 261.14,72.98 262.42,71.69 RE277.2
  IN2 w0.122: v1(259.61,65.71) 259.11,66.22 259.11,66.4 257.67,67.84 251.36,67.84 251.19,68.01 246.62,68.01 245.86,67.25 237.85,67.25 236.51,68.59 235.1,68.59 230.02,73.66 230.02,75.59 v1(229.93,75.68)
  BOTTOM w0.102: v1(258.67,73.24) 258.67,71.38 259.59,70.46 259.59,69.59 260.17,69 260.17,67.63 260.36,67.44 260.36,66.46 v1(259.61,65.71) ; v1(182.4,116.93) JDOCK1.140
DOCK_PSID: length 183.7
  TOP w0.102: v1(40.6,104.28) v2(40.6,103.49)
  IN1 w0.089: v1(38.66,83.28) 38.3,83.28 37.93,83.64 37.93,87.75 38.3,88.12 38.3,90.71 v1(38.54,90.95)
  IN3 w0.122: v1(180.51,111.76) 179.74,112.52 176.7,112.52 174.56,114.66 174.56,116.86 174.24,117.18 172.3,117.18 171.77,116.64 169.36,116.64 168.49,117.52 161.51,117.52 159.89,115.9 158.15,115.9 156.33,117.73 146.54,117.73 144.44,119.82 138.97,119.82 132.13,112.99 132.13,112.72 132.13,112.72 132.13,112.26 124.66,104.79 105.14,104.79 104.65,105.28 99.39,105.28 98.1,106.56 79.24,106.56 78.44,107.36 57.61,107.36 57.02,106.77 53.56,106.77 52.2,105.41 42.99,105.41 41.86,104.28 v1(40.6,104.28)
  IN4 w0.089: v1(40.6,104.28) 40.43,104.12 40.43,103.61 39.64,102.81 39.64,96.67 38.9,95.94 38.9,91.3 v1(38.54,90.95)
  BOTTOM w0.102: v1(180.51,111.76) 181.14,111.76 181.4,111.5 JDOCK1.135
  BOTTOM w0.254: v1(38.66,83.28) 40.12,83.28 40.6,82.79 PU1.1
DOCK_PWR_BTN#: length 146.2
  TOP w0.102: CE44.1 266.74,49.86 RE42.2 ; CE44.1 268.43,50.76 v1(268.64,50.76) ; CE44.1 267.39,49.22 v2(268.14,49.22)
  IN2 w0.122: v1(182.4,108.52) 182.4,108.24 183.93,106.71 196.7,106.71 198.86,104.55 199.12,104.55 202.11,101.56 224.59,101.56 226.16,99.99 231.07,99.99 232.2,98.86 240.38,98.86 240.79,98.44 241.74,98.44 242.43,99.13 250.19,99.13 251.16,98.16 254.24,98.16 254.57,97.83 258.13,97.83 258.31,97.65 262.8,97.65 271.42,89.03 271.42,78.86 272.31,77.97 272.31,68.67 274.14,66.84 274.14,66.27 271.82,63.95 271.82,58.92 269.83,56.93 269.83,54.88 270.43,54.28 270.43,52.56 v1(268.64,50.76)
  BOTTOM w0.102: JDOCK1.139 v1(182.4,108.52)
DOCK_PWR_SW#: length 7.9
  TOP w0.102: UE2.A63 261.1,53.64 261.73,53.01 262.8,53.01 v2(263.3,52.51) 263.67,52.14 265.16,52.14 CE45.1 RE42.1 267.73,51.58 RE62.2
DOCK_SMB_ALERT#: length 420.3
  TOP w0.254: v1(79.62,6.25) 81.66,6.25 82.82,5.1 PQ1.3 ; v1(55.36,77.22) v2(52.69,79.89) v1(52.69,82.57) ; v1(183.11,115.83) 183.11,119.07 183.74,119.7 189.65,119.7 191.17,118.18 191.17,110.35 192.24,109.29 192.24,105.93 v1(192.51,105.67) ; UE1.A51 260.64,76.69 v1(260.97,77.03) 261.31,76.69 262.39,76.69 RE9.2
  IN3 w0.254: v1(51.1,107) 51.71,107.61 52.16,107.61 52.47,107.29 52.96,107.29 53.8,108.13 79.23,108.13 80,107.36 93.15,107.36 94.69,108.89 104.06,108.89 107.47,105.48 124.33,105.48 131.44,112.59 131.44,113.27 138.68,120.52 143.97,120.52 144.73,120.52 146.82,118.42 156.62,118.42 158.24,116.8 159.55,116.8 161.28,118.53 169.14,118.53 169.79,119.18 175.06,119.18 176.5,117.73 182.47,117.73 183.24,116.97 183.24,115.95 v1(183.11,115.83) ; v1(55.36,77.22) 60.36,77.22 63.27,74.31 71.9,74.31 73.7,72.51 73.7,66.35 79.48,60.57 79.48,58.69 82.83,55.34 82.83,48.78 82.84,48.72 83.86,47.71 83.86,36.22 83.36,35.73 83.36,33.37 82.85,32.85 82.85,28.83 82.63,28.6 82.63,14.51 79.83,11.71 79.83,6.47 v1(79.62,6.25)
  IN4 w0.254: v1(51.1,107) 51.1,98.2 52.29,97.02 52.29,95 52.9,94.39 52.9,82.77 v1(52.69,82.57) ; v1(192.51,105.67) 192.51,98.08 192.93,97.66 197.38,97.66 197.92,97.12 239.92,97.12 241.48,95.56 248.65,95.56 249.22,94.98 259.76,94.98 v1(261.3,96.52)
  BOTTOM w0.254: v1(261.3,96.52) 262,95.82 262,82.24 262.37,81.87 262.37,80.86 262.03,80.52 261.31,80.52 261,80.21 261,77 260.97,77.02 v1(260.97,77.03) ; JDOCK1.133 180.9,108.97 183.01,106.86 184.26,106.86 185.95,105.17 192.01,105.17 v1(192.51,105.67)
DOCK_SMB_CLK: length 138.6
  TOP w0.102: RPE3.2 253.53,52 v1(253.56,52.03) ; UE2.B4 261.84,57 v1(261.76,57.08)
  IN1 w0.089: v1(261.76,57.08) 262.37,56.47 262.37,55.57 261.96,55.16 257.07,55.16 257.05,55.13 255.86,55.13 255.47,55.13 253.61,53.27 253.61,52.35 253.56,52.29 v1(253.56,52.03) 253.53,52.06 253.21,52.06 252.81,52.45 252.81,52.65 252.3,53.16 248.07,53.16 247.11,52.21 239.24,52.21 238.72,52.72 237.93,52.72 v1(237.9,52.76)
  BOTTOM w0.102: JDOCK1.127 179.4,109.3 179.44,109.26 179.44,107.8 181.29,105.95 183.96,105.95 185.55,104.36 192.53,104.36 193.47,105.3 193.47,105.88 194.6,107.01 202.09,107.01 211.71,97.39 216.78,97.39 217.34,96.83 217.34,95.29 220.47,92.15 222.45,92.15 229.81,84.8 235.79,84.8 237.66,82.93 237.66,75.7 236.75,74.8 236.75,73.36 239.66,70.45 239.66,64.29 240.3,63.66 240.3,62.2 240.09,61.99 240.09,56.21 237.96,54.07 237.96,52.82 v1(237.9,52.76)
DOCK_SMB_DAT: length 140.8
  TOP w0.102: v1(254.17,51.92) 254.17,51.77 254.03,51.63 RPE3.1 ; UE2.A3 v1(264.12,56.75)
  IN1 w0.089: v1(237.91,52.15) 238.01,52.25 238.53,52.25 239.04,51.74 247.31,51.74 248.26,52.69 252.11,52.69 252.34,52.46 252.34,52.26 253.06,51.54 253.94,51.54 254.17,51.77 v1(254.17,51.92) 254.17,51.97 254.08,52.05 254.08,53.08 255.67,54.66 262.2,54.66 262.84,55.3 262.84,56.1 263.49,56.75 v1(264.12,56.75)
  BOTTOM w0.102: JDOCK1.129 179.9,109.48 179.92,109.46 179.92,108 181.49,106.43 184.16,106.43 185.75,104.84 192.33,104.84 192.99,105.5 192.99,106.08 194.4,107.5 202.29,107.5 211.91,97.87 216.98,97.87 217.82,97.03 217.82,95.49 220.67,92.64 222.65,92.64 230.01,85.28 235.99,85.28 238.14,83.13 238.14,75.5 237.24,74.6 v2(237.24,74.11) 237.24,73.56 240.14,70.65 240.14,64.49 240.73,63.91 240.73,61.95 240.58,61.79 240.58,56.01 238.44,53.87 238.44,52.62 238.24,52.42 238.24,52.4 237.99,52.15 v1(237.91,52.15)
DOCK_USB3RN1: length 40.5
  TOP w0.102: UI4.22 189.52,96.05 189.33,96.24 189.33,96.81 189.47,96.95 189.51,96.95 v1(189.85,96.61)
  IN4 w0.089: v1(167.37,116.67) 167.57,116.47 167.57,116.32 167.82,116.07 168.31,116.07 168.67,116.42 169.77,116.42 170.64,115.56 171.39,115.56 172.47,114.47 172.47,113.89 173.71,112.65 173.71,112.3 173.57,112.15 173.57,111.72 175.91,109.37 177.25,109.37 177.37,109.24 179.16,109.24 179.48,108.93 179.48,108.02 179.95,107.55 179.95,105.8 181.5,104.26 186.65,104.26 187.73,103.18 187.73,100.16 189.32,98.57 189.32,97.72 189.1,97.49 189.1,97.04 189.42,96.71 189.75,96.71 v1(189.85,96.61)
  BOTTOM w0.102: JDOCK1.84 167.4,117.15 167.58,116.97 167.58,116.87 v1(167.37,116.67)
DOCK_USB3RP1: length 40.4
  TOP w0.102: v1(189.85,97.2) 189.81,97.16 189.38,97.16 189.12,96.9 UI4.23
  IN4 w0.089: v1(167.95,116.67) 167.74,116.45 167.74,116.39 167.89,116.24 168.24,116.24 168.6,116.59 169.84,116.59 170.71,115.73 171.46,115.73 172.64,114.54 172.64,113.96 173.88,112.72 173.88,112.22 173.74,112.08 173.74,111.79 175.98,109.54 177.32,109.54 177.44,109.41 179.24,109.41 179.65,109 179.65,108.09 180.12,107.62 180.12,105.87 181.57,104.43 186.72,104.43 187.9,103.25 187.9,100.23 189.49,98.64 189.49,97.65 189.27,97.42 189.27,97.11 189.49,96.88 189.54,96.88 v1(189.85,97.2)
  BOTTOM w0.102: v1(167.95,116.67) 167.78,116.84 167.78,117.04 167.9,117.15 JDOCK1.86
DOCK_USB3TN1: length 36.8
  TOP w0.102: UI4.24 188.72,96.13 188.61,96.24 188.61,97.68 v1(188.85,97.92)
  IN4 w0.089: v1(168.86,115.88) 168.94,115.8 169.37,115.8 169.53,115.64 169.53,114.86 169.21,114.54 169.21,113.77 170.09,112.89 172.15,112.89 173.09,111.95 173.09,111.49 176.06,108.53 178.28,108.53 179.43,107.38 179.43,105.57 181.23,103.77 182.73,103.77 183.43,103.07 184.59,103.07 187.26,100.4 187.26,99.93 188.76,98.43 188.76,98.01 v1(188.85,97.92)
  BOTTOM w0.102: JDOCK1.90 168.9,117.15 168.98,117.07 169.11,117.07 169.19,116.98 169.19,116.98 169.55,116.62 169.55,115.97 169.2,115.63 169.11,115.63 v1(168.86,115.88)
DOCK_USB3TP1: length 36.7
  TOP w0.102: v1(188.26,97.92) 188.4,97.78 188.4,96.19 188.32,96.12 UI4.25
  IN4 w0.089: v1(188.26,97.92) 188.59,98.25 188.59,98.36 187.09,99.86 187.09,100.33 184.52,102.9 183.36,102.9 182.66,103.6 181.16,103.6 179.26,105.5 179.26,107.3 178.21,108.36 175.98,108.36 172.92,111.42 172.92,111.88 172.08,112.72 170.02,112.72 169.04,113.7 169.04,114.61 169.36,114.93 169.36,115.57 169.3,115.63 169.2,115.63 v1(168.86,115.3)
  BOTTOM w0.102: v1(168.86,115.3) 168.99,115.42 169.29,115.42 169.76,115.89 169.76,116.71 169.4,117.06 JDOCK1.92
DOCK_USBP0+: length 52.2
  TOP w0.102: UI4.15 193.11,94.45 193.28,94.62 194.09,94.62 194.34,94.38 v1(194.34,93.87)
  IN4 w0.089: v1(164.16,119.6) 164.36,119.8 164.36,119.99 164.8,120.42 166.03,120.42 166.3,120.15 166.3,116.69 167.28,115.71 167.5,115.71 168.18,115.03 168.18,113.78 169.8,112.17 171.46,112.17 175.77,107.86 178,107.86 178.71,107.15 178.71,105.29 180.89,103.11 182.13,103.11 182.51,102.73 182.51,101.92 182.08,101.49 182.08,101.04 182.5,100.62 184.32,100.62 186.62,98.32 186.62,97.18 188.14,95.65 193.31,95.65 194.34,94.63 v1(194.34,93.87)
  BOTTOM w0.102: JDOCK1.72 164.4,119.43 164.23,119.6 v1(164.16,119.6)
DOCK_USBP0-: length 52.1
  TOP w0.102: UI4.14 193.21,94.05 193.28,94.12 193.28,94.32 193.37,94.41 194.01,94.41 194.08,94.34 194.08,94.2 193.79,93.91 v1(193.71,93.91)
  IN4 w0.089: v1(164.92,119.47) 164.88,119.43 164.64,119.43 164.57,119.51 164.57,119.95 164.87,120.25 165.96,120.25 166.13,120.08 166.13,116.62 167.21,115.54 167.43,115.54 168.01,114.96 168.01,113.71 169.73,112 171.39,112 175.7,107.69 177.93,107.69 178.54,107.08 178.54,105.21 180.81,102.94 182.06,102.94 182.34,102.66 182.34,101.99 181.91,101.56 181.91,100.97 182.43,100.45 184.25,100.45 186.45,98.25 186.45,97.11 188.07,95.48 193.24,95.48 194.14,94.59 194.14,94.26 193.78,93.91 v1(193.71,93.91)
  BOTTOM w0.102: v1(164.92,119.47) 164.8,119.47 164.67,119.33 164.67,119.22 164.9,118.99 JDOCK1.74
DOCK_USBP3+: length 17
  TOP w0.102: v1(163.82,107.21) 164,107.4 164,110.8 164.12,110.92 164.12,112.32 164.74,112.93 165.52,112.93 165.72,113.14 165.72,115.11 v1(165.52,115.31)
  BOTTOM w0.102: UI5.3 163.86,105.45 164.05,105.63 164.05,106.99 v1(163.82,107.21) ; JDOCK1.66 162.9,117.31 163.05,117.16 163.05,116.97 163.22,116.79 164.03,116.79 164.23,116.59 165.58,116.59 165.7,116.47 165.7,115.48 v1(165.52,115.31)
DOCK_USBP3-: length 17
  TOP w0.102: v1(164.4,107.21) 164.21,107.41 164.21,110.72 164.33,110.83 164.33,112.23 164.82,112.73 165.6,112.73 165.93,113.05 165.93,115.13 v1(166.11,115.31)
  BOTTOM w0.102: JDOCK1.68 163.4,117.31 163.25,117.16 163.25,117.08 163.33,117 164.12,117 164.32,116.8 165.66,116.8 165.91,116.56 165.91,115.51 v1(166.11,115.31) ; v1(164.4,107.21) 164.34,107.21 164.25,107.13 164.25,105.59 164.36,105.48 UI5.4
DOCKED: length 191.1
  TOP w0.102: v1(229.15,97.64) 228.88,97.37 228.88,87.73 230.84,85.78 v2(232.14,85.78) 233.64,85.78 v1(233.65,85.79) ; UV16.30 174.37,94.05 v1(174.19,94.22) ; v1(185.42,92.94) 185.72,93.25 UI4.32 ; UI4.10 191.12,92.04 191.48,91.68 v1(191.59,91.68) ; v1(253.85,72.67) 253.75,72.67 253.35,73.07 253.35,73.49 253.17,73.67 UE1.A38 ; v1(248.08,99.69) 248.08,99.85 247.55,100.38 UL4.13
  IN2 w0.122: v1(174.19,94.22) 175.01,93.41 184.95,93.41 v1(185.42,92.94) 190.33,92.94 v1(191.59,91.68) ; v1(253.85,72.67) 251.49,72.67 251.02,72.2 248.26,72.2 247.42,73.04 243.29,73.04 243,73.33 243,73.33 v1(242.29,74.04)
  IN3 w0.122: v1(248.08,99.69) 248.08,99.86 247.29,100.65 241.35,100.65 238.34,97.64 v1(229.15,97.64) ; v1(241.48,84.08) 239.56,85.99 233.73,85.99 233.65,85.92 ; 233.65,85.92 233.58,85.99 226.91,85.99 225.54,87.37 223.09,87.37 222.25,88.2 211.29,88.2 210.42,87.34 192.27,87.34 189.62,84.7 v1(189.61,84.7) ; 233.65,85.92 v1(233.65,85.79) ; v1(156.78,89.86) 156.78,88.98 157.48,88.28 168.66,88.28 172.55,92.17 172.55,92.58 v1(174.19,94.22)
  BOTTOM w0.102: v1(191.59,91.68) 191.59,91.67 191.57,91.65 191.57,91.39 189.84,89.66 189.84,84.93 v1(189.61,84.7) ; QV11.2 137.3,87 137.42,86.88 146.27,86.88 147.28,87.9 147.28,89.91 147.71,90.34 150.94,90.34 151.42,89.86 v1(156.78,89.86) ; v1(242.29,74.04) 241.8,74.54 241.8,83.76 v1(241.48,84.08)
DOCKED_LIO_EN: length 132
  TOP w0.102: UE1.B52 259.3,75.44 259.69,75.05 v1(259.92,75.05) ; v1(260.2,96.51) v2(260.2,97.28)
  IN3 w0.122: v1(162.98,102.78) 163.26,103.06 164.09,103.06 164.29,103.26 182.01,103.26 182.91,102.36 187.53,102.36 187.99,102.82 190.03,102.82 191.4,104.19 195.24,104.19 207.32,92.11 223.9,92.11 224.95,91.06 240.22,91.06 241.77,92.61 241.77,92.85 244.73,95.81 247.69,95.81 248.49,95.01 253.49,95.01 254.29,95.81 257.33,95.81 258.51,96.99 259.72,96.99 v1(260.2,96.51)
  BOTTOM w0.102: v1(162.98,102.78) 162.86,102.9 UI5.9 ; v1(259.92,75.05) 259.79,75.17 259.79,95.04 260.2,95.44 v1(260.2,96.51)
DPB_CA_DET: length 90.3
  TOP w0.102: UV8.M14 165.4,91.23 165.82,90.81 v1(165.84,90.81) ; v1(194.7,103.77) 194.96,103.77 v2(195.75,102.99)
  IN2 w0.122: v1(154.62,113.53) 154.85,113.3 156.96,113.3 157.61,112.65 159.71,112.65 161.42,114.36 167.36,114.36 168.41,113.3 168.41,112.61 168.82,112.21 168.82,109.53 173.41,104.94 173.41,99.82 172.94,99.35 v1(172.94,98.63)
  IN3 w0.122: v1(194.7,103.77) 193.21,102.28 188.94,102.28 v1(188.52,101.86) 185.41,98.75 v1(184.59,98.75) 183.92,99.42 173.72,99.42 v1(172.94,98.63) 172.02,97.72 172.02,92.16 169.49,89.63 166.49,89.63 165.84,90.29 v1(165.84,90.81)
  BOTTOM w0.102: v1(154.62,113.53) 152.74,115.41 150.96,115.41 150.84,115.53 148.86,115.53 148.44,115.95 147.68,115.95 146.9,116.73 JDOCK1.6 ; v1(188.52,101.86) 188.33,101.67 UV11.4 ; v1(194.7,103.77) 195.73,104.8 QV9.2 ; v1(184.59,98.75) 184.77,98.75 RV508.2 185.74,99.72 UV11.1
DPB_CA_DET#: length 9
  BOTTOM w0.102: UV11.13 v2(194.73,100.37) 195.38,100.37 RV90.2 196.38,101.36 QV9.1 194.73,103.23 193.82,102.32 UV11.10
DPB_DOCK_AUX: length 56.2
  IN2 w0.112: v1(155.41,114.52) 155.5,114.61 155.5,115.06 156.33,115.89 160.39,115.89 161,116.5 166.76,116.5 169.37,113.89 169.37,113.67 170.43,112.6 171.34,112.6 171.97,111.97 171.97,108.31 172.47,107.81 173.39,107.81 173.94,107.27 173.94,106.34 176.29,103.99 181.66,103.99 182.58,103.06 189.85,103.06 190.41,102.5 v1(190.41,101.84)
  BOTTOM w0.102: JDOCK1.34 153.9,116.63 155.41,115.12 v1(155.41,114.52) ; UV11.3 189.58,101.02 v1(190.41,101.84) 190.98,101.27 191.9,101.27 192.29,101.67 UV11.11
DPB_DOCK_AUX#: length 57.2
  IN2 w0.112: v1(189.75,101.83) 189.82,101.83 190.21,102.22 190.21,102.42 189.77,102.86 182.5,102.86 181.57,103.79 176.2,103.79 173.74,106.26 173.74,107.18 173.31,107.61 172.38,107.61 171.77,108.22 171.77,111.88 171.25,112.4 170.35,112.4 169.16,113.58 169.16,113.81 166.67,116.3 161.09,116.3 160.48,115.69 156.41,115.69 155.7,114.97 155.7,114.81 155.99,114.52 v1(156.04,114.52)
  BOTTOM w0.102: v1(156.04,114.52) 155.62,114.95 155.62,115.2 154.11,116.71 154.11,117.02 154.21,117.12 154.32,117.12 154.4,117.2 JDOCK1.36 ; UV11.6 189.48,102.97 189.75,102.69 v1(189.75,101.83) 191.54,103.62 UV11.8
DPB_DOCK_HPD: length 56.7
  TOP w0.102: R271.1 C311.1 155.49,119.49 v1(155.4,119.57) ; UV8.K14 165.55,92.53 165.95,92.13 v1(166.55,92.13)
  IN2 w0.122: v1(155.47,102.34) 155.51,102.34 156.29,103.11 160.66,103.11 161.12,103.58 165.82,103.58 166.94,102.47 166.94,99.23 166.17,98.47 166.17,96.27 165.87,95.98 165.87,92.7 166.45,92.13 v1(166.55,92.13)
  IN4 w0.089: v1(155.47,102.34) 155.46,102.34 149.51,108.29 148.84,108.29 147.71,109.42 147.71,118.47 148.82,119.57 v1(155.4,119.57)
  BOTTOM w0.102: v2(166.92,91.76) v1(166.55,92.13) ; JDOCK1.40 v1(155.4,119.57)
DPB_DOCK_LANE_N0: length 4.1
  TOP w0.102: R261.1 147.87,119.95 147.49,120.34 147.49,120.53 v1(147.63,120.68)
  BOTTOM w0.102: JDOCK1.12 148.4,119.25 148.25,119.4 148.25,119.73 147.95,120.04 147.7,120.04 147.44,120.29 147.44,120.49 v1(147.63,120.68)
DPB_DOCK_LANE_N1: length 3.7
  TOP w0.102: R256.1 149.49,120.31 149.49,120.49 v1(149.66,120.65)
  BOTTOM w0.102: v1(149.66,120.65) 149.47,120.46 149.47,120.04 149.75,119.76 149.75,119.4 149.9,119.25 JDOCK1.18
DPB_DOCK_LANE_N2: length 3.7
  TOP w0.102: R264.1 151.53,120.31 151.53,120.49 v1(151.69,120.65)
  BOTTOM w0.102: JDOCK1.24 151.4,119.25 151.25,119.4 151.25,119.5 151.5,119.75 151.5,120.46 v1(151.69,120.65)
DPB_DOCK_LANE_N3: length 3.9
  TOP w0.102: R267.1 153.52,120.34 153.52,120.4 v1(153.71,120.58)
  BOTTOM w0.102: v1(153.71,120.58) 153.52,120.4 153.52,120.11 153.03,119.62 152.89,119.62 152.75,119.49 152.75,119.4 152.9,119.25 JDOCK1.30
DPB_DOCK_LANE_P0: length 4.1
  TOP w0.102: v1(147.04,120.68) 147.28,120.44 147.28,120.33 R260.1
  BOTTOM w0.102: JDOCK1.10 147.9,119.25 148.05,119.4 148.05,119.65 147.87,119.83 147.61,119.83 147.23,120.21 147.23,120.49 v1(147.04,120.68)
DPB_DOCK_LANE_P1: length 3.7
  TOP w0.102: R254.1 149.29,120.31 149.29,120.44 v1(149.08,120.65)
  BOTTOM w0.102: v1(149.08,120.65) 149.26,120.46 149.26,119.95 149.55,119.67 149.55,119.4 149.4,119.25 JDOCK1.16
DPB_DOCK_LANE_P2: length 3.7
  TOP w0.102: v1(151.11,120.65) 151.32,120.44 151.32,120.31 R262.1
  BOTTOM w0.102: JDOCK1.22 150.9,119.25 151.05,119.4 151.05,119.58 151.3,119.83 151.3,120.46 v1(151.11,120.65)
DPB_DOCK_LANE_P3: length 3.8
  TOP w0.102: v1(153.12,120.58) 153.31,120.4 153.31,120.27 R258.1
  BOTTOM w0.102: v1(153.12,120.58) 153.31,120.4 153.31,120.19 152.95,119.83 152.8,119.83 152.55,119.57 152.55,119.4 152.4,119.25 JDOCK1.28
DPB_HPD: length 108.1
  TOP w0.102: QV5.3 100.46,98.88 RV18.1 100.46,95.52 v2(100.13,95.19) 100.13,93.81 v1(100.24,93.7)
  IN3 w0.086: v1(166.12,72.2) 166.17,72.26 166.17,73.39
  IN3 w0.122: v1(100.24,93.7) 100.25,93.71 100.69,93.27 104.2,93.27 108.17,97.23 116.34,97.23 117.01,97.9 128.36,97.9 129.37,98.91 133.26,98.91 135.74,96.43 135.74,93.03 138.32,90.45 138.32,90.09 138.79,89.61 142.92,89.61 143.13,89.4 146.33,89.4 147.17,90.24 150.6,90.24 151.42,89.41 151.42,85.78 152.13,85.07 152.99,85.07 153.79,84.27 159.85,84.27 160.34,83.78 163.13,83.78 163.52,83.39 166.31,83.39 169.6,80.1 170.98,80.1 171.49,79.59 171.49,79.16 170.6,78.27 169.01,78.27 167.06,76.33 166.76,76.33 166.76,76.33 166.41,76.33 166.17,76.08 166.17,73.39
  BOTTOM w0.076: UC1.C8 164.57,69.16 164.57,69.88 164.73,70.04 164.73,70.48 166.12,71.87 v1(166.12,72.2)
