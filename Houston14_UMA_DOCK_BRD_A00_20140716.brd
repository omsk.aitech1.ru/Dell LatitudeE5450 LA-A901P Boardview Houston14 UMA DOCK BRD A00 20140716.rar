# Allegro board Houston14_UMA_DOCK_BRD_A00_20140716.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+3.3V_RUN on TOP (solid shape): outline of 82 points within 241.81,79.68 243.41,82.51
+3.3V_RUN on BOTTOM (solid shape): 295.55,38.59 295.55,37.72 295.24,37.4 294.7,37.4 294.67,37.44 294.67,37.92 294.63,37.96 294.22,37.96 294.18,37.92 294.18,37.44 294.14,37.4 293.83,37.4 293.62,37.61 293.62,38.2 294.17,38.75 295.39,38.75
+3.3V_RUN on BOTTOM (solid shape): 97.11,101.16 97.11,99.91 97.18,99.83 97.18,98.6 97.11,98.52 97.11,98.16 96.95,98.01 96.36,98.01 96.27,98.1 96.27,98.49 96.66,98.88 96.66,99.96 96.74,100.04 96.74,101.18 96.83,101.27 97,101.27
+3.3V_RUN on BOTTOM (solid shape): 107.28,70.88 108.04,70.88 108.14,70.78 108.14,70.47 108.04,70.37 107.76,70.37 107.68,70.45 107.61,70.45 107.58,70.48 106.65,70.48 106.54,70.47 106.43,70.45 106.29,70.45 106.24,70.5 106.24,71.01 106.29,71.06 107.1,71.06
+3.3V_RUN on BOTTOM (solid shape): 273.96,38.51 273.96,37.09 273.84,36.96 272.48,36.96 272.39,37.05 272.39,37.15 272.4,37.2 272.41,37.25 272.41,37.84 272.4,37.89 272.39,37.94 272.39,37.96 272.43,38.01 272.68,38.19 272.69,38.5 272.82,38.64 273.84,38.64
+3.3V_RUN on BOTTOM (solid shape): 235.5,62.04 235.5,55.17 235.47,55.14 235.47,49.65 234.45,48.63 232.51,48.63 232.46,48.58 231.94,48.58 228.51,45.15 228.51,42.92 226.42,40.82 226.42,36.59 225.19,35.37 224.19,35.37 224.07,35.5 224.07,36.01 224.45,36.39 224.45,40.45 226.99,42.99 226.99,45.41 230.92,49.34 233.34,49.34 234.23,50.23 234.23,60.39 233.97,60.65 233.21,60.65 233.08,60.77 233.08,61.92 232.07,62.93 230.16,62.93 229.91,63.19 226.73,63.19 226.35,62.8 226.35,61.85 226.48,61.72 226.48,61.28 225.97,61.28 225.97,60.77 226.54,60.77 226.54,60.39 226.48,60.33 225.15,60.33 225.02,60.45 225.02,63.25 226.23,64.46 233.08,64.46
+3.3V_RUN on BOTTOM (solid shape): 189.71,70.36 189.71,67.49 189.65,67.29 189.71,67.08 189.71,65.61 189.78,65.55 189.78,64.58 189.72,64.53 189.72,62.82 189.78,62.77 189.78,61.22 189.46,60.9 188.51,60.9 188.44,60.96 188.44,62.61 188.25,62.8 187.09,62.8 186.83,62.92 186.57,62.8 186.44,62.8 185.95,62.83 185.9,62.34 185.9,62.11 185.46,61.66 185.46,61.39 185.37,61.05 185.61,60.8 185.63,60.79 185.97,60.45 185.97,59.95 185.84,59.82 184.57,59.82 184.38,60.01 184.38,64.77 184.63,65.03 185.71,65.03 185.92,64.82 185.91,64.79 185.9,64.56 186.02,64.37 186.99,63.39 187.29,63.39 187.36,63.31 188.32,63.31 188.46,63.45 188.46,64.96 188.49,65 188.49,65.25 188.53,65.32 188.6,65.35 188.62,65.35 189.03,65.35 189.28,65.6 189.03,65.86 188.62,65.86 188.61,65.86 188.54,65.88 188.51,65.96 188.51,69.74 189.2,70.44 189.63,70.44
+3.3V_RUN on IN1 (solid shape): outline of 84 points within 185.01,60.96 189.97,63.54
+3.3V_RUN on VCC (solid shape): outline of 65434 points within 19.8,1.27 328.03,120.93
+3.3V_RUN on IN4 (solid shape): outline of 92 points within 144.97,91.16 148.77,98.21
+3.3V_RUN on IN4 (solid shape): outline of 639 points within 170.6,79.53 183.16,95.86
+3.3V_RUN_AUDIO on BOTTOM (solid shape): 20.39,86.93 20.87,86.93 21.19,87.25 22.31,87.25 22.44,87.12 22.44,86.53 22.29,86.39 21.54,86.39 21.28,86.13 20.05,86.13 19.78,86.4 19.77,86.4 19.69,86.49 18.97,86.49 18.9,86.56 18.9,87.19 18.97,87.27 20.05,87.27
+3.3V_RUN_AUDIO on IN3 (solid shape): outline of 886 points within 20.09,85.9 36.12,103.55
+3.3V_RUN_CARD on TOP (solid shape): 311.16,61.15 311.16,59.57 310.78,59.18 310.78,58.41 310.97,58.22 310.97,57.71 310.92,57.66 310.21,57.66 310.07,57.8 310.07,57.99 309.74,58.32 309.74,59.17 309.92,59.35 310.53,59.35 310.96,59.78 310.96,61.15 311.02,61.22 311.1,61.22
+3.3V_RUN_CARD on BOTTOM (solid shape): 299.09,60.83 299.09,59.64 298.93,59.48 298.23,59.48 298.14,59.57 298.14,60.11 298,60.26 297.16,60.26 297,60.42 297,61.11 297.09,61.2 298.72,61.2
+3.3V_RUN_CARD on IN3 (solid shape): outline of 1284 points within 297.56,55.95 312.33,62.7
+3.3V_RUN_UN3 on TOP (solid shape): 305.59,51.34 305.59,49.29 305.03,49.29 305.03,48.81 305.59,48.81 305.59,47.79 305.4,47.6 303.59,47.6 303.48,47.72 303.48,48.26 303.54,48.33 303.96,48.33 304.3,48.67 304.3,51.49 304.34,51.53 305.4,51.53
+3.3V_RUN_UZ9 on TOP (solid shape): 222.42,92.52 223.88,92.52 224,92.4 224,89.54 223.69,89.22 219.01,89.22 218.25,89.98 217.41,89.98 217.34,90.06 217.34,90.83 217.94,91.44 217.94,92.36 218.1,92.52 220.89,92.52 220.89,93.03 221.21,93.03 221.21,92.52 222.03,92.52 222.03,93.09 222.42,93.09
+3.3V_RUN_VDDA on TOP (solid shape): 169.59,88.2 169.59,86.83 169.08,86.83 169.07,86.84 168.74,86.84 168.69,86.8 168.68,86.79 168.59,86.73 168.53,86.64 168.53,86.63 168.37,86.48 167.82,86.48 167.36,86.94 167.36,88.25 167.53,88.42 169.36,88.42
+3.3V_RUN_VDDA on IN2 (solid shape): outline of 1413 points within 156.76,89.22 169.42,100.98
+3.3V_RUN_VDDA on IN4 (solid shape): outline of 1197 points within 157.85,82.67 169.42,98.17
+3.3V_RUN_VDDIO on TOP (solid shape): 151.19,101.39 151.19,100.49 151.43,100.26 151.43,99.18 151.32,99.08 150.62,99.08 150.53,99.16 150.53,100.27 150.04,100.76 150.04,101.55 150.14,101.65 150.93,101.65
+3.3V_RUN_VDDIO on IN3 (solid shape): outline of 407 points within 157.99,90.44 168.66,93.23
+3.3V_RUN_VDDIO on IN3 (solid shape): outline of 884 points within 150.53,96.61 168.61,101.81
+3.3V_RUN_VDDIO on IN4 (solid shape): 164.68,97.61 164.66,97.57 164.62,97.35 164.72,97.15 164.75,97.08 164.72,97.01 164.72,96.5 165.23,96.51 165.3,96.54 165.37,96.51 165.57,96.4 165.79,96.44 165.82,96.46 165.93,96.35 165.93,92.92 166.19,92.66 166.19,92.01 165.4,91.23 163.49,91.23 163.39,91.33 163.39,92.38 163.53,92.53 163.56,92.52 163.73,92.51 163.88,92.57 164.11,92.57 164.32,92.5 164.53,92.57 164.86,92.57 165.1,92.81 165.1,95.3 163.69,96.71 163.69,96.79 163.45,97.03 163.45,97.64 163.7,97.89 164.39,97.89
+3.3V_RUN_VMM on TOP (solid shape): 172.92,90.24 172.92,89.11 172.97,89.05 173.42,89.05 173.47,89 173.47,88.92 173.43,88.88 172.96,88.88 172.91,88.83 172.91,88.46 172.58,88.12 170.78,88.12 170.35,87.7 170.35,86.89 170.24,86.78 169.79,86.78 169.72,86.85 169.72,88.37 170.03,88.68 170.03,90.35 170.2,90.52 172.64,90.52
+3.3V_RUN_VMM on IN2 (solid shape): outline of 811 points within 148.32,88.01 172.55,105.21
+3.3V_SUS on TOP (solid shape): 271.07,57.14 271.07,56.64 271.11,56.61 271.5,56.61 271.55,56.66 271.55,57.14 271.59,57.18 272.07,57.18 272.16,57.09 272.16,55.44 271.59,54.87 270.87,54.87 270.66,55.07 270.66,55.25 270.23,55.68 270.23,57.03 270.36,57.16 270.8,57.16 270.81,57.18 271.03,57.18
+3.3V_SUS on TOP (solid shape): 240.39,19.13 240.39,17.47 240.14,17.22 238.21,17.22 238.11,17.12 236.65,17.12 236.58,17.19 236.58,18.4 236.64,18.46 238.42,18.46 238.48,18.39 239.66,18.39 239.76,18.49 239.76,19 239.93,19.17 240.35,19.17
+3.3V_SUS on TOP (solid shape): 191.86,97.92 191.86,97.14 191.78,97.07 190.83,97.07 190.42,96.66 190.42,95.32 190.41,95.3 190.41,95.23 190.4,95.19 190.36,95.18 190.27,95.18 190.22,95.23 190.22,96.64 190.22,96.64 190.25,96.81 190.22,96.98 190.22,96.99 190.22,97.13 190.21,97.14 190.21,97.51 190.31,97.61 190.31,98.04 190.45,98.18 191.6,98.18
+3.3V_SUS on BOTTOM (solid shape): 192.34,97.5 192.34,95.65 192.15,95.46 191,95.46 190.77,95.68 190.77,96.46 190.27,96.96 190.27,97.54 190.4,97.68 192.16,97.68
+3.3V_SUS on IN2 (solid shape): outline of 1038 points within 270.33,54.57 279.18,96.78
+3.3V_SUS on IN3 (solid shape): 275.22,96.36 275.22,95.67 274.02,94.47 272.94,94.47 272.69,94.71 272.69,96.08 273.19,96.57 275.01,96.57
+3.3V_SUS on IN3 (solid shape): outline of 627 points within 183.82,89.39 195.73,97.86
+3.3V_SUS_UZ3 on TOP (solid shape): 273.91,59.79 273.91,59.12 273.37,58.57 273.37,57.2 273.3,57.14 272.72,57.14 272.54,57.32 271.42,57.32 271.4,57.29 271.4,56.78 271.37,56.76 271.25,56.76 271.22,56.78 271.22,57.25 271.16,57.32 270.69,57.32 270.59,57.42 270.59,58.04 270.75,58.21 271.02,58.21 271.64,58.82 271.64,59.35 272.17,59.88 273.82,59.88
+3.3V_TP on TOP (solid shape): outline of 157 points within 233.21,31.19 240.45,38.61
+3.3V_WLAN on TOP (solid shape): 270.66,50.36 270.66,49.37 270.85,49.18 270.85,48.49 270.79,48.43 269.67,48.43 269.46,48.64 269.46,50.26 269.76,50.57 270.45,50.57
+3.3V_WLAN on TOP (solid shape): 277.67,57.15 277.67,56.63 277.7,56.61 278.12,56.61 278.16,56.64 278.16,57.14 278.18,57.17 279.23,57.17 279.55,56.85 279.55,54.96 279.35,54.75 279.25,54.75 279.23,54.74 277.44,54.74 277.12,55.06 277.12,57.11 277.2,57.19 277.63,57.19
+3.3V_WLAN on BOTTOM (solid shape): 270.68,51.63 270.68,51.12 270.42,50.87 270.42,50.5 270.69,50.23 270.69,49.35 270.78,49.27 270.78,47.78 270.65,47.65 269.2,47.65 269.04,47.82 269.04,51.11 268.99,51.15 269,51.15 269,51.73 269.02,51.76 270.55,51.76
+3.3V_WLAN on BOTTOM (solid shape): 289.15,51.4 289.15,48.48 288.86,48.19 288.37,48.19 288.18,48 287.55,48 287.43,48.12 287.43,49.19 287.52,49.28 287.52,49.8 286.4,50.92 286.4,51.36 286.49,51.45 289.1,51.45
+3.3V_WLAN on IN3 (solid shape): outline of 1167 points within 269.47,49.23 289.32,55.95
+3.3V_WLAN_UZ3 on TOP (solid shape): 276.8,59.78 276.8,59.38 277.18,58.99 278.08,58.99 278.51,58.56 278.51,57.36 278.47,57.32 278.04,57.32 278,57.28 278,56.77 277.99,56.76 277.84,56.76 277.83,56.77 277.83,57.27 277.76,57.33 277.41,57.33 277.38,57.36 276.95,57.36 276.76,57.17 275.86,57.17 275.83,57.19 275.83,58.16 275.31,58.68 275.31,59.86 275.36,59.91 276.67,59.91
+3.3V_WWAN on TOP (solid shape): 284.33,101.93 284.33,100.12 284.63,99.81 284.63,98.75 284.51,98.62 281.47,98.62 281.34,98.75 281.34,101.41 281.98,102.05 284.21,102.05
+3.3V_WWAN on TOP (solid shape): 267.7,79.15 267.7,78.34 267.53,78.16 267.53,77.4 267.21,77.08 267.13,77.08 267.12,77.09 266.75,77.09 266.66,77.18 266.66,77.66 266.65,77.68 266.19,77.68 266.17,77.65 266.17,77.12 266.14,77.09 265.85,77.09 265.7,77.24 265.7,78.97 265.95,79.23 267.63,79.23
+3.3V_WWAN on BOTTOM (solid shape): 298.88,82.44 298.88,79.09 297.95,78.16 293.12,78.16 292.62,77.66 289.46,77.66 289.08,78.04 289.08,80.66 289.17,80.76 292.14,80.76 294.04,82.65 298.67,82.65
+3.3V_WWAN on BOTTOM (solid shape): 285.32,101.97 285.32,100.76 285.25,100.7 283.76,100.7 283.6,100.85 282.87,100.85 282.52,100.51 282.52,98.81 282.41,98.69 280.68,98.69 280.48,98.9 280.48,101.49 281.03,102.03 285.25,102.03
+3.3V_WWAN on BOTTOM (solid shape): outline of 191 points within 281.66,79.99 285.41,85.23
+3.3V_WWAN on IN3 (solid shape): outline of 1172 points within 265.58,70.81 293.37,100.71
+3.3V_WWAN_UZ2 on TOP (solid shape): 266.5,77.5 266.5,76.99 266.52,76.96 267.07,76.96 268.07,75.96 268.07,74.68 268.02,74.63 267.41,74.63 267.34,74.7 266.2,74.7 266.17,74.74 266.17,75.25 266.23,75.31 266.23,75.94 265.9,76.27 265.9,76.94 265.93,76.96 266.29,76.96 266.32,76.99 266.32,77.5 266.34,77.52 266.47,77.52
+3V5V_PWR_SRC on TOP (solid shape): 209.21,71.57 209.21,61.53 208.95,61.28 205.27,61.28 205.02,61.53 205.02,70.81 205.91,71.69 209.08,71.69
+3V5V_PWR_SRC on TOP (solid shape): 216.24,64.35 217.39,64.35 217.41,64.33 217.41,64.18 217.36,64.12 216.17,64.12 215.84,64.26 215.54,64.07 214.72,64.07 214.41,64.38 214.41,65.6 214.48,65.66 214.93,65.66
+3V5V_PWR_SRC on BOTTOM (solid shape): 204,68.14 204.89,68.14 204.89,68.65 208.83,68.65 209.21,68.27 209.21,65.09 208.95,64.84 202.22,64.84 201.97,65.09 201.97,68.39 202.1,68.52 202.86,68.52 202.86,68.14 203.62,68.14 203.62,68.65 204,68.65
+5V_ALW on TOP (solid shape): 308.94,76.48 308.94,74.55 308.66,74.27 307.2,74.27 307,74.48 307,76.6 307.09,76.69 308.74,76.69
+5V_ALW on TOP (solid shape): 215.94,88.64 215.94,87.2 215.93,87.19 215.91,87.06 215.93,86.93 215.94,86.92 215.94,85.54 215.87,85.47 213.4,85.47 213.33,85.54 213.33,88.37 213.68,88.71 215.86,88.71
+5V_ALW on TOP (solid shape): 55.85,103.96 57.19,103.96 57.34,103.81 57.34,103.08 57.19,102.92 55.4,102.92 55.13,102.66 55.13,102.4 55.04,102.31 54.41,102.31 54.3,102.21 54.3,100.81 54.2,100.71 53.07,100.71 52.84,100.94 52.84,103.72 53.15,104.03 55.79,104.03
+5V_ALW on BOTTOM (solid shape): 225.02,58.74 225.02,54.23 224.7,53.91 221.59,53.91 221.4,54.1 221.4,54.93 221.91,54.93 221.91,55.82 221.4,55.82 221.4,56.07 221.91,56.07 221.91,56.96 221.4,56.96 221.4,58.74 221.65,58.99 224.76,58.99
+5V_ALW on BOTTOM (solid shape): outline of 515 points within 247.07,96.78 256.96,117.43
+5V_ALW on IN1 (solid shape): outline of 215 points within 38.13,80.65 44.56,101.25
+5V_ALW on IN1 (solid shape): outline of 521 points within 289.1,66.77 309.02,80.11
+5V_ALW on IN2 (solid shape): outline of 346 points within 42.46,98.83 77.17,102.78
+5V_ALW on IN4 (solid shape): outline of 420 points within 53.01,100.45 77.58,103.52
+5V_ALW on VCC: 223.79,55.06 223.43,55.42 223.43,60.41 224.96,61.94 224.96,87.04 223.92,88.08 217.61,88.08 216.95,87.42 216.95,85.9 216.21,85.16 209.31,85.16 190.14,104.33 175.02,104.33 173.63,105.73 132.77,105.73 126.68,99.63 111.95,99.63 106.87,94.55 99.63,94.55 93.28,88.2 83.33,88.2 75.6,95.93 75.6,102.45 76.22,103.06 78.67,103.06 83.12,98.62 96.03,98.62 97.43,100.02 105.17,100.02 108.73,103.57 125.75,103.57 133.87,111.7 137.73,111.7 138.36,111.06 182.94,111.06 185.1,108.91 192.34,108.91 206.88,94.36 233.38,94.36 239.54,100.52 261.93,100.52 290.36,72.1 290.36,65.07 289.75,64.46 277,64.46 273.09,68.37 273.09,72.69 264.71,81.07 264.71,87.8 262.4,90.11 256.94,90.11 255.41,91.63 251.01,91.63 247.71,88.33 244.41,88.33 243.5,87.42 243.5,83.02 244.13,82.38 244.13,79.55 241.21,76.63 241.21,59.99 236.28,55.06 ; 1 cut-out
+5V_ALWP on BOTTOM (solid shape): 221.15,56.77 221.65,56.77 221.65,56.39 221.15,56.39 221.15,55.5 221.65,55.5 221.65,55.18 221.15,55.18 221.15,53.41 220.64,52.9 215.56,52.9 214.97,53.48 207.02,53.48 206.87,53.63 206.87,56.3 206.97,56.4 211.09,56.4 212.05,57.37 221.15,57.37
+5V_HDD on BOTTOM (solid shape): 311.2,41.61 311.2,39.39 311,39.19 310.03,39.19 309.83,39.39 309.83,41.67 309.93,41.77 311.04,41.77
+5V_HDD on BOTTOM (solid shape): 293.46,36.26 293.46,34.55 293.66,34.34 293.66,33.3 293.7,33.26 294.2,33.26 294.22,33.24 294.22,33.1 294.21,33.09 293.7,33.09 293.66,33.05 293.66,32.68 293.56,32.58 292.32,32.58 291.82,33.07 291.82,35.84 292.34,36.36 293.36,36.36
+5V_HDD on IN2 (solid shape): outline of 295 points within 291.58,32.2 312.29,40.59
+5V_RUN on TOP (solid shape): 274.55,109.43 274.55,107.45 274.2,107.11 272.26,107.11 272.12,107.25 272.12,108.02 272.12,108.02 272.12,109.46 272.27,109.61 274.37,109.61
+5V_RUN on TOP (solid shape): 90.87,59.81 90.87,59.45 90.08,58.66 90.08,58.11 91,57.19 91,56.07 90.69,55.77 90.28,55.77 89.07,56.99 89.07,57.93 89.32,58.18 89.32,58.64 89.62,58.94 89.62,59.76 89.8,59.93 90.74,59.93
+5V_RUN on TOP (solid shape): 214.03,95.13 214.03,93.47 213.84,93.28 212.89,93.28 212.89,92.78 212.57,92.78 212.57,93.28 211.68,93.28 211.68,92.78 211.37,92.78 211.37,93.28 210.54,93.28 210.41,93.41 210.41,95.25 210.54,95.38 213.78,95.38
+5V_RUN on TOP (solid shape): 238.58,15.06 239.47,15.06 239.71,14.82 240.4,14.82 240.45,14.77 240.45,14 240.36,13.91 239.06,13.91 237.84,15.13 236.72,15.13 236.61,15.25 236.61,15.4 236.68,15.47 238.18,15.47
+5V_RUN on TOP (solid shape): 100.36,108.02 100.36,107.97 100.38,107.94 100.38,105.46 100.52,105.32 100.52,103.63 100.39,103.51 99.67,103.51 99.52,103.36 99.52,102.67 99.05,102.21 97.97,102.21 97.73,101.96 97.37,101.96 97.21,102.12 95.99,102.12 95.78,102.33 95.78,102.92 96.3,103.44 96.3,104.16 96.18,104.28 95.61,104.28 95.52,104.37 95.52,104.98 95.57,105.03 96.18,105.03 96.28,104.93 99.2,104.93 99.53,105.26 99.53,106.19 98.87,106.85 98.87,108.19 98.96,108.28 100.09,108.28
+5V_RUN on TOP (solid shape): outline of 201 points within 102.02,95.7 138.21,111.95
+5V_RUN on TOP (solid shape): outline of 280 points within 291,63.97 299.82,92.59
+5V_RUN on BOTTOM (solid shape): 72.71,76.57 72.71,75.89 72.53,75.71 70.98,75.71 70.75,75.94 70.75,76.55 70.93,76.72 72.56,76.72
+5V_RUN on BOTTOM (solid shape): 104.94,96.64 105.79,96.64 105.85,96.57 105.85,96.34 105.38,95.87 105.38,95.79 105.37,95.79 105.37,94.77 105.02,94.41 103.78,94.41 103.12,95.07 103.12,96.76 103.45,97.09 104.48,97.09
+5V_RUN on BOTTOM (solid shape): 296.68,33.64 296.68,32.78 296.56,32.65 293.87,32.65 293.8,32.72 293.8,32.87 293.87,32.93 294.13,32.93 294.14,32.92 294.3,32.92 294.39,33.01 294.39,33.37 294.34,33.42 293.89,33.42 293.83,33.48 293.83,33.63 293.88,33.68 294.59,33.68 294.68,33.77 296.56,33.77
+5V_RUN on BOTTOM (solid shape): 201.43,105.39 201.43,98.94 201.74,98.63 208.95,98.63 210.68,96.9 213.46,96.9 213.84,96.52 213.84,93.92 213.69,93.77 208.72,93.77 208.46,94.03 198.29,94.03 197.42,94.9 197.42,100.95 197.42,100.95 197.42,101.73 197.42,101.75 197.42,103.26 197.46,103.34 197.54,103.36 197.94,103.56 197.87,104.01 197.42,104.45 197.42,104.76 197.49,104.89 197.51,105.04 197.51,105.22 197.49,105.37 197.42,105.5 197.42,105.73 197.85,106.16 200.66,106.16
+5V_RUN on BOTTOM (solid shape): 85,66.08 87.08,66.08 87.19,65.99 87.32,65.93 87.34,65.93 87.35,65.91 87.78,65.91 91.3,62.4 91.3,58.99 90.77,58.46 90.77,56.76 90.54,56.53 89.73,56.53 89.07,57.19 89.07,58.16 89.6,58.69 89.6,59.66 89.6,59.67 89.66,60.4 89.6,61.13 89.6,61.14 89.6,61.6 89.61,61.63 89.65,61.65 89.97,62.14 89.4,62.27 89.31,62.25 89.24,62.3 86.41,64.74 82.71,64.21 82.7,64.2 82.64,64.2 81.45,65.39 81.45,66.06 82.11,66.72 84.37,66.72
+5V_RUN on BOTTOM (solid shape): outline of 183 points within 32.4,83.36 38.57,91.95
+5V_RUN on IN1 (solid shape): outline of 284 points within 44.16,75.61 72.05,82.18
+5V_RUN on IN1 (solid shape): outline of 546 points within 34.81,89.23 46.8,104.96
+5V_RUN on IN2 (solid shape): outline of 389 points within 93.29,95.6 106.26,103.11
+5V_RUN on IN3 (solid shape): outline of 1905 points within 45.2,97.41 98.02,104.84
+5V_RUN on IN3 (solid shape): outline of 2315 points within 294.28,32.03 318.47,69.9
+5V_RUN on IN3 (solid shape): outline of 5242 points within 135.86,100.78 274.87,113.12
+5V_RUN on IN4 (solid shape): outline of 252 points within 96.37,103.62 138.53,112.21
+5V_RUN on IN4 (solid shape): outline of 554 points within 272.71,89.93 293.49,109.22
+5V_RUN_AUDIO on BOTTOM (solid shape): outline of 285 points within 22.21,80.23 37.1,94.38
+5V_RUN_PVDD on TOP (solid shape): 26.2,92.19 26.2,90.77 25.96,90.53 25.96,90.48 25.95,90.46 25.95,90.21 25.77,90.03 25.54,90.03 25.45,90.12 25.45,90.68 26,91.23 26,92.14 26.07,92.22 26.17,92.22
+5V_RUN_PVDD on TOP (solid shape): 28.21,92.19 28.21,91.38 28.73,90.86 29.11,90.86 29.43,90.54 29.43,90.26 29.45,90.24 29.45,89.91 29.39,89.84 29.11,89.84 28.99,89.96 28.99,90.08 28.51,90.57 28.51,90.82 28.33,91 28.26,91 28,91.25 28,92.14 28.08,92.22 28.18,92.22
+5V_RUN_PVDD on BOTTOM (solid shape): 26.28,94.15 26.28,93.31 26.48,93.11 26.84,93.11 26.91,93.03 26.91,92.42 27.25,92.08 28.96,92.08 29.15,92.27 29.78,92.27 30.06,91.99 30.06,91.01 30.02,90.93 29.94,90.91 29.5,90.57 29.94,90.22 30.02,90.2 30.06,90.12 30.06,88.61 29.96,88.51 29.02,88.51 28.61,88.92 28.61,89.69 28.64,89.7 28.84,90.02 28.64,90.34 28.61,90.35 28.61,90.46 28.51,90.57 28.51,90.58 28.24,90.89 27.86,90.74 27.76,90.74 27.74,90.76 27.51,90.83 27.28,90.74 27.07,90.74 27.06,90.75 26.94,90.77 26.81,90.75 26.8,90.74 26.3,90.74 25.95,90.39 25.95,90.16 25.84,90.05 25.34,90.05 25.26,90.14 25.26,92.04 24.84,92.46 24.84,94.24 24.96,94.35 26.07,94.35
+5V_RUN_UZ9 on TOP (solid shape): 211.05,92.59 211.11,92.52 211.94,92.52 211.94,93.03 212.32,93.03 212.32,92.59 212.38,92.52 213.21,92.52 213.21,93.03 213.78,93.03 214.32,92.49 215.61,92.49 215.65,92.46 215.65,91.4 215.94,91.11 215.94,90.13 215.79,89.98 210.59,89.98 209.91,90.67 209.91,92.9 210.03,93.03 211.05,93.03
+5V_TSP on BOTTOM (solid shape): outline of 105 points within 101.26,96.84 106.15,101.56
+5V_USB_CHG_PWR on TOP (solid shape): 310.71,82.46 310.8,82.41 310.79,82.31 311.09,81.75 311.38,82.31 311.38,82.41 311.47,82.46 313.08,82.46 314.44,81.1 314.44,80.29 314.16,80.01 311.57,80.01 310.92,79.36 310.92,78.51 310.65,78.25 310.05,78.25 309.88,78.41 308.07,78.41 308.03,78.46 308.01,78.46 307.99,78.47 307.96,78.5 307.96,78.84 308.8,79.68 308.8,82.06 309.21,82.46
+GND_CHASSIS on TOP (solid shape): 306.49,99.38 306.49,98.75 306.24,98.49 296.96,98.49 296.84,98.62 296.84,99.47 297,99.63 306.24,99.63
+GND_CHASSIS on TOP (solid shape): 319.93,101.51 319.93,100.61 319.75,100.43 317.88,100.43 317.79,100.52 317.79,101.41 318.01,101.63 319.82,101.63
+GND_CHASSIS on BOTTOM (solid shape): 320.87,101.53 320.87,99.34 320.73,99.2 318.36,99.2 318.27,99.28 318.27,101.43 318.44,101.6 320.8,101.6
+V1.05SP_B+ on BOTTOM (solid shape): 220.13,52.52 220.13,51.95 219.56,51.95 219.56,51.31 220.13,51.31 220.13,51.12 219.56,51.12 219.56,50.49 220.07,50.49 220.07,48.71 219.88,48.52 218.41,48.52 218.16,48.26 218.16,47.56 217.91,47.31 216.51,47.31 216.45,47.37 216.45,49.37 216.69,49.61 216.69,52.5 216.83,52.64 220,52.64
+VCC_CORE on TOP (solid shape): outline of 4101 points within 126.19,55.46 154.22,89.03
+VCC_CORE on BOTTOM (solid shape): 146.22,84.39 146.23,84.38 146.24,84.33 146.2,84.29 146.02,83.72 146.61,83.8 146.69,83.86 146.78,83.83 146.85,83.76 146.85,83.09 146.85,80.27 146.66,80.08 143.23,80.08 142.97,80.33 142.97,80.69 142.98,80.76 142.97,80.83 142.97,81.35 142.98,81.42 142.97,81.49 142.97,81.87 142.97,81.87 142.97,81.99 142.98,82.08 142.97,82.18 142.97,82.65 142.98,82.74 142.97,82.84 142.97,83.06 142.65,83.38 137.85,83.38 137.82,83.41 136.88,83.41 136.71,83.24 136.71,80.47 136.32,80.08 131.67,80.08 131.48,79.89 131.48,79.76 131.41,79.68 131.41,78.49 131.61,78.28 146.59,78.28 146.76,78.12 148.55,78.12 148.82,77.85 148.82,76.58 148.69,76.46 131.17,76.46 131.04,76.58 131.04,77.66 130.94,77.76 128.71,77.76 128.71,77.77 128.61,77.68 125.88,77.68 125.56,77.99 125.56,81.32 125.69,81.45 128.04,81.45 128.05,81.46 128.05,82.25 128.03,82.27 125.73,82.27 125.68,82.32 125.68,83.38 127.34,85.04 145.57,85.04
+VCC_CORE on BOTTOM (solid shape): outline of 1634 points within 133.72,55.45 156.21,68.42
+VCC_CORE on IN2 (solid shape): 136.77,84.06 136.77,80.41 136.39,80.03 131.69,80.03 131.41,79.75 131.41,78.45 131.91,77.94 141.82,77.94 142.2,77.56 142.2,76.82 141.91,76.53 129.39,76.53 128.77,77.16 128.77,83.91 129.32,84.47 136.36,84.47
+VCC_CORE on IN3 (solid shape): outline of 5177 points within 126.29,57.24 154.5,86.98
+VCC_CORE on VCC: 132.37,57.72 132.37,70.4 127.04,75.74 127.04,80.86 128.79,82.62 134.91,82.62 135.3,82.31 135.69,82.62 135.98,82.62 136.29,82.45 136.6,82.62 144.42,82.62 144.96,83.16 148.36,83.16 148.63,82.89 148.63,78.7 153.71,73.62 153.71,66.38 153.55,66.03 153.71,65.68 153.71,57.72
+VCC_PWR_SRC on TOP (solid shape): 127.51,92.43 127.51,91.07 127.31,90.87 122.72,90.87 122.66,90.81 121.3,90.81 121.22,90.88 121.22,91.3 122.63,92.71 127.23,92.71
+VCC_PWR_SRC on BOTTOM (solid shape): 128.77,94.91 128.77,92.6 129.22,92.14 129.39,92.14 129.51,92.01 129.51,91.58 129.51,91.57 129.51,90.88 129.51,90.81 129.45,90.74 125.47,90.74 125.26,90.81 125.05,90.74 124.26,90.74 124.05,90.81 123.84,90.74 123.63,90.74 123.42,90.81 123.21,90.74 118.79,90.74 118.73,90.68 115.42,90.68 115.1,91 113.83,91 113.83,91.51 113,91.51 113,91 112.62,91 112.62,91.51 111.8,91.51 111.8,91.06 111.73,91 110.97,91 110.78,91.19 110.78,94.81 111.16,95.19 128.49,95.19
+VDDA_AVDD1 on BOTTOM (solid shape): 23.14,98.8 23.14,98.34 23.01,98.22 23.01,97.91 23,97.87 22.97,97.86 22.68,97.65 22.71,97.29 22.72,97.19 22.63,97.13 21.92,97.13 21.83,97.22 21.83,97.78 21.6,98.01 21.26,98.01 21.07,98.2 21.07,98.83 21.13,98.9 23.04,98.9
+VDDA_PVDD on TOP (solid shape): 22.47,89.99 22.47,89.8 22.07,89.41 21.3,89.41 21.21,89.32 21.21,88.71 21.08,88.59 18.96,88.59 18.88,88.66 18.88,89.44 18.95,89.5 19.78,89.5 20.38,90.1 22.36,90.1
+VDDA_PVDD on BOTTOM (solid shape): 22.49,89.99 22.49,88.03 22.38,87.91 21.41,87.91 21.23,88.09 21.23,90.03 21.31,90.11 22.38,90.11
GND on TOP (solid shape): 328.97,44.26 327.95,44.26 327.95,73.98 328.97,73.98
GND on TOP (solid shape): 55.28,105.91 55.28,104.87 55.14,104.73 54.27,104.73 54.17,104.83 54.17,105.84 54.32,106 55.19,106
GND on TOP (solid shape): 60.87,90.68 60.87,89.41 60.81,89.35 59.6,89.35 59.03,89.92 59.03,91.44 59.09,91.51 60.05,91.51
GND on TOP (solid shape): 81.39,76.16 81.39,75.53 81.29,75.43 80.23,75.43 80.12,75.53 80.12,76.25 80.19,76.32 81.24,76.32
GND on TOP (solid shape): 87.11,81.3 87.11,80.03 86.73,79.64 84.14,79.64 84,79.78 84,81.23 84.23,81.46 86.94,81.46
GND on TOP (solid shape): 206.76,53.19 206.76,51.77 206.68,51.69 202.07,51.69 201.96,51.81 201.96,53.13 202.11,53.28 206.67,53.28
GND on TOP (solid shape): 247.77,62.61 247.77,61.57 247.68,61.47 246.63,61.47 246.49,61.61 246.49,62.52 246.66,62.69 247.69,62.69
GND on TOP (solid shape): 303.33,68.38 303.33,67.3 303.21,67.19 301.89,67.19 301.62,67.45 301.62,68.31 301.82,68.5 303.21,68.5
GND on TOP (solid shape): 303.54,60.26 303.54,59.32 303.52,59.3 302.04,59.3 301.9,59.44 301.9,60.19 302.08,60.37 303.44,60.37
GND on TOP (solid shape): 277.5,93.79 277.5,92.63 277,92.13 276.31,92.13 275.64,92.8 275.64,93.8 275.73,93.89 277.39,93.89
GND on TOP (solid shape): 11.9,96.23 11.9,95.76 11.18,95.04 10.87,95.04 10.57,95.33 10.57,95.51 10.74,95.67 10.74,95.68 11.41,96.35 11.78,96.35
GND on TOP (solid shape): 98.91,77.97 98.91,75.95 98.78,75.82 94.2,75.82 93.57,76.44 93.57,77.77 93.83,78.03 98.86,78.03
GND on TOP (solid shape): 109.52,18.7 109.52,14.55 108.95,13.99 105.37,13.99 105.05,14.3 105.05,18.23 106.03,19.2 109.02,19.2
GND on TOP (solid shape): 157.11,84.03 157.11,83.43 156.93,83.25 154.86,83.25 154.74,83.38 154.74,84.04 154.84,84.14 157,84.14
GND on TOP (solid shape): 271.23,47.46 271.23,46.62 271.06,46.45 270.04,46.45 269.75,46.74 269.75,47.67 269.82,47.74 270.95,47.74
GND on TOP (solid shape): 114.85,87.38 114.85,85.16 114.66,84.97 112.98,84.97 112.71,84.69 111.56,84.69 111.23,85.03 111.23,87.04 111.66,87.46 114.76,87.46
GND on TOP (solid shape): 80.68,68.96 80.68,67.69 80.62,67.63 79.73,67.63 79.67,67.69 79.67,68.33 79.16,68.33 79.16,68.46 79.67,68.46 79.67,68.9 79.79,69.03 80.62,69.03
GND on TOP (solid shape): 214.1,18.58 214.1,14.32 213.64,13.86 209.5,13.86 209.11,14.25 209.11,18.6 209.38,18.87 213.8,18.87
GND on TOP (solid shape): 313.97,70.82 313.97,69.99 313.92,69.94 311.59,69.94 311.51,70.02 311.51,70.84 311.55,70.87 313.91,70.87
GND on TOP (solid shape): 92.84,100.6 92.84,99.88 92.72,99.76 91.29,99.76 90.71,99.18 90.25,99.18 90.18,99.25 90.18,100.5 90.37,100.69 92.75,100.69
GND on TOP (solid shape): 247.22,88.23 247.22,86.87 247.09,86.74 246.04,86.74 245.91,86.87 245.91,88.25 246,88.34 247.1,88.34
GND on TOP (solid shape): 288.35,99.66 288.35,98.45 287.9,98 285.54,98 285.24,98.3 285.24,99.74 285.38,99.88 288.14,99.88
GND on TOP (solid shape): 98.71,108.59 98.71,106.76 99.37,106.1 99.37,105.29 99.17,105.1 98.02,105.1 97.8,105.31 97.8,106.56 97.05,107.3 97.05,108.96 97.15,109.05 98.25,109.05
GND on TOP (solid shape): 267.8,88.26 267.8,87.37 267.8,87.37 267.8,86.51 267.73,86.44 265.93,86.44 265.8,86.57 265.8,87.51 266.27,87.98 266.81,87.98 267.13,88.29 267.77,88.29
GND on TOP (solid shape): 272.14,88.76 272.14,87.37 271.89,87.12 271.18,87.12 271.02,86.96 271.02,86.56 270.88,86.42 270.54,86.42 270.42,86.54 270.42,87.68 271.02,88.28 271.02,89.11 271.06,89.14 271.75,89.14
GND on TOP (solid shape): 107.86,72.08 107.86,71.57 107.35,71.06 107.35,69.54 107.1,69.28 102.27,69.28 102.02,69.54 102.02,71.19 102.02,71.2 102.05,71.34 102.02,71.49 102.02,71.5 102.02,72.08 102.15,72.2 107.73,72.2
GND on TOP (solid shape): 248.58,34.23 248.58,32.58 248.45,32.45 247.43,32.45 247.18,32.2 247.18,29.78 247.05,29.66 246.04,29.66 245.78,29.4 245.78,28.39 245.66,28.26 242.74,28.26 242.35,28.64 242.35,31.09 241.63,31.82 241.63,34.11 241.74,34.23 246.8,34.23 246.93,34.36 248.45,34.36
GND on TOP (solid shape): 268.29,60.87 268.32,60.8 268.29,60.73 268.22,60.44 268.4,60.19 268.43,60.18 268.43,59.74 268.27,59.59 266.81,59.59 266.69,59.72 266.69,61.05 266.79,61.15 268.01,61.15
GND on TOP (solid shape): 138.85,82.97 138.85,79.97 139.06,79.76 141.19,79.76 141.36,79.94 141.36,82.92 141.49,83.05 142.86,83.05 142.91,83 142.91,79.95 143.1,79.76 146.91,79.76 147.12,79.56 147.12,78.31 147,78.2 146.8,78.2 146.56,78.44 136.55,78.44 136.41,78.58 136.41,79.66 136.51,79.76 136.94,79.76 137.15,79.96 137.15,82.95 137.33,83.12 138.7,83.12
GND on TOP (solid shape): 130.98,90.43 130.98,88.59 130.85,88.46 129.9,88.46 129.77,88.33 129.77,87.44 129.71,87.38 128.98,87.38 127.84,86.24 127.4,86.24 125.98,84.83 125.98,78.93 125.47,78.42 121.32,78.42 120.69,79.05 120.69,84.75 120.99,85.05 122.66,85.05 123.46,85.85 123.46,87.94 123.41,87.94 123.4,87.94 124.54,87.94 124.54,86.18 124.75,85.97 126.33,85.97 126.64,86.28 126.64,87.94 126.46,88.13 124.72,88.13 124.54,87.94 123.4,87.94 123.27,88.08 123.23,88.08 121.98,88.08 121.98,88.08 121.77,88.08 121.7,88.01 121.7,87.76 121.51,87.57 120.56,87.57 120.56,90.11 121.01,90.55 122.72,90.55 122.85,90.68 130.72,90.68
GND on TOP (solid shape): 309.32,85.92 309.58,85.66 309.93,85.77 310,85.8 310.07,85.77 310.4,85.69 310.65,85.92 310.66,85.96 311.16,85.96 311.47,85.65 311.47,83.64 311.23,83.4 308.94,83.4 308.7,83.64 308.7,85.69 308.97,85.96 309.31,85.96
GND on TOP (solid shape): 211.75,70.3 211.75,69.28 211.87,69.15 212.08,69.15 212.08,69.15 213.2,69.15 213.2,69.15 213.4,69.15 213.53,69.28 214.29,69.28 214.41,69.15 214.41,66.04 214.16,65.79 214.16,64.07 214.41,63.82 214.41,61.15 212.89,61.15 212.76,61.28 212.76,62.17 212.51,62.42 210.73,62.42 210.6,62.55 210.6,62.83 210.61,62.88 210.62,62.92 210.62,63.5 210.61,63.54 210.6,63.59 210.6,63.82 210.48,63.95 210.4,63.95 209.46,63.95 209.33,64.07 209.33,70.17 209.59,70.42 211.62,70.42
GND on TOP (solid shape): 8.86,100.9 10.02,99.79 10.45,98.25 6.65,95.36 4.88,99.79 4.88,99.8 5.08,99.8 5.21,99.78 5.41,99.73 5.59,99.64 5.7,99.55 5.8,99.46 5.89,99.33 5.95,99.22 6,99.11 6.04,98.92 6.04,98.81 6.05,98.23 6.05,98.1 6.08,97.9 6.14,97.73 6.22,97.56 6.33,97.39 6.46,97.25 6.57,97.15 6.71,97.05 6.88,96.96 7.09,96.89 7.26,96.86 7.35,96.85 7.49,96.85 7.65,96.86 7.87,96.9 8.05,96.98 8.18,97.05 8.26,97.1 8.35,97.17 8.42,97.23 8.59,97.41 8.64,97.5 8.72,97.63 8.82,97.89 8.85,98.04 8.86,98.26
GND on TOP (solid shape): outline of 252 points within 81.19,79.63 94.37,88.84
GND on TOP (solid shape): outline of 268 points within 150.6,36.69 153.34,47.02
GND on TOP (solid shape): outline of 97 points within 9.1,99.84 61.2,121.95
GND on TOP (solid shape): outline of 488 points within 304.46,89.52 329.05,120.93
GND on TOP (solid shape): outline of 480 points within 142.71,0.41 150.03,14.44
GND on TOP (solid shape): outline of 546 points within 238.7,107.46 287.5,121.95
GND on TOP (solid shape): outline of 157 points within 71.46,106.21 228.38,122.16
GND on TOP (solid shape): outline of 1473 points within 90.74,0.36 109.69,10.74
GND on TOP (solid shape): outline of 3723 points within 20.88,0 329.05,79.5
GND on BOTTOM (solid shape): 57.38,95.32 57.38,93.86 57.32,93.79 55.73,93.79 55.66,93.86 55.66,95.32 55.73,95.38 57.32,95.38
GND on BOTTOM (solid shape): 82.96,69.05 82.96,67.36 82.8,67.21 80.24,67.21 79.98,67.46 79.98,69.19 80.03,69.23 82.78,69.23
GND on BOTTOM (solid shape): 213.36,85.89 213.36,83.78 212.71,83.14 211.47,83.14 211.4,83.2 211.4,86.08 211.57,86.25 213,86.25
GND on BOTTOM (solid shape): 219.21,72.86 219.21,70.32 218.86,69.97 216.22,69.97 215.99,70.2 215.99,73.09 216.24,73.35 218.73,73.35
GND on BOTTOM (solid shape): 228.24,106.49 228.24,105.01 227.99,104.75 225.44,104.75 225.27,104.92 225.27,106.47 225.43,106.62 228.12,106.62
GND on BOTTOM (solid shape): 229.4,62.87 229.4,61.47 229.34,61.41 227.88,61.41 227.75,61.53 227.75,62.87 227.88,62.99 229.27,62.99
GND on BOTTOM (solid shape): 237.99,106.59 237.99,105.22 237.77,105.01 235.95,105.01 235.57,105.39 235.57,106.26 236.02,106.71 237.87,106.71
GND on BOTTOM (solid shape): 238,93.77 238,91.34 237.77,91.11 236.41,91.11 236.28,91.24 236.28,93.89 236.33,93.94 237.82,93.94
GND on BOTTOM (solid shape): 245.58,30.48 245.58,27.83 244.22,26.47 241.73,26.47 241.34,26.86 241.34,30.36 241.73,30.75 245.31,30.75
GND on BOTTOM (solid shape): 302.64,42.22 302.64,40.29 302.54,40.19 301.03,40.19 300.94,40.27 300.94,41.84 301.42,42.32 302.54,42.32
GND on BOTTOM (solid shape): 314.79,42.24 314.79,40.27 314.55,40.03 312.9,40.03 312.79,40.15 312.79,42.57 312.84,42.62 314.41,42.62
GND on BOTTOM (solid shape): 315.23,37.66 315.23,36.32 314.97,36.07 312.6,36.07 312.56,36.11 312.56,37.72 312.74,37.9 314.99,37.9
GND on BOTTOM (solid shape): 320.87,97.16 320.87,95.22 320.64,94.99 318.45,94.99 318.27,95.17 318.27,97.32 318.37,97.42 320.62,97.42
GND on BOTTOM (solid shape): 38.35,99.96 38.35,97.55 38.25,97.45 36.72,97.45 36.6,97.56 36.6,100 36.64,100.04 38.28,100.04
GND on BOTTOM (solid shape): 98.81,77.79 98.81,75.99 98.58,75.76 94.22,75.76 93.7,76.28 93.7,77.79 93.95,78.04 98.56,78.04
GND on BOTTOM (solid shape): 298.97,86.3 298.97,83.42 298.59,83.04 296.98,83.04 296.32,83.7 296.32,86.07 296.84,86.59 298.68,86.59
GND on BOTTOM (solid shape): 65.42,101.78 65.42,100.13 65.32,100.03 63.42,100.03 63.3,100.15 63.3,101.7 63.55,101.96 65.24,101.96
GND on BOTTOM (solid shape): 94.18,57.41 95.05,56.07 95.05,54.47 94.34,53.76 93.29,53.76 92.41,54.64 91.4,56.26 91.4,56.91 92.56,58.07 93.52,58.07
GND on BOTTOM (solid shape): 191.86,45.57 191.86,42.13 191.76,42.03 189.43,42.03 189.31,42.15 189.31,45.58 189.47,45.75 191.68,45.75
GND on BOTTOM (solid shape): 206.81,53.2 206.81,51.82 206.68,51.69 202.74,51.69 201.99,51.69 201.94,51.74 201.94,53.16 202.06,53.28 206.73,53.28
GND on BOTTOM (solid shape): 229.73,49.57 229.73,48.54 229.53,48.34 227.8,48.34 227.8,49.58 227.89,49.67 229.63,49.67
GND on BOTTOM (solid shape): 248.8,119.99 248.8,118.18 248.61,117.99 247.21,117.99 246.99,118.21 246.99,120.01 247.13,120.16 248.64,120.16
GND on BOTTOM (solid shape): 258.14,42.66 258.14,41.68 257.71,41.25 256.87,41.25 256.46,41.66 256.46,42.61 256.59,42.74 258.06,42.74
GND on BOTTOM (solid shape): 258.17,38.97 258.17,38.18 258.11,38.13 257.1,38.13 256.72,38.51 256.72,38.85 256.88,39.02 258.11,39.02
GND on BOTTOM (solid shape): 288.16,80.5 288.16,76.25 287.88,75.97 286.66,75.97 286.49,76.15 286.49,80.62 286.54,80.67 287.99,80.67
GND on BOTTOM (solid shape): 54.29,100.41 54.29,97.74 54.01,97.46 51.1,97.46 50.99,97.58 50.99,100.19 51.35,100.55 54.15,100.55
GND on BOTTOM (solid shape): 114.97,86.81 114.97,85.28 114.85,85.16 113.2,85.16 112.77,84.73 111.6,84.73 111.35,84.97 111.35,86.62 111.67,86.93 114.85,86.93
GND on BOTTOM (solid shape): 131.1,90.49 131.1,88.39 131.04,88.33 124.9,88.33 124.88,88.31 124.46,88.31 122.01,85.85 118.78,85.85 118.59,86.05 118.59,90.36 118.85,90.62 130.98,90.62
GND on BOTTOM (solid shape): 213.4,68.27 213.4,62.8 213.14,62.55 211.75,62.55 209.33,64.96 209.33,65.04 209.33,68.32 209.33,69.03 209.59,69.28 212.38,69.28
GND on BOTTOM (solid shape): 86.09,53.22 86.79,52.25 87.41,51.28 87.41,50.05 86.93,49.57 85.5,49.57 84.62,50.45 83.96,51.87 83.96,52.39 85.04,53.47 85.84,53.47
GND on BOTTOM (solid shape): 303.75,38.34 303.75,36.35 303.28,35.88 301.04,35.88 300.81,36.11 300.81,37.94 300.89,38.01 302.26,38.01 302.77,38.52 303.57,38.52
GND on BOTTOM (solid shape): 258.94,38.95 258.94,38.01 259.02,37.94 259.7,37.94 259.78,37.86 259.78,36.18 259.73,36.13 258,36.13 257.98,36.16 257.98,37.89 258.03,37.94 258.71,37.94 258.76,37.99 258.76,38.98 258.79,39 258.89,39
GND on BOTTOM (solid shape): 142.84,83.01 142.84,80.15 143.16,79.83 148.44,79.83 148.83,79.44 148.83,78.44 148.64,78.25 146.81,78.25 146.65,78.41 131.66,78.41 131.53,78.54 131.53,79.63 131.74,79.83 136.52,79.83 136.93,80.24 136.93,83.04 137.14,83.25 142.6,83.25
GND on BOTTOM (solid shape): 70.14,10.89 70.14,10.86 71.41,9.59 71.41,6.8 69,4.38 66.84,4.38 66.02,5.21 66.02,5.52 66.3,5.8 66.3,6.24 65.48,7.06 65.48,7.85 67.86,10.23 68.4,10.23 69.19,11.01 70.02,11.01
GND on BOTTOM (solid shape): 258.56,35.85 258.56,34.97 258.63,34.89 258.63,34.85 258.79,34.69 258.79,34.46 258.79,34.28 259.02,34.05 259.02,33.82 258.91,33.72 258.56,33.72 258.2,34.08 258.2,34.72 258.31,34.82 258.31,34.89 258.36,34.94 258.36,35.85 258.41,35.91 258.51,35.91
GND on BOTTOM (solid shape): 129.86,88.1 129.86,87.16 130.11,86.91 130.11,86.85 130.1,86.84 130.03,86.62 130.11,86.41 130.11,86.05 130.01,85.94 129.55,85.94 129.45,86.05 129.45,86.98 129.65,87.19 129.65,88.1 129.71,88.15 129.81,88.15
GND on BOTTOM (solid shape): 219.24,64.39 219.24,63.88 219.43,63.69 220.38,63.69 220.51,63.57 220.51,62.55 220.38,62.42 217.28,62.42 217.09,62.47 216.9,62.42 216.51,62.42 216.45,62.49 216.45,62.51 216.45,63.44 216.57,63.57 217.4,63.57 217.59,63.76 217.59,64.33 217.78,64.52 219.11,64.52
GND on BOTTOM (solid shape): 81.57,91.71 87.82,91.71 87.95,91.68 88.07,91.7 88.54,91.23 88.54,89.33 88.89,88.98 90.2,88.98 90.39,88.79 90.39,88.29 90.12,88.03 89.26,88.03 88.87,87.65 88.87,86.77 88.76,86.65 85.76,86.65 84.78,85.67 81.53,85.67 81.18,86.02 78.82,86.02 77.65,87.19 77.65,91.38 77.65,91.39 77.65,91.77 78.17,92.28 81,92.28
GND on BOTTOM (solid shape): 39.74,85.77 40.49,85.77 40.5,85.78 40.5,86.31 40.96,86.31 40.96,85.79 40.98,85.76 41.68,85.76 41.72,85.81 41.72,86.32 41.73,86.34 42.65,86.34 43.16,85.83 44.77,85.83 44.85,85.75 44.85,85.05 44.65,84.85 42.93,84.85 41.94,83.86 39.61,83.86 38.8,84.67 38.8,86.22 38.91,86.34 39.74,86.34
GND on BOTTOM (solid shape): 216.76,61.9 216.79,61.86 216.83,61.82 216.86,61.75 216.83,61.68 216.74,61.32 216.99,61.05 217.03,61.04 217.03,58.77 216.7,58.44 214.85,58.44 214.69,58.59 214.69,61.92 214.85,62.07 216.6,62.07
GND on BOTTOM (solid shape): 106.03,72.15 106.03,71.52 106.11,71.44 107.02,71.44 107.05,71.41 107.05,71.26 107.02,71.24 106.03,71.24 106.01,71.21 106.01,70.3 106.08,70.22 107.02,70.22 107.07,70.17 107.07,70.09 107.02,70.04 106.06,70.04 105.93,69.92 105.91,69.73 105.94,69.54 105.92,69.46 105.91,69.38 105.9,69.35 105.86,69.33 103.21,69.33 103.19,69.36 103.19,72.13 103.24,72.18 106.01,72.18
GND on BOTTOM (solid shape): 102.53,60.62 102.53,59.45 102.68,59.3 104.43,59.3 104.48,59.25 104.48,57.44 104.58,57.34 105.78,57.34 105.83,57.29 105.83,57.11 105.8,57.09 104.56,57.09 104.46,56.99 104.46,55.16 104.43,55.13 102.6,55.13 102.53,55.06 102.53,53.81 102.48,53.76 102.3,53.76 102.27,53.79 102.27,55.06 102.2,55.13 100.37,55.13 100.32,55.18 100.32,57.06 100.27,57.11 98.97,57.11 98.92,57.17 98.92,57.27 99,57.34 100.16,57.34 100.32,57.5 100.32,59.25 100.37,59.3 102.2,59.3 102.27,59.38 102.27,60.62 102.32,60.67 102.48,60.67
GND on BOTTOM (solid shape): 216.38,52.45 216.38,49.48 216.32,49.42 216.32,47.32 216.38,47.26 216.38,46.93 216.26,46.8 214.41,46.8 214.35,46.87 214.35,47.12 214.41,47.18 215.48,47.18 215.49,47.18 215.52,47.21 215.59,47.21 215.59,47.28 215.62,47.31 215.62,47.32 215.62,48.57 215.62,48.64 215.56,48.71 215.48,48.71 214.23,48.71 214.16,48.71 214.1,48.64 213.33,48.64 213.14,48.83 213.14,49.35 213.12,49.38 213.02,49.38 213.01,49.39 211.01,49.39 210.72,49.68 210.72,50.89 210.95,51.12 212.08,51.12 212.08,51.12 213.26,51.12 213.27,51.12 213.34,51.18 213.72,51.56 214.6,51.56 214.73,51.69 214.73,51.96 214.73,52.39 214.86,52.52 216.32,52.52
GND on BOTTOM (solid shape): 229.96,92.94 229.96,92.69 230.25,92.4 230.25,91.72 229.73,91.2 225.54,91.2 225.41,91.33 225.41,92.34 228.94,92.34 228.94,92.29 228.95,92.23 228.97,92.18 228.99,92.13 229.02,92.09 229.06,92.05 229.1,92.02 229.14,91.99 229.19,91.97 229.25,91.96 229.3,91.96 229.35,91.96 229.4,91.97 229.45,91.99 229.5,92.02 229.54,92.05 229.58,92.09 229.61,92.13 229.63,92.18 229.65,92.23 229.66,92.29 229.66,92.34 229.65,92.39 229.63,92.44 229.61,92.49 229.58,92.53 229.54,92.57 229.5,92.61 229.45,92.63 229.4,92.65 229.35,92.67 229.3,92.67 229.25,92.67 229.19,92.65 229.14,92.63 229.1,92.61 229.06,92.57 229.02,92.53 228.99,92.49 228.97,92.44 228.95,92.39 228.94,92.34 225.41,92.34 225.41,92.95 225.53,93.07 229.83,93.07
GND on BOTTOM (solid shape): 183.27,6.14 183.32,6.05 183.32,5.35 183.27,5.26 183.17,5.26 182.73,5.24 182.61,4.82 182.61,4.81 182.6,4.78 182.1,4.28 182.08,4.26 182.06,4.26 182.02,4.29 182.03,4.35 182.22,4.54 182.22,5.44 182.22,5.46 182.23,5.48 182.84,6.08 182.87,6.09 182.88,6.09 183.03,6.08 183.17,6.14
GND on BOTTOM (solid shape): 92.3,6.11 92.37,6.21 92.48,6.19 92.64,6.09 92.83,6.09 92.85,6.09 93.88,5.07 93.88,4.2 93.86,4.18 93.84,4.16 93.76,4.13 93.69,4.16 93.66,4.18 93.64,4.2 93.64,4.29 93.11,4.82 93.11,4.85 92.93,5.27 92.48,5.21 92.37,5.19 92.3,5.28
GND on BOTTOM (solid shape): 216.26,10.33 216.34,10.3 216.4,10.25 216.47,10.21 216.48,10.21 217.25,9.44 217.24,9.42 217.4,9.01 217.84,9.02 217.94,9.03 218,8.94 218,8.2 217.94,8.11 217.84,8.12 217.69,8.18 217.53,8.18 217.52,8.18 216.9,8.8 216.9,9.48 216.16,10.22 216.18,10.3
GND on BOTTOM (solid shape): 92.31,6.15 92.37,6.24 92.48,6.22 92.63,6.12 92.81,6.11 92.82,6.11 92.84,6.11 93.88,5.07 93.88,4.23 93.88,4.21 93.84,4.16 93.76,4.13 93.69,4.16 93.64,4.21 93.64,4.23 93.64,4.29 93.1,4.82 93.09,4.85 93.09,4.87 92.9,5.25 92.48,5.18 92.37,5.16 92.31,5.25
GND on BOTTOM (solid shape): 147.35,6.28 147.41,6.18 147.41,5.37 147.35,5.27 147.24,5.29 146.93,5.39 146.66,5.21 146.64,5.2 146.61,5.19 146.43,5.19 145.48,4.25 145.48,4.21 145.46,4.19 145.43,4.16 145.4,4.12 145.36,4.1 145.32,4.12 145.29,4.15 145.27,4.22 145.3,4.29 146.35,5.34 146.35,5.65 146.86,6.16 146.88,6.17 146.89,6.16 147.08,6.17 147.24,6.26
GND on BOTTOM (solid shape): 8.86,100.9 10.02,99.79 10.45,98.25 6.65,95.36 4.88,99.79 4.88,99.8 5.08,99.8 5.21,99.78 5.41,99.73 5.59,99.64 5.7,99.55 5.8,99.46 5.89,99.33 5.95,99.22 6,99.11 6.04,98.92 6.04,98.81 6.05,98.23 6.05,98.1 6.08,97.9 6.14,97.73 6.22,97.56 6.33,97.39 6.46,97.25 6.57,97.15 6.71,97.05 6.88,96.96 7.09,96.89 7.26,96.86 7.35,96.85 7.49,96.85 7.65,96.86 7.87,96.9 8.05,96.98 8.18,97.05 8.26,97.1 8.35,97.17 8.42,97.23 8.59,97.41 8.64,97.5 8.72,97.63 8.82,97.89 8.85,98.04 8.86,98.26
GND on BOTTOM (solid shape): outline of 172 points within 178.77,87.18 187.9,90.46
GND on BOTTOM (solid shape): outline of 117 points within 238.82,107.76 287.5,121.95
GND on BOTTOM (solid shape): 22.06,83.52 22.06,78.2 22.69,77.56 46.25,77.56 54.81,76.55 62.9,73.57 66.59,71.44 66.59,71.44 70.19,68.8 72.19,67.1 72.94,66.11 73.65,65.31 82.45,34.4 63.58,8.38 63.17,7.97 63.17,1.64 64.05,0.76 66.26,0.76 66.26,0.25 60.43,0.25 59.65,0.15 58.87,0.25 55.65,0.25 55.12,0.47 54.9,1 54.9,5.01 55.06,5.47 55.46,5.74 81.59,32.72 69.78,68.38 68.04,69.78 57.73,75.19 46.25,77.05 20.28,77.05 20.25,77.07 20.23,77.1 20.23,78.6 20.52,78.88 20.52,80.56 20.53,80.8 20.52,81.04 20.52,81.82 19.81,82.53 19.81,83.56 19.87,83.63 21.95,83.63
GND on BOTTOM (solid shape): outline of 447 points within 304.61,89.68 329.05,120.93
GND on BOTTOM (solid shape): outline of 99 points within 9.1,99.84 60.95,121.95
GND on BOTTOM (solid shape): outline of 360 points within 133.97,67.43 155.79,70.09
GND on BOTTOM (solid shape): outline of 1558 points within 72.33,99.09 228.71,122.16
GND on BOTTOM (solid shape): outline of 2854 points within 88.15,1.47 110.56,17.11
GND on BOTTOM (solid shape): outline of 2862 points within 204.64,1.46 227.62,16.2
GND on BOTTOM (solid shape): outline of 6895 points within 68.29,0 329.05,79.14
GND on BOTTOM (solid shape): outline of 7291 points within 128.99,46.5 164.55,64.45
GND on IN1 (solid shape): 11.91,96.39 11.91,95.79 11.16,95.04 10.85,95.04 10.68,95.21 10.68,95.81 11.32,96.45 11.85,96.45
GND on IN1 (solid shape): outline of 228 points within 119.57,77.6 131.36,90.67
GND on IN1 (solid shape): outline of 97 points within 9.1,99.84 60.95,121.95
GND on IN1 (solid shape): outline of 465 points within 238.92,108.12 287.5,121.95
GND on IN1 (solid shape): outline of 607 points within 304.61,89.55 329.05,120.93
GND on IN1 (solid shape): outline of 163 points within 71.51,106.26 228.33,121.95
GND on IN1 (solid shape): outline of 1270 points within 132.37,5.25 147.21,10.45
GND on IN1 (solid shape): outline of 4280 points within 20.23,0.25 329.05,79.24
GND on IN2 (solid shape): outline of 87 points within 131.56,78.22 142.86,86.35
GND on IN2 (solid shape): outline of 207 points within 119.28,77.6 131.36,90.67
GND on IN2 (solid shape): outline of 341 points within 8.36,93.27 17.95,102.68
GND on IN2 (solid shape): outline of 93 points within 9.1,99.84 60.95,121.95
GND on IN2 (solid shape): outline of 505 points within 304.61,89.83 329.05,120.93
GND on IN2 (solid shape): outline of 622 points within 238.75,108.78 287.5,121.95
GND on IN2 (solid shape): outline of 149 points within 71.66,106.16 228.31,121.95
GND on IN2 (solid shape): outline of 3852 points within 90.48,0.48 133.32,10.2
GND on IN2 (solid shape): outline of 4401 points within 20.23,0.25 329.05,79.14
GND on IN3 (solid shape): outline of 89 points within 120.56,78.43 130.87,91.06
GND on IN3 (solid shape): outline of 105 points within 238.82,108.42 287.5,121.95
GND on IN3 (solid shape): outline of 94 points within 9.1,99.84 60.97,121.95
GND on IN3 (solid shape): outline of 603 points within 304.59,89.65 329.05,120.93
GND on IN3 (solid shape): outline of 147 points within 71.64,106.25 228.51,121.95
GND on IN3 (solid shape): outline of 10854 points within 20.23,0.25 329.05,79.21
GND on IN4 (solid shape): outline of 179 points within 119.28,77.6 131.36,90.67
GND on IN4 (solid shape): outline of 96 points within 9.1,99.84 61.02,121.95
GND on IN4 (solid shape): outline of 486 points within 238.75,108.73 287.5,121.95
GND on IN4 (solid shape): outline of 558 points within 304.61,89.63 329.05,120.93
GND on IN4 (solid shape): outline of 145 points within 71.36,106.15 228.56,121.95
GND on IN4 (solid shape): outline of 961 points within 166.46,5.24 185.06,8.85
GND on IN4 (solid shape): outline of 1046 points within 20.23,0.25 329.05,79.21
GND on IN4 (solid shape): outline of 1835 points within 92.21,6.15 124.48,11.81
GND on GND1: outline of 389 points within 16.57,0.26 329.05,121.95 ; 2 cut-outs
GND on GND2: outline of 775 points within 16.57,0.26 329.05,121.95
GND on VCC: outline of 147 points within 213.27,105.86 287.59,121.95
GND on VCC: outline of 158 points within 49.82,106.37 113.63,121.95
GND on VCC: 86.65,1.27 86.65,12.03 107.86,33.23 107.86,35.9 108.47,36.52 111.14,36.52 114.72,40.09 114.72,49.36 116.35,50.99 119.27,50.99 122.83,54.55 131.72,54.55 132.37,55.21 132.37,57.22 156.65,57.22 159.68,54.19 159.68,50.63 159.93,50.38 160.02,50.01 160.39,49.92 168.59,41.72 180.02,41.72 181.92,39.82 199.7,39.82 216.09,23.43 217.99,23.43 225.79,15.63 225.9,15.42 226.12,15.31 228.77,12.66 228.77,2.1 228.45,1.74 228.77,1.38 228.77,1.27 161.94,1.27 158.65,4.8 155.36,1.27
GND on VCC: outline of 165 points within 304.6,73.09 329.05,120.93
GND on GND3: outline of 769 points within 16.55,0.26 329.05,121.95
GNDA on TOP (solid shape): 20.12,87.66 20.12,85.79 19.95,85.62 19.4,85.62 18.76,86.27 18.76,86.43 18.61,86.58 18.61,87.71 18.73,87.84 19.95,87.84
GNDA on TOP (solid shape): 24.63,92.25 24.63,91.42 24.61,91.4 24.61,91.37 24.55,91.31 24.52,91.31 24.35,91.15 23.8,91.15 23.69,91.26 23.69,91.79 23.76,91.86 23.76,92.08 24,92.33 24.55,92.33
GNDA on TOP (solid shape): 25.04,101.51 25.04,100.37 24.93,100.26 22.72,100.26 22.67,100.21 22.67,99.47 22.56,99.35 21.84,99.35 21.65,99.55 21.65,101.07 22.17,101.59 24.55,101.59 24.56,101.6 24.96,101.6
GNDA on BOTTOM (solid shape): 26.6,100.83 26.57,100.66 26.63,100.49 26.63,100.46 26.75,100.34 26.85,100.34 26.92,100.33 27,100.34 27.17,100.17 27.17,97.05 27.12,97 26.8,97 26.63,97.17 26.63,98.08 26,98.7 26,100.92 26.1,101.01 26.42,101.01
GNDA on GND1: outline of 165 points within 0.26,77.05 27.58,106.55
GNDA on GND2: outline of 81 points within 0.25,77.05 27.58,106.55
GNDA on VCC: 4.03,78.07 4.03,78.55 3.73,79.53 2.95,80.19 12.91,80.19 13.13,80.1 13.23,80.15 14.84,81.25 14.47,83.15 14.47,87.49 14.88,89.27 13.49,90.47 13.46,90.49 1.27,90.49 1.27,92.42 4.67,92.42 5.72,93.47 5.72,96.21 8.44,95.77 10.11,97.97 10.12,97.99 10.12,101.68 24.41,101.68 24.43,101.7 26.42,103.1 26.29,105.53 26.48,105.53 26.83,104.71 27.47,104.09 27.47,100.07 26.27,98.88 26.27,97.53 26.22,97.48 24.57,97.48 24.04,96.95 24.04,92.67 24.57,92.14 25.69,92.14 25.69,91.36 24.93,90.6 24.93,87.04 24.57,86.68 21.52,86.68 20.87,86.02 20.87,83.48 20.56,83.18 17.01,83.18 16.07,82.24 16.07,78.07
GNDA on GND3: outline of 81 points within 0.25,77.05 27.58,106.55
GNDA_CHG on TOP (solid shape): 77.7,71.31 77.7,70.75 78.03,70.42 79.03,70.42 79.46,70 79.46,69.43 79.48,69.41 79.48,68.65 78.91,68.65 78.91,68.14 79.48,68.14 79.48,67.88 79.41,67.82 77.55,67.82 76.72,68.65 76.72,69.89 77.79,69.89 77.79,69.84 77.8,69.79 77.81,69.73 77.83,69.69 77.86,69.64 77.9,69.6 77.94,69.57 77.99,69.54 78.04,69.52 78.09,69.51 78.14,69.51 78.2,69.51 78.25,69.52 78.3,69.54 78.34,69.57 78.39,69.6 78.42,69.64 78.45,69.69 78.48,69.73 78.49,69.79 78.5,69.84 78.5,69.89 78.49,69.94 78.48,70 78.45,70.04 78.42,70.09 78.39,70.13 78.34,70.16 78.3,70.19 78.25,70.21 78.2,70.22 78.14,70.22 78.09,70.22 78.04,70.21 77.99,70.19 77.94,70.16 77.9,70.13 77.86,70.09 77.83,70.04 77.81,70 77.8,69.94 77.79,69.89 76.72,69.89 76.72,71.19 76.91,71.38 77.64,71.38
GNDA_CHG on BOTTOM (solid shape): 79.84,78.56 79.84,76.46 79.65,76.27 76.05,76.27 75.86,76.46 75.86,77.79 75.67,77.98 75.67,78.69 75.73,78.75 79.65,78.75
GNDA_CHG on BOTTOM (solid shape): 79.63,71.01 79.63,67.99 79.3,67.66 77.01,67.66 76.71,67.96 76.68,68.03 76.7,68.1 76.81,68.42 76.62,68.7 76.62,70.65 76.81,70.84 77.14,70.84 77.3,70.68 77.3,69.93 77.7,69.54 77.95,69.54 78.14,69.48 78.32,69.53 78.33,69.54 78.49,69.54 78.6,69.65 78.6,70.96 78.7,71.06 79.58,71.06
GNDA_CHG on IN4 (solid shape): outline of 803 points within 72.52,68.87 83.57,81.37
+BL_PWR_SRC on TOP (solid shape): 93.76,99.46 93.76,95.74 93.64,95.61 93.64,95.33 93.5,95.19 90.02,95.19 89.66,95.54 89.66,97.21 89.99,97.56 89.66,97.92 89.66,98.71 89.97,99.02 90.85,99.02 91.44,99.61 93.61,99.61
+BL_PWR_SRC on BOTTOM (solid shape): 93.51,101.16 93.51,99.23 93.41,99.13 91.86,99.13 91.71,99.28 91.71,99.67 91.85,99.81 92.12,99.81 92.24,99.94 92.24,101.21 92.29,101.26 93.41,101.26
+CRT_VCC on TOP (solid shape): 272.29,112.65 272.29,110.86 272.14,110.71 271.49,110.71 271.21,110.99 270.03,110.99 269.98,111.04 269.98,112.31 270.43,112.76 272.18,112.76
+CRT_VCC on IN1 (solid shape): outline of 110 points within 262.45,109.07 271.37,117.29
+DC_IN on TOP (solid shape): 58.59,91.51 58.59,90.17 59.54,89.22 60.86,89.22 61.25,89.22 61.51,88.97 61.51,87.06 61.38,86.93 58.39,86.93 58.33,87 58.33,88.78 58.08,89.03 56.93,89.03 56.74,89.22 56.74,91.57 56.81,91.63 58.46,91.63
