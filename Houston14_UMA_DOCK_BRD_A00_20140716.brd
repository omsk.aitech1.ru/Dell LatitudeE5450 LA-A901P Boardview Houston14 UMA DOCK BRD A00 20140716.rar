# Allegro board Houston14_UMA_DOCK_BRD_A00_20140716.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+3.3V_ALW_PCH_UZ8:
  vias: v2(186.86,38.04)
+3.3V_ALW_UE1: length 42.2
  TOP w0.254: UE1.B5 256.42,83.42 v1(256.27,83.28) ; v1(250.49,77.64) 250.29,77.44 UE1.B30 ; CE3.1 255.67,71.75 v4(255.67,72.71) UE1.A43 ; UE1.A54 261.86,78.19 CE4.1
  TOP w0.508: v1(254.76,72.02) 255.27,71.52 CE3.1 ; CE2.1 v1(256.45,85.92) ; v1(246.65,77.27) 246.65,77.09 246.2,76.65 CE6.1 ; v1(261.71,78.81) 261.71,78.91 261.92,79.12 262.66,79.12 CE4.1
  IN1 w0.508: v1(254.76,72.02) 255.07,72.02 255.55,72.51 255.55,76.44 257.01,77.9 260.81,77.9 v1(261.71,78.81) ; v1(250.49,77.64) 250.28,77.43 246.81,77.43 v1(246.65,77.27)
  IN3 w0.508: v1(256.45,85.92) 256.45,85.5 256.89,85.07 259.37,85.07 262.93,81.51 262.93,80.03 v1(261.71,78.81)
  BOTTOM w0.508: v1(256.27,83.28) 256.27,85.54 256.43,85.69 256.43,85.89 v1(256.45,85.92)
  vias: v1(246.67,83.25) v1(247.43,83.25)
+3.3V_ALW_UE2: length 43.4
  TOP w0.254: CE13.1 259.1,67.41 UE2.A22 ; UE2.A26 257.1,65.44 v1(256.87,65.67) ; UE2.A41 250.74,59.25 250.52,59.48 250.2,59.48 CE18.1 ; UE2.B35 252.97,63.5 252.23,64.24 250.09,64.24 CE19.1
  TOP w0.305: UE2.B3 262.09,56.5 v1(261.79,56.2) ; CE15.1 258.6,52.08 UE2.A58 ; UE2.A52 255.6,53.53 255.59,53.52 255.59,53.1 255.6,53.09 255.6,51.62 CE17.1
  TOP w0.508: CE19.1 249.94,64.09 v1(249.94,63.52) ; v1(254.85,51.68) 255.14,51.68 255.24,51.58 CE17.1 ; v1(259.96,66.82) 259.96,66.84 260.13,67.02 CE14.1 CE13.1 ; CE15.1 CE20.1 v1(256.32,51.58) ; v1(265.38,55.76) 265.38,55.88 265.95,56.45 CE16.1 ; CE18.1 249.92,59.48 249.62,59.17 v1(249.49,59.17)
  IN3 w0.508: v1(254.85,51.68) 255.36,51.68 255.46,51.58 v1(256.32,51.58)
  IN4 w0.508: v1(249.94,63.52) 249.85,63.43 249.85,62.66 249.61,62.42 249.61,59.28 v1(249.49,59.17)
  BOTTOM w0.508: v1(261.79,56.2) 261.99,56.2 262.37,55.82 262.37,55.13 260.21,52.97 260.21,49.42 259.25,48.45 257.02,48.45 256.32,49.15 v1(256.32,51.58)
  vias: v1(247.7,63.95) v1(248.31,63.94) v1(265.42,59.97) v1(266.03,59.98) v4(247.94,64.58)
+3.3V_ALWP: length 21
  TOP w0.102: v3(218.22,77.09) v2(218.22,77.92)
  IN1 w0.508: v3(218.22,77.09) 218.68,76.63 224.4,76.63 224.89,76.14 224.89,65.41 224.32,64.84 v3(223.43,64.84)
  BOTTOM w0.508: PR100.1 v3(223.43,64.84)
+3.3V_CAM: length 3.7
  TOP w0.127: 96.06,97.53 96.52,97.53 v2(96.72,97.32)
  BOTTOM w0.254: v1(95.75,97.96) 95.75,98.5 96.39,99.15 JEDP1.11
+3.3V_HDD: length 38.9
  TOP w0.102: v1(294.37,51.29) v4(294.37,50.41)
  TOP w0.254: v1(293.61,60.45) 294.13,60.45 294.44,60.15 UN2.20 ; UN2.10 296.44,54.67 v1(296.19,54.42)
  TOP w0.508: RN24.1 v1(292.99,60.58) ; RN22.1 299.86,54.27 v1(299.67,54.08) 299.22,53.63 CN29.1 ; v1(299.95,59.59) 299.98,59.62 300.37,59.98 RN12.2 ; v1(294.46,51.93) 294.17,52.22 RN10.2 ; v1(298.65,64.23) 298.34,63.91 297.51,63.91 297.22,63.62 RN14.1 RN20.1 ; RN18.1 293.15,52.11 293.98,51.29 v1(294.37,51.29) ; RN8.1 297.75,52.69 298.72,51.73 v1(298.72,51.46)
  IN2 w0.508: v1(298.65,64.23) 298.35,64.23 297.65,63.53 297.65,60.43 297.51,60.29 297.51,53.79 298.72,52.58 v1(298.72,51.46)
  IN4 w0.457: v1(299.95,59.59) 300.27,59.91
  IN4 w0.508: v1(299.67,54.08) 299.67,54.83 301.46,56.62 301.46,59.4 300.95,59.91 300.27,59.91
  BOTTOM w0.508: v1(293.61,60.45) 293.61,59.96 CN24.1
  vias: v1(295.06,36.57) v1(295.68,36.57) v1(296.32,36.58) v1(306.07,51.27) v1(306.67,51.25) v1(307.02,42.05) v1(307.63,42.04)
+3.3V_LAN: length 116.5
  TOP w0.254: v1(243.41,100.18) 243.41,100.24 243.05,100.6 UL4.4 ; UL4.8 245.05,100.4 244.91,100.26 244.91,100.25 v1(244.86,100.2) ; UL4.30 245.55,105.23 245.58,105.26 245.58,105.74 245.49,105.83 CL25.1 ; v1(240.07,103.63) 240.16,103.54 UL4.39 ; CL26.1 248.68,99.89 248.05,100.52 UL4.14 ; UL4.21 250.77,103.54 v1(250.94,103.37) ; CL27.1 241.15,100.02 241.55,100.41 UL4.1
  TOP w0.381: v1(244.84,106.68) 245.2,106.68 CL25.1
  TOP w0.508: v1(270.42,91.57) 271.04,91.57 RL6.1 RL5.1 ; v1(241.57,98.91) 241.15,99.33 CL27.1 ; RL1.1 285.62,86.93 285.89,87.2 v1(285.89,87.76) 285.89,88.13 285.56,88.46 RL2.1 ; RL29.1 v1(253.71,102.95) ; v1(237.34,99.99) 236.93,100.4 RL30.1 ; v1(248.68,97.94) CL26.1 ; RL4.2 274.56,91.96 v1(274.36,91.76)
  IN2 w0.508: 251.73,105.3 253.71,103.32 v1(253.71,102.95) ; JLOM1.12 303.43,107.98 304.41,107 304.41,106.87 305.41,105.87 306.44,105.87 308.08,104.23 310.24,104.23 311.9,102.57 311.9,97.87 311.23,97.2 311.23,90.22 v1(310.67,89.66)
  IN2 w1.016: 252.51,105.6 253.5,105.6 256.25,102.86 262.95,102.86 263.56,102.25 281.34,102.25 284.62,105.53 286.63,105.53 JLOM1.9
  IN3 w0.508: v1(310.67,89.66) 310.67,89.35 308.43,87.11 305.73,87.11 305.28,86.67 300.75,86.67 299.85,87.57 291.33,87.57 291.15,87.39 290.27,87.39 v1(290.11,87.56)
  BOTTOM w0.508: 240.47,100.99 238.91,100.99 237.91,99.99 v1(237.34,99.99)
  vias: v1(250.89,105.51) v1(251.47,105.48) v1(266.95,89.08) v1(267.59,89.08) v1(269.09,79.7) v1(269.09,78.81) v1(269.72,79.7) v1(269.72,78.81) v1(286.37,81.08) v1(286.96,81.07) v1(288.53,105.68) v1(288.56,105.07) v4(271.18,78.68)
+3.3V_LAN_OUT: length 3.9
  TOP w0.102: v2(270.17,87.95) 270.17,88.19 v1(269.89,88.47)
  TOP w0.203: UL1.19 v1(278.88,82.04) ; v1(276.9,81.73) 277.03,81.85 277.03,81.98 277.28,82.23 UL1.15 ; v1(282.65,85.36) 282.61,85.32 UL1.29
  vias: v1(270.51,88.45) v1(273.55,88.1) v1(273.56,87.48)
+3.3V_LAN_UZ2:
  vias: v2(273.61,73.38)
+3.3V_M: length 128.8
  TOP w0.508: CC54.1 163.92,60.26 v1(164.57,59.61)
  IN1 w0.508: v1(184.07,40.86) 184.07,40.22 185.9,38.39 187.9,38.39 191.13,35.16 191.13,35.09 v1(191.21,35.02)
  IN2 w0.508: v1(212.42,81.66) 211.02,81.66 210.32,80.97 203.4,80.97 201.05,78.62 201.05,64.52 204.03,61.55 204.03,58.17 203.09,57.23 203.09,55.07 201.76,53.75 201.7,53.75 201.61,53.66 194.6,53.66 v1(194.55,53.61)
  IN3 w0.254: 193.78,53.47 193.32,53.47 191.71,55.08 190.42,55.08 189.95,54.61 187.99,54.61 186.6,56 186.6,56.75 187.9,58.04 187.9,59.12 187.6,59.41 186.23,59.41 186.23,59.41 186.16,59.43 185.98,59.6 185.42,59.6 184.76,59.6 184.42,59.95 184.42,62.35 183.69,63.07 180.85,63.07 179.88,62.11 179.88,61.15 179.54,60.81 176.38,60.81 175.41,61.78 172.86,61.78 171.88,60.8 169.49,60.8 169.46,60.76 168.99,60.76 168.84,60.61 167.23,60.61 166.8,61.04 164.49,61.04 164.16,60.71 164.16,60.03 v1(164.57,59.61)
  IN3 w0.508: 193.78,53.47 194.41,53.47 v1(194.55,53.61) 194.55,50.78 193.71,49.94 193.71,46.85 195.75,44.82 195.75,43.13 195.02,42.41 195.02,38.09 193.42,36.49 192.84,36.49 191.36,35.02 v1(191.21,35.02)
  BOTTOM w0.254: v1(164.57,59.61) 164.4,59.43 UC1.Y8
  BOTTOM w0.305: JSPI1.5 210.61,83.17 211.72,82.06 RC231.1
  BOTTOM w0.508: RC231.1 212.23,81.85 v1(212.42,81.66)
  vias: v4(195.11,53.66)
+3.3V_M_TPM: length 51.8
  TOP w0.356: CZ7.1 196.05,60.39 UZ1.3
  TOP w0.381: CZ6.1 185.38,61.76 186.91,61.76 186.98,61.69 UZ1.24 ; UZ1.3 193.26,60.39 192.82,59.95 192.82,58.88 192.82,58.87 192.82,57.04 ; UZ1.10 194.64,64.94 194.98,64.59 196.1,64.59 196.43,64.92 CZ5.1
  TOP w0.406: UZ1.19 189.13,64.94 189.47,65.28 v1(190.17,65.28)
  TOP w0.508: v1(185.12,68.14) 185.12,68.04 184.9,67.82 CZ4.1 ; v1(185.71,61.14) 185.57,61.28 CZ6.1 ; CZ7.1 v1(196.43,61.64) ; CZ5.1 196.53,65.19 196.53,66.16 v1(196.9,66.53)
  IN2 w0.508: v1(196.43,61.64) 196.43,61.15 196.77,60.81 197.6,60.81 198.6,61.81 198.6,63.6 198.29,63.92 198.29,66.06 197.82,66.53 v1(196.9,66.53) 196.82,66.45 194.67,66.45 193.15,64.94 190.51,64.94 v1(190.17,65.28)
  IN3 w0.508: v1(185.71,61.14) 185.74,61.17 185.74,61.61 185.99,61.86 188.24,61.86 188.48,62.11 188.48,64 189.76,65.28 v1(190.17,65.28)
  IN4 w0.508: v1(185.12,68.14) 185.12,67.72 185.81,67.02 186.4,67.02 186.42,67.05 187.73,67.05 188.44,66.34 188.44,65.05 188.86,64.62 189.54,64.62 189.67,64.75 189.72,64.75 190.17,65.2 v1(190.17,65.28)
  vias: v4(193.48,56.84)
+3.3V_M_UZ8:
  vias: v2(182.78,37.11)
+3.3V_MMI: length 26.8
  TOP w0.102: v4(317.74,63.39) 316.06,63.39 v1(315.77,63.1)
  TOP w0.203: v1(307.03,59.42) 307.46,59.85 UR1.13 ; UR1.9 305.84,62.82 305.6,63.06 CR8.2 ; UR1.11 306.12,62.02 305.66,61.56 305.07,61.56 CR3.1 ; UR1.27 313.16,62.42 314.22,61.36 314.82,61.36 315.05,61.58 CR2.1 ; CR4.1 309.66,68.7 309.66,67.76 309.86,67.56 UR1.42
  TOP w0.508: RR6.1 309.41,56.96 309.91,56.47 v1(309.91,56.44) ; v1(304.13,63.78) 304.53,63.38 CR8.2 ; v1(305.3,61.03) CR3.1 ; v1(310.3,68.27) 310.3,68.52 309.92,68.9 CR4.1
  IN2 w0.508: v1(310.3,68.27) 310.05,68.52 305.82,68.52 304.52,67.22 304.52,64.18 v1(304.13,63.78)
  vias: v1(305.19,60.11) v1(305.22,59.46) v1(306.43,57.36) v1(306.45,56.77) v1(311.23,58.65) v1(311.38,59.25) v1(315.76,62.45)
+3.3V_RTC_LDO: length 100
  TOP w0.102: v4(224.75,64.94) 223.76,63.95 v3(223.76,63.82)
  TOP w0.508: v3(223.76,63.82) PR103.1 ; PD3.3 311.65,73.26 v1(311.91,73.52)
  IN2 w0.508: v1(249.72,67.57) 249.26,67.57 248.48,66.78 237.31,66.78 237.02,66.49 226.43,66.49 v3(223.76,63.82)
  IN3 w0.508: v1(249.72,67.57) 251.13,68.98 251.98,68.98 252.58,68.38 259.66,68.38 260.58,69.29 263.27,69.29 264.29,68.28 269.75,68.28 273.01,65.01 283.1,65.01 287.12,69.04 304.24,69.04 306.53,71.33 310.54,71.33 311.91,72.7 v1(311.91,73.52)
+3.3V_RUN: length 442.8
  TOP w0.203: UV16.23 177.69,96.57 177.33,96.93 177.33,97.4 CV128.1 ; CV125.1 177.38,90.24 177.38,90.72 177.1,91 177.1,91.82 177.29,92.01 UV16.4 ; CV127.1 173.79,93.28 173.99,93.08 174.42,93.08 174.59,93.25 UV16.32 ; UV16.29 174.62,94.45 174.24,94.82 173.79,94.82 173.52,94.55 CV126.1
  TOP w0.254: 181.7,62.6 v1(181.75,62.55) ; 181.7,62.6 181.7,62.97 181.35,63.32 RPC6.2 ; 181.7,62.6 181.48,62.82 RPC6.1 ; v1(163.2,61.48) 162.84,61.13 CC69.1 ; RPE3.6 253.03,49.66 252.67,49.3 v1(252.53,49.3) RPE3.5 ; UC7.14 106.54,34.78 106.11,34.34 106.11,33.39 CC17.1 ; RC155.2 185.16,57.97 185.75,57.97 186.16,58.38 v1(186.16,58.45) ; RPC6.4 181.41,64.32 v1(181.67,64.58) 181.71,64.54 181.71,64.25 181.28,63.82 RPC6.3 ; v1(164.6,60.52) 165.08,61 165.38,61 165.75,61.37 165.75,61.57 166.17,61.99 167.51,61.99 167.56,61.94 ; v1(160.72,63.48) 160.72,62.94 160.35,62.58 159.69,62.58 159.3,62.18 CC66.1 ; 168.64,61.45 168.9,61.19 171.72,61.19 172,61.47 172,61.84 171.65,62.18 168.88,62.18 168.64,61.94 168.64,61.45
  TOP w0.305: UN1.1 286.92,57.74 287.44,57.22 CN2.1 ; UN1.7 284.77,60.8 v1(284.52,61.05) 284.27,60.8 UN1.8 ; CN1.1 284.27,55.64 284.27,57.26 UN1.14
  TOP w0.381: QV3.5 101.77,107.24 101.97,107.04 v1(101.97,106.73) 101.77,106.53 QV3.2 ; v1(185.93,52.22) 185.92,52.24 185.92,52.77 UC5.5 ; RC122.1 175.86,58.49 175.49,58.85 UC4.5 ; v1(178.24,63.95) 177.97,63.95 177.84,64.07 QC1.2 QC1.5 174.47,64.07 CC85.2
  TOP w0.508: CC17.1 106.68,33.35 106.68,33.86 v1(106.74,33.92) ; v1(173.37,92.56) 173.22,92.71 CV127.1 ; v1(184.2,46.27) 184.59,45.87 184.59,44.35 183.6,43.36 183.6,42 182.93,41.33 181.32,41.33 180.67,40.68 180.67,39 181.1,38.57 RZ46.1 ; RN2.1 278.9,61.71 v1(279.5,61.71) ; CC85.2 173.01,62.61 RC302.1 172.64,62.18 172.3,61.84 172,61.84 ; v1(175.44,62.45) 175.59,62.3 RC95.1 ; RE51.1 v1(261.15,72.18) ; RE67.1 v1(259.12,72.16) 259.13,72.18 259.87,72.18 260.13,71.91 RE48.1 ; v1(151.37,13.49) 151.21,13.32 CD31.1 150.56,13.43 149.75,13.43 CD32.1 ; v1(145.75,93.25) 145.45,93.54 CV69.1 ; v1(145.58,96.19) 145.43,96.19 145.02,95.79 CV62.1 ; v1(287.9,56.56) 287.87,56.58 CN2.1 287.82,57.27 RN4.1 ; v1(226.92,12.69) 226.16,12.69 224.46,10.99 CD63.1 CD64.1 221.48,12.23 220.56,13.15 RD27.2 ; RC176.1 169.96,78.53 v1(169.76,78.73) ; RN3.1 285.28,63.22 v1(284.98,63.53) ; RV19.1 83.3,101.79 v1(83.59,102.09) ; v1(97.32,95.32) 98.49,95.32 99.54,96.37 RV18.2 99.54,98.59 99.97,99.02 QV5.2 99.97,99.75 101.46,101.23 v1(101.46,102.28) ; v1(252.48,109.36) 252.22,109.62 CV380.1 ; RC247.2 174.79,54.54 v1(175.84,55.58) ; CV70.1 135.52,92.27 134.86,91.61 v1(134.86,91.65) ; RV54.1 140.36,92.34 v4(140,91.98) 140,90.4 140.7,89.7 141.97,89.7 142.72,90.45 v1(142.72,90.64) ; v1(176.31,90.92) CV124.1 CV125.1 ; CV379.1 v1(253.58,109.36) ; 242.35,82.24 242.21,82.37 242.21,88.83 v1(241.69,89.35) ; RC122.1 175.27,57.72 v1(175.15,57.6) ; RV121.1 178.85,88.9 v1(178.22,88.27) ; v1(250.05,109.78) 249.4,110.43 248.58,110.43 MIC1.6 ; v1(135.17,87.63) 134.86,87.94 CC95.2 ; v1(161.85,58.83) 162.1,58.83 162.39,59.12 CC64.1 ; CV128.1 177.58,97.48 v1(178.04,97.02) ; CV126.1 173.22,95.11 v1(173.01,95.32) ; CV378.1 v1(69.39,103.02) ; CV61.1 v1(145.87,94.43) ; CV377.1 v1(68.1,103.06) ; RV250.1 RV251.1 v1(182.11,89.27) ; 168.64,61.94 167.56,61.94 ; v1(282.83,56.33) 283.53,55.63 CN1.1 ; v1(103.62,110.14) RV8.1 ; RV71.1 136.14,96.83 CV66.1 136.13,97.25 135.34,98.03 v1(135.31,98.03)
  IN1 w0.508: v1(259.12,72.16) 261.14,72.16 v1(261.15,72.18) 261.19,72.18 262.61,70.75 266.71,70.75 266.87,70.6 269.06,70.6 271.29,68.37 273.44,68.37 274.13,69.07 278.79,69.07 281.55,66.32 290.71,66.32 291.3,66.91 v1(291.3,67.11) ; v1(142.72,90.64) 143.14,90.64 v1(145.75,93.25)
  IN2 w0.508: v1(146.05,88.72) 145.25,88.72 144.06,89.92 143.45,89.92 v1(142.72,90.64) ; v1(178.04,97.02) 178.04,96.23 177.46,95.65 175.26,95.65 v1(175.02,95.4) ; v1(164.6,60.52) 163.82,60.52 162.13,58.83 v1(161.85,58.83) ; v1(241.69,89.35) 239.56,89.35 v1(233.3,95.61) ; v1(151.37,13.49) 151.57,13.49 151.99,13.07 151.99,11.48 150.97,10.46 v1(150.97,9.99) ; v1(134.86,91.65) 134.86,87.94 v1(135.17,87.63)
  IN3 w0.254: 161.57,70.27 161.57,64.77 161.14,64.35 161.14,63.84 160.78,63.48 v1(160.72,63.48) ; 159.82,69.05 159.86,69.05 160.63,68.28 160.63,64.79 160.24,64.39 160.24,63.28 160.58,62.93 160.97,62.93 162.42,61.48 v1(163.2,61.48)
  IN3 w0.508: v1(134.86,91.65) 134.04,92.47 132.23,92.47 130.96,93.74 130.96,94.49 v1(131.28,94.81) ; v1(167.08,79.4) 166.99,79.49 v1(165.87,79.49) 164.54,79.49 164.04,79.99 161.83,79.99 159.18,77.34 159.18,74.15 160.06,73.27 160.06,71.25 159.59,70.78 159.59,69.28 159.82,69.05 ; 161.57,70.27 161.57,70.84 161.38,71.03 161.38,73.07 159.99,74.45 159.99,76.88 161.23,78.11 161.25,78.11 161.76,78.62 162.93,78.62 163.18,78.87 v1(163.18,79.3) ; v1(184.2,46.27) 184.87,46.94 184.87,47.65 184.28,48.25 184.28,48.67 184.72,49.11 184.72,49.9 184.35,50.26 184.35,51.27 184.7,51.62 185.61,51.62 185.93,51.93 v1(185.93,52.22) ; v1(252.53,49.3) 252.4,49.17 248.04,49.17 v1(247.98,49.24) ; v1(230.23,13.72) 228.4,13.72 227.37,12.69 v1(226.92,12.69) ; v1(189.32,59.53) 189.13,59.72 189.13,60.95 v1(189.47,61.3) v1(189.47,62.3) 189.47,63.71 v1(189.36,63.82)
  IN4 w0.508: v1(97.32,95.32) 96.51,96.13 96.51,97.26 96.98,97.73 v1(96.98,99) ; v1(134.86,91.65) 134.9,91.65 135.31,92.05 v1(135.31,98.03) ; v1(151.37,13.49) 151.63,13.49 152.06,13.06 152.06,11.7 152.37,11.38 154.24,11.38 155.59,10.04 155.59,4.42 154.65,3.48 152.59,3.48 152.25,3.15 138.93,3.15 138.3,3.77 134.01,3.77 133.73,4.05 131.32,4.05 131.13,4.24 123.32,4.24 122.98,3.9 113.13,3.9 112.48,3.25 87.44,3.25 86.07,1.88 v1(85.6,1.88)
  BOTTOM w0.203: v1(135.31,98.03) 135.53,97.81 135.53,96.8 135.19,96.46 135.19,96.04 135.39,95.85 UV7.30 ; v1(142.72,90.64) 142.45,90.92 UV7.5 ; v1(145.75,93.25) 145.57,93.25 145.37,93.45 UV7.57 ; UV7.21 135.41,92.25 135.03,91.86 135.03,91.81 v1(134.86,91.65) ; UV7.51 145.31,95.85 145.58,96.12 v1(145.58,96.19)
  BOTTOM w0.254: UC1.W9 163.95,59.64 UC1.V8 164.6,60.29 v1(164.6,60.52) ; RPC5.2 181.39,54.93 181.56,54.75 ; v1(186.16,58.45) 186.16,58.35 185.78,57.97 RPC9.2 ; 181.56,54.75 v1(181.56,54.68) ; 181.56,54.75 181.56,54.78 180.91,55.43 RPC5.1 ; v1(185.53,57.09) 185.53,57.08 185.46,57 184.79,57 RPC9.4 ; RPC16.4 181.05,59.77 181.17,59.65 ; RPC2.8 165.63,79.25 v1(165.87,79.49) ; 181.17,59.65 181.17,59.97 180.87,60.27 RPC16.3 ; 181.17,59.65 181.74,59.08 v1(181.74,58.94) ; RPC17.1 180.59,58.47 v1(181.03,58.91) 181.17,58.77 181.17,58.21 180.93,57.97 RPC17.2 ; v1(169.76,78.73) 169.43,79.06 168.91,79.06 168.68,78.83 RPC20.8 ; 181.23,61.27 RPC16.1 ; 181.23,61.27 181.23,61 181,60.77 RPC16.2 ; 181.23,61.27 181.36,61.27 181.8,61.71 v1(181.8,61.88) ; RPC17.4 181.61,56.97 v1(181.71,57.07) 181.31,57.47 RPC17.3 ; RPC2.5 164.13,78.81 163.67,78.81 v1(163.18,79.3) ; PJP10.1 33.55,94.62 33.88,94.95 v1(33.88,95.54) ; UC1.U8 163.95,61.48 UC1.T9 163.25,61.52 163.22,61.48 v1(163.2,61.48) ; v1(160.72,63.48) 160.78,63.48 161.14,63.84 UC1.K14 UC1.K16 ; v1(167.08,79.4) 167.08,79.33 167.18,79.23 RPC20.5
  BOTTOM w0.356: v1(226.92,12.69) 226.76,12.53 JDIMM2.199 ; v1(150.97,9.99) 150.76,10.2 JDIMM1.199
  BOTTOM w0.381: v1(182.69,66.66) 182.19,66.66 181.93,66.4 181.47,66.4 180.75,65.67 180.4,65.67 RC180.1
  BOTTOM w0.508: v1(147.29,97.3) 147.69,96.9 RV55.1 ; RC66.1 189.09,59.76 v1(189.32,59.53) ; RV51.1 v1(148.31,92.52) ; v1(146.05,88.72) 145.58,88.25 RV53.1 ; RV69.1 132.17,94.81 131.72,94.81 v1(131.28,94.81) ; 189.41,70.23 v1(189.41,77.56) ; v1(98.68,70.17) PR516.2 99.4,69.14 PR519.1 ; RC160.1 180.66,63.57 v1(181.67,64.58) ; RC156.2 v1(181.75,62.55) ; v1(170.75,79.68) 174.03,79.68 174.92,78.79 RC164.1 RC163.1 ; v1(148.32,93.54) RV58.1 ; v1(148.36,94.57) 148.34,94.57 148.32,94.55 RV57.1 ; RV56.1 v1(148.36,95.57) ; RV52.1 v1(135.17,87.63) ; RC180.1 RC158.1 ; RV60.1 v1(148.42,91.51)
  vias: v1(93.37,102.15) v1(93.95,102.14) v1(96.92,99.6) v1(174.24,89.17) v1(185.6,62.54) v1(185.61,63.44) v1(185.69,60.11) v1(185.71,64.66) v1(218.81,95.58) v1(219.16,95.06) v1(219.42,95.61) v1(219.8,95.09) v1(220.1,95.61) v1(220.38,94.97) v1(220.68,95.48) v1(221.07,95.04) v1(224.32,35.75) v1(225.08,35.78) v1(237.6,32.69) v1(237.68,31.23) v1(239.41,16) v1(240.02,15.99) v1(273,38.34) v1(273.61,38.33) v1(294.13,38.52) v1(294.73,38.53) v1(295.33,38.51) v1(307.99,52.69) v1(308.6,52.72) v3(107.89,70.63)
+3.3V_RUN_AUDIO: length 19.9
  TOP w0.102: v1(30.71,93.08) v4(31.48,93.08)
  TOP w0.203: v1(30.71,93.08) 30.71,93.22 30.52,93.41 UA1.3 ; v1(30.54,95.68) 30.3,95.68 30.18,95.81 UA1.9
  TOP w0.508: RA18.1 v1(30.62,88)
  IN1 w0.508: v1(26.3,102.07) 26.3,102.33 26.97,103 v1(28.4,103)
  BOTTOM w0.254: PJP10.2 32.17,94.62 v1(31.93,94.38)
  BOTTOM w0.381: RA29.1 33.62,96.17 32.97,95.52 v1(32.18,95.52)
  BOTTOM w0.508: v1(30.54,95.68) 30.54,95.69 30.5,95.65 CA11.1 29.92,95.64 29.92,94.72 CA50.1 ; v1(26.3,102.07) 26.3,101.77 25.39,100.85 RA45.2 ; CA10.1 30.18,93.61 v1(30.71,93.08) 33.83,93.08 34.19,93.44 35.42,93.44 36.04,94.06 RA26.1 ; RA38.2 28.54,102.86 v1(28.4,103)
  vias: v1(20.5,86.43) v1(21.08,86.43)
+3.3V_RUN_CARD:
  vias: v1(298.41,59.74) v1(298.84,60.16) v1(310.18,58.49) v1(310.21,59.08) v2(310.71,59.32)
+3.3V_RUN_UN3: length 1.7
  TOP w0.102: v2(302.93,46.7) 302.93,47.16 303.76,47.98 CN3.2
+3.3V_RUN_UZ9:
  vias: v2(220.64,89.86)
+3.3V_RUN_VDDA: length 6.5
  TOP w0.203: UV8.H12 v1(164.32,93.51) ; UV8.K6 v1(159.78,92.21) ; UV8.K7 v1(160.43,92.21) ; v1(163.02,97.41) UV8.C10 ; UV8.H5 v1(159.13,93.51) ; UV8.J4 v1(158.48,92.86)
  BOTTOM w0.102: v1(168.31,100.14) 169.48,100.14 v2(169.61,100.27)
  BOTTOM w0.178: v1(158.48,92.86) 157.82,92.21 CV100.1
  BOTTOM w0.381: CV99.1 159.73,92.16 v1(159.78,92.21) ; v1(164.32,93.51) 164.8,93.51 CV98.1
  vias: v1(168.21,86.71) v1(169.15,88.12)
+3.3V_RUN_VDDIO: length 7.6
  TOP w0.127: v2(168.49,91.53) 168.14,91.89 v1(167.84,91.89)
  TOP w0.203: v1(158.48,97.41) UV8.C4 ; v1(157.83,97.41) UV8.C3 ; UV8.B6 160.1,97.73 v1(159.78,97.41) UV8.B5 ; v1(163.67,97.41) UV8.C11 ; UV8.K12 v1(164.32,92.21) ; UV8.K11 v1(163.67,92.21) ; UV8.K4 v1(158.48,92.21) ; v1(164.32,97.41) UV8.C12
  TOP w0.254: UV8.K3 158.15,92.53 v1(158.48,92.21)
  TOP w0.508: CV96.1 v1(168.29,99.13)
  BOTTOM w0.381: CV97.1 164.78,91.89 164.46,92.21 v1(164.32,92.21) ; CV95.1 158.48,91.82 v1(158.48,92.21)
  vias: v1(150.93,101.35) v1(150.94,100.76)
+3.3V_RUN_VMM: length 93.8
  TOP w0.102: v1(156.5,104.64) v2(155.56,104.64)
  TOP w0.508: RV516.2 152.84,101.54 v1(152.74,101.64) ; v1(170.81,96.07) 170.48,96.07 169.53,97.02 169.53,97.04 RV518.1 ; v1(170.83,92.59) 170.76,92.52 RV82.2 ; v1(182.17,98.75) 182.17,100.35 182.55,100.73 v1(182.55,101.27) ; v1(151.54,101.63) 151.63,101.54 151.63,100.75 152.1,100.28 RV517.1 RV84.2 RV83.2 ; v1(148.91,101.12) 148.95,101.16 LV24.1 ; RV88.1 v1(158.79,85.83) ; RV85.2 v1(169.91,102.81)
  IN2 w0.508: v1(197.04,101.73) 195.67,100.36 v1(195.67,98.9) 195.03,98.26 190.69,98.26 189.56,99.39 182.82,99.39 v1(182.17,98.75)
  IN3 w0.508: v1(170.81,96.07) 170.42,96.46 170.42,99.48 171.35,100.41 181.69,100.41 v1(182.55,101.27)
  IN4 w0.508: v1(159.73,99.25) 159.78,99.3 159.78,99.81 159.42,100.17 154.39,100.17 152.92,101.64 v1(152.74,101.64) ; v1(158.79,85.83) 158.79,85.56 161.43,82.92 161.96,82.92 163.28,81.6 167.5,81.6 169.95,84.05 v1(169.95,88.18)
  BOTTOM w0.254: RPV2.8 157.76,104.38 v1(157.52,104.63) 157.26,104.37 RPV2.7 ; RPV2.5 156.26,104.4 v1(156.5,104.64) 156.76,104.38 RPV2.6
  BOTTOM w0.381: CV121.1 181.62,99.72 UV12.14 ; CV118.1 195.59,99.72 UV11.14
  BOTTOM w0.508: v1(182.55,101.27) 182.55,101.03 182.87,100.71 RV91.1 ; CV118.1 v1(195.67,98.9) ; CV121.1 181.95,98.96 v1(182.17,98.75) ; CV114.1 153,92.52 RV87.1 ; CV114.1 151.93,93.49 UV9.8 ; CV114.1 152.01,92.47 v1(151.65,92.11) ; RV519.1 159.77,99.21 v1(159.73,99.25) ; RV86.1 159.04,104.47 v1(159.11,104.54) ; v1(197.04,101.73) 197.04,101.11 RV90.1
  vias: v1(171.2,89.93) v1(171.23,89.27) v1(172.3,89.12)
+3.3V_SPI: length 96.9
  TOP w0.508: v1(192.9,89.79) 194.87,89.79 198.69,85.97 198.69,81.45 199.81,80.33 v4(205.91,80.33) 211.99,80.33 v1(213.27,81.61)
  IN2 w0.508: v1(201.84,55.86) 201.47,55.86 200.88,55.26 200.86,55.27 200.36,55.27 200.11,55.03 193.13,55.03 192.54,55.62 189.6,55.62 v1(189.47,55.49)
  IN3 w0.508: v1(189.47,55.49) 191.73,57.75 191.73,58.82 193.41,60.5 193.41,67.24 192.13,68.52 v1(191,68.52)
  BOTTOM w0.254: RC31.1 188.77,56.33 189.03,56.58 190.37,56.58 191.78,57.99 CC6.1 ; RC231.2 210.81,82.4 210.11,83.1 JSPI1.6
  BOTTOM w0.381: RC31.1 189.45,55.51 v1(189.47,55.49)
  BOTTOM w0.508: v1(189.47,55.49) 189.55,55.57 UC2.8 ; RC29.1 201.51,55.53 v1(201.84,55.86) ; UC3.8 191.59,66.28 191.38,66.5 191.38,68.14 v1(191,68.52) 190.54,68.98 CC7.1 190.33,69.93 190.33,82.34 192.44,84.44 192.44,87.19 192.81,87.56 192.81,89.7 v1(192.9,89.79) ; RC231.2 210.81,81.59 211.37,81.03 212.69,81.03 v1(213.27,81.61)
+3.3V_SUS: length 206.9
  TOP w0.203: CI417.1 188.32,90.26 UI4.3 ; UI4.16 193.09,94.85 193.31,95.06 194.65,95.06 CI416.1 ; UI4.29 185.96,94.45 185.66,94.74 185.66,95.54 v1(185.7,95.58) ; CI415.1 194.83,93.21 194.06,93.21 194.02,93.25 UI4.12 ; UI4.9 190.72,91.98 191.15,91.56 191.15,90.54 CI414.1
  TOP w0.508: v1(195.41,92.37) 195.41,92.42 194.91,92.93 CI415.1 ; v1(189.85,103.7) v4(191.36,103.7) 192.33,102.73 192.33,100.22 191.99,99.88 191.99,98.2 191.67,97.88 ; CI414.1 190.67,90.31 190.67,91.33 v1(190.49,91.51) ; CI416.1 CI419.1 194.91,96.62 v1(194.81,96.73) ; RZ9.1 241.53,19.88 241.73,20.08 241.73,20.88 v1(241.72,20.89) RZ8.1 ; CI418.1 v1(184.14,92.94) ; CI417.1 188.18,90.19 v1(187.68,90.68)
  IN2 w0.508: v1(261.66,49.92) 261.66,49.92 262.09,50.35 266.56,50.35 267.08,49.82 268.57,49.82 269.14,50.4 269.14,50.41 270.66,51.93 271.14,51.93 272.14,52.92 272.14,54.61
  IN3 w0.508: v1(241.72,20.89) 239.76,22.85 239.76,38.46 246.38,45.09 256.41,45.09 258.17,46.84 258.17,47.37 258.99,48.19 259.52,48.19 260.43,49.1 261.07,49.1 261.66,49.69 v1(261.66,49.92) ; v1(160.2,103.69) 160.47,103.95 182.47,103.95 183.32,103.1 186.65,103.1 187.2,103.65 189.8,103.65 v1(189.85,103.7)
  IN3 w1.524: 193.95,90.72 204.51,90.72 204.95,91.16 223.5,91.16 224.55,90.11 240.74,90.11 241.25,90.62 242.65,90.62 244.06,89.21 248.04,89.21 250.74,91.9 259.08,91.9 262.41,95.23 272.97,95.23
  BOTTOM w0.254: CI38.1 161.63,104.46 UI5.10
  BOTTOM w0.508: CI38.1 160.43,103.9 160.21,103.69 v1(160.2,103.69) ; v1(241.72,20.89) 240.45,19.62 240.45,18.48 v1(240.09,18.13)
  vias: v1(190.47,97.36) v1(191.07,97.36) v1(191.67,97.39) v1(270.47,56) v1(271.08,55.74) v1(271.07,55.15) v1(274.35,96.39) v1(274.37,95.78) v1(274.89,96.1)
+3.3V_SUS_UZ3:
  vias: v2(272.12,59.16)
+3.3V_TP:
  vias: v4(239.84,38.12)
+3.3V_WLAN: length 6.6
  TOP w0.102: v1(269.79,50.19) 269.79,50.99 v4(269.91,51.12)
  TOP w0.457: QZ2.5 274.36,50.66 v1(274.6,50.42) ; QZ2.2 v1(274.36,54.31)
  TOP w0.508: v1(273.15,53.99) 273.09,53.93 273.09,53.9 272.58,53.39 RZ15.2 ; v1(276.64,50.75) 276.14,51.25 RZ14.2
  vias: v1(269.8,49.61) v1(270.45,50.21) v1(270.43,49.6) v1(277.71,55.72) v1(277.71,55.07) v1(278.76,55.69) v1(278.76,55.04) v1(279.36,55.7) v1(279.36,55.06) v1(287.91,50.42) v1(287.91,49.84) v1(288.53,50.42) v1(288.53,49.84)
+3.3V_WLAN_UZ3:
  vias: v2(276.97,58.92)
+3.3V_WWAN: length 44
  TOP w0.381: v1(276.69,53.36) 276.69,53.52 276.9,53.72 277.63,53.72 277.91,53.44 QZ11.2
  TOP w0.508: v1(280.96,50.9) 280.96,50.9 280.54,50.9 279.97,51.48 RZ37.2 ; RZ39.1 v1(286.22,93.03)
  IN1 w0.508: v1(276.69,53.36) 276.69,53.36 278.23,51.82 280.2,51.82 281,51.02 281,50.94 280.96,50.9 v1(280.96,50.9)
  IN2 w0.508: v1(282.57,82.49) 282.57,78.83 283.06,78.35 283.06,72.01 282.03,70.99 282.03,64.42 280.62,63.01 280.62,59.81 280.04,59.23 280.04,56.94 280.78,56.19 280.78,54.19 280.45,53.86 280.45,51.41 v1(280.96,50.9)
  vias: v1(265.94,78.86) v1(266.18,78.27) v1(266.56,78.96) v1(266.76,78.27) v1(267.27,77.66) v1(267.39,78.31) v1(281.58,99.49) v1(281.56,98.91) v1(282.17,99.49) v1(282.18,98.9) v1(282.57,83.11) v1(283.16,83.21) v1(283.2,82.62) v1(283.25,83.79) v1(291.77,79.3) v1(291.71,78.7) v1(292.29,78.7) v1(292.35,79.29) v1(292.96,79.31) v1(292.95,78.7) v4(282.61,101.03)
+3.3V_WWAN_UZ2: length 2.7
  TOP w0.102: v2(265.87,72.91) 265.75,73.04 265.75,74.74 265.95,74.95 CZ24.1
+3V5V_PWR_SRC: length 7.1
  IN1 w0.508: v3(214.73,65.41) 214.67,65.47 v3(207.68,65.47)
  vias: v3(205.93,67.93) v3(205.96,67.15) v3(205.96,66.26) v3(205.96,65.5) v3(206.77,67.91) v3(206.79,67.12) v3(206.79,66.23) v3(206.79,65.47) v3(207.68,67.88) v3(207.68,67.12) v3(207.68,66.23) v4(205.33,66.75)
+5V_ALW: length 599.9
  TOP w0.203: v1(274.71,62.35) 274.61,62.25 UZ3.4 ; v1(216.74,86.55) 216.7,86.59 216.7,87.51 216.64,87.57 UZ9.4 ; UZ2.4 268.77,72.46 269,72.23 v1(269,72.1) ; UZ8.4 185.65,33.87 186.02,33.51 189.08,33.51 190.25,34.67 190.25,34.91 v1(190.32,34.99)
  TOP w0.254: v1(302.86,52.71) 303.1,52.71 303.44,53.05 UN3.4 ; 304.14,78.93 304.53,78.54 UI3.1 ; UZ7.4 177.48,79.07 177.22,78.81 v1(176.99,78.81)
  TOP w0.305: JLED1.1 293.26,41.73 293.05,41.52
  TOP w0.508: v1(237.67,43.74) 237.67,45.54 238.54,46.42 v4(238.54,48.45) 238.54,49.57 240.82,51.84 240.82,52.91 240.07,53.66 240.07,57.15 240.55,57.64 v1(241.27,57.64) 241.72,57.64 242.05,57.3 RZ21.1 ; RD9.1 132.88,2.03 v1(132.49,1.64) ; v1(103.61,30.04) 103.61,32.12 102.92,32.81 102.92,33.89 102.35,34.46 102.35,35.84 v1(102.07,36.12) ; CI422.1 310.73,88.48 311.42,89.18 311.42,96.29 v1(311.87,96.74) 317.64,96.74 LED3.2 ; v1(245,45.72) 245.19,45.53 249.21,45.53 250.86,43.88 v4(252.39,43.88) 261.79,43.88 263.06,42.62 263.06,33.86 PR202.1 PR204.2 ; v1(304.08,79.89) 304.01,79.95 CI19.1 303.38,79.94 303.38,79.31 303.76,78.93 304.14,78.93 ; v1(171.06,82.59) 169.57,84.08 RV210.1 ; 293.05,41.52 291.33,41.52 290.39,42.45 290.39,43.52 v1(290.02,43.9) ; RZ5.1 v1(173.3,82.62) ; RI13.2 v1(302.35,76.28)
  IN1 w0.508: v1(87.92,1.88) 88.69,2.65 100.37,2.65 100.67,2.35 110.63,2.35 111.12,1.86 v1(111.12,1.53) ; v1(289.77,64.87) 289.62,64.72 276.83,64.72 275.09,62.98 275.09,62.73 v1(274.71,62.35) ; v1(273.7,69.79) 273.7,69.9 273.63,69.97 273.63,71.38 271.41,73.6 270.5,73.6 v1(269,72.1) ; v1(190.32,34.99) 190.32,34.07 190.92,33.47 191.68,33.47 193.04,32.11 203.3,32.11 205.52,29.89 222.14,29.89 222.91,30.66 v1(223.1,30.66)
  IN2 w0.508: v3(229.97,59.25) 230.37,58.85 239.96,58.85 241.17,57.64 v1(241.27,57.64) ; v1(302.35,76.28) 303.26,77.19 303.26,79.07 v1(304.08,79.89) 304.08,80.01 305.16,81.09 305.16,84.31 306.17,85.32 307.52,85.32 311.87,89.68 v1(311.87,96.74) ; v1(171.06,82.59) 173.28,82.59 v1(173.3,82.62) ; v1(289.77,64.87) 289.77,57.4 293.59,53.58 293.59,50.43 294.51,49.51 v1(294.51,48.03) ; v1(88.89,28.53) 89.27,28.53 89.79,28.01 89.79,25.61 88.05,23.87 88.05,18.07 87.27,17.3 87.27,9.26 85.29,7.28 85.29,3.61 85.84,3.06 86.94,3.06 87.92,2.09 v1(87.92,1.88)
  IN3 w0.508: v1(213.78,86.43) 213.51,86.43 212.9,85.82 212.9,85.6 212.33,85.03 194.47,85.03 192.26,82.82 173.51,82.82 v1(173.3,82.62) ; v1(88.89,28.53) 92.2,28.53 94.01,30.33 98.26,30.33 99.77,28.82 102.33,28.82 103.55,30.04 v1(103.61,30.04) ; v1(302.86,52.71) 300.65,50.5 296.98,50.5 v1(294.51,48.03) 294.51,47.35 293.71,46.55 292.05,46.55 290.45,44.95 290.45,44.33 v1(290.02,43.9) 284.51,43.9 283.8,44.6 278.39,44.6 274.77,48.22 268.78,48.22 265.7,51.3 258.94,51.3 258.3,50.66 255.27,50.66 255.03,50.42 252.17,50.42 251.87,50.12 247.82,50.12 247.23,49.53 247.23,48.66 245,46.42 v1(245,45.72) 245,45.04 239.31,39.36 v1(237.67,39.36) 237.2,38.89 234.99,38.89 232.94,36.85 231.86,36.85 226.26,31.24 225.32,31.24 224.74,30.66 v1(223.1,30.66)
  IN4 w0.508: v1(132.49,1.64) 132.49,1.77 131.85,2.42 130.67,2.42 130.46,2.63 123.99,2.63 123.65,2.29 113.94,2.29 113.18,1.53 v1(111.12,1.53) ; v3(105.13,63.95) 105.13,63.65 104.36,62.88 101.13,62.88 100.61,63.4 99.18,63.4 97.56,61.78 97.56,55.34 96.67,54.45 96.67,51.89 97.83,50.74 v3(99.1,50.74) 99.1,50.28 103.3,46.08 103.3,41.56 103.73,41.13 103.73,38.52 102.78,37.57 102.78,37.38 102.07,36.67 v1(102.07,36.12)
  BOTTOM w0.356: PU1.5 v3(41.25,81.12)
  BOTTOM w0.508: v3(105.13,63.95) 105.13,64.02 105.19,64.09 PR526.2 ; v1(237.67,43.74) v1(237.67,39.36) ; PC20.1 54.84,100.74 54.01,101.56 v1(53.89,101.56) ; v1(173.3,82.62) 174.7,82.62 175.06,82.26 175.06,80.27 176.52,78.81 v1(176.99,78.81) ; PR843.2 v3(99.1,50.74) ; v1(103.61,30.04) 104.65,29 108.83,29 111.37,31.54 187.2,31.54 190.32,34.66 v1(190.32,34.99) ; PR11.1 v3(42.96,81.47) ; v3(229.97,59.25) 229.97,59.62 PC400.1 230.73,59.74 230.73,58.99 230.54,58.8 PU400.6
  vias: v1(42.93,100.89) v1(43.56,100.9) v1(43.92,100.36) v1(44.26,100.89) v1(53.29,102.19) v1(53.3,101.58) v1(53.59,101.03) v1(53.87,102.17) v1(76.37,101.42) v1(76.78,102.15) v1(76.95,101.41) v1(77.01,100.78) v1(213.83,85.79) v1(255.77,98.54) v1(255.71,97.4) v1(256.37,98.54) v1(256.35,97.4) v1(289.52,68.42) v1(289.52,67.81) v1(290.12,68.43) v1(290.13,67.8) v1(290.13,67.19) v1(307.4,75.19) v1(307.42,74.55) v1(308.28,75.72) v1(308.27,75.12) v1(308.28,74.53) v3(223.81,58.55) v3(223.81,57.72) v3(223.81,56.96) v3(223.81,56.26) v3(223.81,55.63) v3(224.57,58.55) v3(224.57,57.72) v3(224.57,56.96) v3(224.57,56.26) v3(224.57,55.63) v4(213.91,88.08)
+5V_ALW2: length 3
  TOP w0.203: PU100.13 215.91,63.85 v3(215.87,63.88)
  BOTTOM w0.102: v2(215.18,64.07) 215.37,63.88 v3(215.87,63.88)
  BOTTOM w0.508: PC118.1 216.26,64.26 v3(215.87,63.88)
+5V_ALW_UZ5: length 3.2
  TOP w0.508: UZ5.1 241.74,54.17 v2(241.17,54.74) 241.17,55.91 CZ35.1 RZ21.2
+5V_ALWP: length 31.1
  TOP w0.102: v2(224.07,62.8) v3(223.43,62.8)
  TOP w0.203: PU100.14 216.34,63.45 216.14,63.25 215.43,63.25 v3(215.37,63.31)
  IN1 w0.254: v3(217.56,54.07) 220.61,54.07 222.48,55.93 222.48,61.85 v3(223.43,62.8)
  IN2 w0.508: v3(217.53,55.67) 219.66,55.67 221.11,57.11 221.11,61.7 220.03,62.77 217.68,62.77 217.21,63.25 215.43,63.25 v3(215.37,63.31)
  BOTTOM w0.254: PR101.2 v3(223.43,62.8)
+5V_HDD: length 62.7
  TOP w0.508: RN1.1 v1(281.94,63.01)
  IN1 w0.508: v1(302.59,62.52) 302.3,62.23 282.8,62.23 282.03,63.01 v1(281.94,63.01)
  IN2 w0.508: v1(305.23,36.64) 305.23,55.12 304.52,55.83 304.52,61.33 303.42,62.44 302.68,62.44 v1(302.59,62.52)
  IN4 w0.508: v1(305.23,36.64) 303.86,35.27 v1(292.37,35.27)
  vias: v1(292.37,35.94) v1(292.34,34.56) v1(292.33,33.95) v1(310.15,40.06) v1(310.16,39.45) v1(310.77,40.06) v1(310.78,39.45) v2(292.06,33.19)
+5V_RUN: length 277.7
  TOP w0.203: CV144.1 183.18,94.85 UV16.16
  TOP w0.254: RPE2.4 240.11,62.18 v1(239.86,62.42) 240.12,62.68 RPE2.3 ; RPE2.2 239.98,63.18 239.84,63.32 v1(239.84,63.35) 240.17,63.68 RPE2.1
  TOP w0.305: CZ29.1 235.57,28.54 235.01,28.54 234.61,28.95 234.61,30.9 234.27,31.24 JKBTP1.12
  TOP w0.508: CZ29.1 v1(236.05,27.93) ; CV144.1 183.22,94.97 183.65,95.4 v1(183.65,97.67) ; PC509.2 130.75,87.82 130.31,87.39 130.31,86.71 v1(130.39,86.63)
  IN1 w0.508: v1(117.73,99.29) 117.73,98.22 116.97,97.46 106.62,97.46 v1(105.6,96.45) ; v1(239.86,62.42) 239.93,62.49 239.93,63.26 v1(239.84,63.35)
  IN1 w1.016: 45.9,100.46 45.35,99.91 45.35,93.21 42.96,90.82 42.96,83.17 44.62,81.52 45.15,81.52
  IN2 w0.508: v1(238.18,15.13) 236.93,16.37 236.93,27.05 v1(236.05,27.93) ; v1(244.97,65.15) 240.63,65.15 239.84,64.37 v1(239.84,63.35)
  IN3 w0.508: v1(295.02,32.9) 270.98,32.9 266.57,37.3 v1(265.76,37.3) ; v1(269.32,67.44) 269.2,67.55 263.74,67.55 263.65,67.46 260.55,67.46 260.34,67.68 251.12,67.68 250.24,66.79 245.56,66.79 244.97,66.2 v1(244.97,65.15) ; v1(183.65,97.67) 187.06,97.67 189.31,99.91 197.03,99.91 v1(198.01,98.94)
  IN4 w0.381: v1(130.39,86.63) 130.4,86.63 130.75,86.29 131.1,86.29 131.6,86.78 131.6,90.99 131.84,91.23 131.84,92.73 132.61,93.5 132.61,98.24 132.12,98.73 118.3,98.73 117.73,99.3 v1(117.73,99.29)
  IN4 w0.508: v1(265.76,37.3) 264.63,38.43 264.63,40.5 264.19,40.94 263.84,40.94 262.71,42.06 260.95,42.06 260.29,42.73 254.99,42.73 254.27,43.45 241.86,43.45 239.79,41.39 237.32,41.39 236.13,40.2 236.13,28.01 v1(236.05,27.93)
  BOTTOM w0.203: PU501.2 130.14,87.26 130.39,87.01 v1(130.39,86.63)
  BOTTOM w0.508: RV6.1 108.37,94.55 108.13,94.31 105.4,94.31 QV8.3 ; v1(265.76,37.3) 266.22,37.76 266.22,43.75 265.91,44.06 265.91,46.87 266.88,47.84 266.88,51.82 266.61,52.09 266.61,57.09 269.6,60.07 269.6,67.16 v1(269.32,67.44)
  BOTTOM w1.016: 72.45,76.22 72.96,76.22 75.79,73.38 75.79,68.99 75.48,68.67 75.48,67.35 77.25,65.57 81.78,65.57
  vias: v1(36.97,90.4) v1(36.98,89.58) v1(37.01,91.25) v1(37.45,91.71) v1(37.41,90.82) v1(37.44,90.01) v1(45.66,102.26) v1(45.66,101.68) v1(45.63,101.03) v1(46.28,102.26) v1(46.27,101.64) v1(46.27,101.03) v1(71.03,76.29) v1(71.62,76.29) v1(89.88,59.53) v1(90.54,59.53) v1(96.11,102.87) v1(96.34,102.31) v1(96.7,102.86) v1(96.99,102.35) v1(97.29,102.87) v1(97.56,102.17) v1(99.1,107.93) v1(99.12,107.27) v1(99.7,107.91) v1(99.7,107.13) v1(100.18,107.57) v1(100.11,106.61) v1(103.35,96.31) v1(103.71,96.85) v1(105.08,96.17) v1(136.69,111.34) v1(136.68,110.73) v1(137.27,111.32) v1(137.3,110.73) v1(137.86,111.34) v1(137.88,110.72) v1(198.3,105.9) v1(198.71,105.48) v1(199.14,105.92) v1(199.54,105.48) v1(199.94,105.92) v1(200.36,105.51) v1(211.14,94.69) v1(211.12,94.1) v1(211.75,94.73) v1(211.75,94.05) v1(212.5,94.08) v1(212.51,94.68) v1(213.12,94.72) v1(213.12,94.03) v1(273.37,109.01) v1(273.32,108.37) v1(273.32,107.74) v1(273.98,108.37) v1(273.98,107.76) v1(274,109.01) v1(293.2,92.19) v1(293.2,91.59) v1(293.2,90.97) v1(293.2,90.39) v1(295.01,33.52) v1(295.53,65.04) v1(295.67,33.52) v1(295.66,32.91) v1(295.73,64.48) v1(296.11,65.03) v1(296.35,64.48) v4(298.62,76.52)
+5V_RUN_AUDIO: length 11.4
  IN2 w0.508: v1(23.36,91.95) 23.22,91.95 21.36,93.8 19.47,93.8 18.53,94.74 v1(18.53,97.46)
  BOTTOM w0.508: v1(18.53,97.46) LA5.2
  vias: v2(25.21,82.62)
+5V_RUN_PVDD:
  vias: v1(25.72,90.29) v1(25.97,90.85) v1(28.92,90.62) v1(29.22,90.11) v2(27.09,91.51)
+5V_RUN_UZ9:
  vias: v2(213.02,90.24)
+5V_TSP:
  vias: v4(105.46,99.47)
+5V_USB_CHG_PWR:
  vias: v4(309.51,80.13)
+GND_CHASSIS: length 12.5
  TOP w1.016: 317.92,100.9 316.01,100.9 314.29,99.18 RL18.2
  vias: v1(318.81,101.03) v1(319.7,101.03) v2(301.16,98.75)
+V1.05S_APLLOPI: length 30.2
  TOP w0.254: CC68.1 155.94,59.25 154.85,59.25 154.72,59.38 154.72,64.65 155.42,65.34 155.42,68.2 155.8,68.58 155.8,73.41 v1(155.49,73.73)
  TOP w0.508: v1(156.92,59.15) 156.58,59.5 CC68.1
  BOTTOM w0.254: v1(155.49,73.73) 155.23,73.73 154.85,74.11 154.85,75.5 154.09,76.27 154.09,78.04 152.82,79.31 CC67.1 153.11,80.18 LC3.2 153.11,83.06 v2(153.42,83.37) ; UC1.W21 157.3,59.52 v1(156.92,59.15) 157.3,58.78 UC1.AA21
+V1.05SP_B+: length 2.2
  BOTTOM w0.102: 219.9,49.7 220.56,49.7 v2(221.68,48.58)
+VCC_CORE: length 86.3
  IN2 w0.508: v1(129.48,70.93) 129.34,70.79 124.94,70.79 120.74,66.59 118.88,66.59 118.57,66.27 v1(118.57,65.73)
  IN4 w0.508: v1(116.36,63.53) 117.54,64.71 117.54,64.79 118.48,65.73 v1(118.57,65.73)
  BOTTOM w0.127: UC1.AB57 133.93,58.25 ; 133.93,58.25 134.24,57.95 ; 133.93,58.25 v1(134.47,58.25) ; 149.63,66.5 149.54,66.5 UC1.G33 ; 137.01,66.52 136.75,66.78 UC1.G53 ; UC1.G27 152.92,66.56 152.81,66.56 ; UC1.G27 153.27,66.91 153.27,67.22 ; UC1.G27 152.81,67.12 ; UC1.G27 153.24,66.69 153.24,66.17 153.21,66.13 ; 134.29,57.31 UC1.AD57 ; UC1.AD57 133.93,56.95 134.18,56.69 ; UC1.AD57 134.31,56.95 ; UC1.G53 136.72,66.17 ; UC1.G53 137.01,67.08 137.01,67.09 ; UC1.G53 136.63,66.87 136.63,67.21 ; 142.01,67.13 142.01,67.06 UC1.G45 ; UC1.J23 155.61,64.99 155.49,64.99 ; UC1.J23 155.55,65.56 155.3,65.56 ; UC1.J23 155.94,65.18 155.94,64.86 ; UC1.J23 155.96,65.33 155.96,65.97 UC1.H23 ; UC1.G57 134.22,66.78 ; UC1.G57 134.21,66.4 134.23,66.39 ; UC1.G57 134.21,66.79 134.03,66.97 134.03,67.15 ; 134.22,66.78 134.23,66.78 134.47,67.02 ; 134.22,66.78 134.47,66.54 ; UC1.G23 155.43,66.56 155.28,66.56 ; UC1.G23 155.85,66.99 155.85,67.13 ; UC1.G23 155.91,66.52 155.91,66.1 UC1.H23 ; UC1.G23 155.36,67.08 ; 147.44,67.13 147.07,67.49 ; 147.44,67.13 147.44,67.57 v1(147.57,67.71) ; 147.44,67.13 UC1.F36 147.44,66.6 147.39,66.55 ; 150.23,67.38 150.21,67.38 149.95,67.12 149.95,67.11 ; UC1.G31 150.62,66.78 150.3,66.46 ; UC1.G31 150.64,66.79 150.37,67.05 ; UC1.G31 150.64,66.17 ; UC1.G31 150.73,66.88 150.73,67.23 ; UC1.G25 154.16,66.67 154.16,66.07 ; UC1.G25 154.6,66.45 ; UC1.G25 154.45,66.96 154.6,66.96 ; UC1.G25 154.18,66.87 154.18,67.2 ; 152.45,66.63 UC1.F28 152.45,67.12 ; UC1.G41 144.24,66.78 144.13,66.67 144.13,66.25 144.2,66.17 144.24,66.17 ; UC1.G41 144.13,66.9 144.13,67.18 144.2,67.25 ; UC1.G41 144.55,67.09 ; UC1.G41 144.4,66.62 144.68,66.62 ; 149.72,66.88 149.95,67.1 UC1.F32 ; UC1.G29 151.99,66.56 152.17,66.56 ; UC1.G29 151.64,66.66 151.64,66.29 151.76,66.17 ; UC1.G29 152.04,67.07 ; 149.21,67.21 149.21,66.83 UC1.G33 ; UC1.G47 140.61,66.8 140.32,67.09 ; UC1.G47 140.73,66.91 140.73,67.22 ; UC1.G47 140.7,66.69 140.7,66.26 140.61,66.17 ; UC1.G47 140.58,66.78 140.25,66.45 ; 141.61,67.25 141.61,66.91 UC1.G45 ; v1(137.54,67.71) 137.54,67.3 137.41,67.17 UC1.F52 ; UC1.F40 144.93,67.11 ; UC1.F40 144.93,66.66 ; UC1.F40 145.31,67.11 ; 144.93,67.11 144.93,67.57 v1(145.07,67.71) ; 144.93,67.11 144.66,67.39 ; UC1.G33 149.57,67.1 149.57,67.13 ; UC1.G33 149.21,66.73 149.21,66.22 149.26,66.17 ; 147.79,67.13 147.79,67.12 UC1.G35 ; 147.66,66.5 147.84,66.5 UC1.G35 ; 133.93,64.76 134.34,64.76 ; 133.93,64.76 UC1.K57 133.93,64.72 134.17,64.47 ; 133.93,64.76 134.2,65.03 134.21,65.03 ; v1(152.59,67.71) 152.45,67.57 152.45,67.12 ; UC1.M57 v1(134.47,63.46) ; UC1.M57 134.2,63.73 134.21,63.73 ; UC1.M57 133.93,63.45 134.28,63.09 ; 139.73,66.56 139.45,66.56 UC1.G49 ; UC1.AG57 133.93,55.65 ; 133.93,55.65 134.42,55.65 ; 133.93,55.65 134.12,55.84 134.4,55.84 ; v1(134.47,60.85) 133.93,60.85 UC1.U57 ; 154.58,67.32 154.8,67.11 UC1.F24 ; 137.14,67.38 137.14,67.38 UC1.F52 ; UC1.P57 134.26,62.49 134.35,62.49 ; UC1.P57 134.47,62.16 v1(134.47,62.15) ; UC1.P57 134.2,61.89 134.32,61.89 134.39,61.82 134.55,61.82 ; UC1.F52 137.12,66.82 137.12,66.79 ; UC1.F52 137.44,67.11 137.7,66.85 ; UC1.G51 138.09,66.78 137.85,67.02 ; UC1.G51 138.22,66.66 138.22,66.3 138.1,66.17 ; UC1.G51 138.22,66.91 138.22,67.21 ; UC1.G51 138.1,66.77 137.84,66.52 ; UC1.G37 146.67,66.87 146.67,67.21 ; UC1.G37 146.75,66.79 147.05,67.09 ; UC1.G37 146.75,66.17 ; UC1.G37 146.78,66.78 147.05,66.52 ; 155.63,65.8 155.87,66.04 UC1.H23 ; UC1.F32 150.18,66.88 ; UC1.F32 149.95,67.11 ; UC1.G45 141.96,66.56 142.2,66.56 ; UC1.G45 141.64,66.69 141.64,66.27 141.73,66.17 ; UC1.L22 156.38,64.14 156.09,64.43 UC1.K23 155.87,64.43 155.53,64.1 ; UC1.L22 155.88,64.03 ; UC1.L22 155.97,63.62 UC1.M23 155.85,63.62 155.57,63.9 ; 134.9,67.1 UC1.F56 ; 134.9,67.1 134.9,67.09 134.61,66.8 ; 134.9,67.1 135.19,66.82 ; UC1.F56 134.92,67.11 135.21,67.4 ; UC1.F56 134.9,67.58 v1(134.79,67.69) ; UC1.F48 139.6,67.43 ; UC1.F48 139.92,67.57 v1(140.05,67.71) ; UC1.F48 139.92,67.08 ; UC1.G43 143.24,66.66 143.24,66.3 143.23,66.3 143.11,66.18 143.11,66.17 ; UC1.G43 142.84,67.06 142.84,67.19 ; UC1.G43 143.22,66.89 143.22,67.26 ; UC1.G43 142.89,66.56 142.65,66.56 ; UC1.G49 139.11,66.9 139.11,67.28 ; UC1.G49 139.54,67.09 139.54,67.13 ; UC1.G49 139.11,66.67 139.11,66.29 139.23,66.17 ; 142.42,66.66 UC1.F44 ; UC1.F44 142.37,67.11 142.08,67.4 ; UC1.F44 142.42,67.58 v1(142.56,67.71) ; UC1.G55 135.68,66.87 135.68,67.21 ; UC1.G55 135.59,66.79 135.3,67.09 ; UC1.G55 135.57,66.78 135.3,66.52 ; UC1.G55 135.74,66.63 135.74,66.32 ; 149.95,67.11 149.94,67.11 149.67,67.38 ; 145.38,66.43 145.62,66.68 UC1.G39 ; 152.45,67.12 152.15,67.42 ; 145.57,67.19 145.62,67.14 UC1.G39 ; UC1.G39 145.22,66.78 145.19,66.75 ; 134.26,59.79 134.17,59.79 UC1.W57 ; UC1.H23 155.86,66.06 155.61,66.31 ; UC1.W57 134.2,59.28 134.28,59.28 ; UC1.W57 v1(134.47,59.55) ; UC1.U57 133.97,60.86 134.23,60.6 ; UC1.U57 134.2,61.13 134.34,61.13 ; UC1.G35 148.3,66.61 148.3,66.34 148.13,66.17 ; UC1.G35 148.3,66.95 148.3,67.19 ; 154.96,66.69 UC1.F24 ; UC1.F24 155.01,67.11 155.22,67.32 ; 139.92,67.08 139.92,66.65 ; 139.92,67.08 140.21,66.78
  BOTTOM w0.254: UC1.F59 133.18,66.76 133.35,66.59 v1(133.35,66.49)
  BOTTOM w0.508: v1(116.36,63.53) 116.79,63.1 RC209.1
  vias: v1(131.74,77.54) v1(131.75,76.95) v1(134,83.71) v1(134.06,77.57) v1(134.07,76.95) v1(134.58,66.12) v1(134.69,64.76) v1(135.12,83.84) v1(135.29,82.72) v1(135.29,82.08) v1(135.29,81.3) v1(135.27,80.51) v1(135.59,66.17) v1(136.28,82.84) v1(136.28,82.13) v1(136.28,81.32) v1(136.28,80.51) v1(136.75,77.62) v1(136.74,77.04) v1(136.72,66.17) v1(138.1,66.17) v1(139.24,77.52) v1(139.24,76.94) v1(139.23,66.17) v1(140.61,66.17) v1(141.62,77.66) v1(141.62,77.08) v1(141.67,70.99) v1(141.74,84.83) v1(141.74,84.19) v1(141.73,66.17) v1(143.11,66.17) v1(144.24,66.17) v1(144.67,84.36) v1(144.65,83.75) v1(144.65,77.65) v1(144.65,77.07) v1(144.7,81.18) v1(144.7,80.57) v1(145.19,82.86) v1(145.19,82.26) v1(145.72,66.07) v1(146.57,82.91) v1(146.57,82.32) v1(146.57,81.23) v1(146.58,80.63) v1(146.75,66.17) v1(146.91,77.65) v1(146.91,77.04) v1(148.13,66.17) v1(149.26,66.17) v1(150.08,67.71) v1(150.63,66.18) v1(151.68,66.17) v1(153.14,66.17) v1(154,66.05) v3(128.99,78.04) v3(129.2,83.25) v3(129.17,82.26) v3(129.17,81.24) v3(129.17,80.33) v3(129.2,79.29) v3(129.67,78.03) v3(130.09,82.29) v3(130.06,81.27) v3(130.06,80.3) v3(130.06,79.24) v3(130.11,83.28) v3(130.47,78.02) v3(131.03,83.35) v3(131.03,82.34) v3(131.03,81.32) v3(131.03,80.3) v3(131.03,79.29) v3(131.15,77.99) v3(131.79,84.17) v3(132.04,83.4) v3(132.04,82.39) v3(132.04,81.37) v3(132.04,80.36) v3(132.85,84.14) v4(147.99,81.85)
+VCC_PWR_SRC: length 28.7
  TOP w0.102: v1(116.7,91.35) v2(116.7,92.06)
  TOP w0.508: v3(109.26,76.65) 109.26,75.59 108.59,74.92 PR518.1
  IN1 w0.508: v3(109.26,76.65) 109.78,76.13 117.49,76.13 118.03,76.67 118.03,90.02 v1(116.7,91.35)
  BOTTOM w0.508: PR511.1 v3(109.26,76.65)
  vias: v3(122.34,91.76) v3(122.85,92.2) v3(123.55,92.2) v3(124.18,92.2) v3(125.34,92.17) v3(125.97,92.17) v3(126.91,92.15)
+VCCIO_OUT: length 8
  BOTTOM w0.254: UC1.A59 133.08,70.74 132.15,71.67 132.15,72.43
  BOTTOM w0.508: 132.15,72.43 130.53,74.05 v2(130.53,75.44) RC196.1
+VCCIOA_OUT: length 4.9
  TOP w0.254: RC133.1 156.55,65.9 156.96,65.5 157.54,65.5 157.84,65.79 v2(157.84,66.36) 157.84,67.62 158.05,67.84 v1(158.29,67.84)
  BOTTOM w0.254: v1(158.29,67.84) 158.03,67.84 UC1.E20
+VDDA_AVDD1: length 3.6
  TOP w0.203: UA1.27 23.28,96.21 23.22,96.27 23.09,96.27 21.76,97.6
  TOP w0.406: v1(22.44,98.14) 21.91,97.6 CA8.1
  vias: v2(22.92,98.34)
+VDDA_PVDD: length 3.7
  TOP w0.203: v1(22.17,89.91) 23.14,90.87 24.4,90.87 24.61,91.09 24.65,91.09 24.84,91.28 24.84,91.31 24.91,91.38 UA1.38
  vias: v1(21.59,89.88) v2(21.88,89.35)
GND: length 4030.1
  TOP w0.102: v3(102.4,57.15) 102.34,57.15 v4(101.77,57.72) ; v4(167.42,12.77) 168.14,12.77 v1(168.14,12.76) ; v3(257.57,41.52) 257.57,42.2 v4(257.59,42.23) ; v1(95.54,12.75) v4(95.54,13.52) ; v4(228.77,49.22) 228.77,48.5 v1(228.73,48.47) ; v4(68.87,4.51) 68.87,5.15 v3(68.94,5.21) ; v4(217.21,13.4) v1(217.21,12.83) ; v4(212.57,51.63) v3(212.57,50.87)
  TOP w0.203: UV8.D11 163.35,96.43 v1(163.02,96.76) 162.7,96.43 UV8.D10 ; UV8.E4 158.8,95.78 v1(158.48,96.11) ; UV8.F8 161.4,95.13 v1(161.72,95.46) ; UZ2.11 268.77,75.68 v1(268.85,75.76) ; UV8.G7 v1(160.43,94.16) ; UV8.G11 v1(163.67,94.16) ; UV8.J9 v1(162.37,92.86) ; v1(162.37,96.76) 162.05,96.43 UV8.D9 ; UV8.G4 v1(158.48,94.16) ; v1(160.43,95.46) 160.75,95.13 UV8.F7 ; UV8.H10 v1(163.02,93.51) ; UV8.J7 v1(160.43,92.86) ; v1(177.13,94.01) 176.89,93.77 UV16.3 ; UV8.D5 159.45,96.43 v1(159.13,96.76) ; UV8.F4 158.8,95.13 v1(158.48,95.46) ; v1(163.02,95.46) 162.7,95.13 UV8.F10 ; UZ9.11 UZ9.15 ; v1(180.48,91.7) 180.09,92.08 UV16.11 ; UV8.J12 v1(164.32,92.86) ; JKBTP1.8 v1(232.59,33.24) ; UV8.F11 163.35,95.13 v1(163.67,95.46) 163.35,95.78 UV8.E11 ; UV8.G8 v1(161.72,94.16) ; v1(161.72,96.76) 161.4,96.43 UV8.D8 UV8.D7 ; v1(190.51,94.03) 191.52,93.02 UI4.11 ; UV8.D4 158.8,96.43 v1(158.48,96.76) ; UV8.C5 v1(159.78,96.76) 160.1,96.43 UV8.D6 ; v1(174.18,93.6) 174.23,93.65 UV16.31 ; UV8.J6 v1(159.78,92.86) ; UI4.28 187.64,94.85 v1(188.43,94.06) ; UV8.H4 v1(158.48,93.51) ; UV8.G10 v1(163.02,94.16) ; UV8.J8 v1(161.72,92.86) ; UV8.J5 v1(159.13,92.86) ; UV8.F6 160.1,95.13 v1(159.78,95.46) 159.45,95.13 UV8.F5 ; UV8.G5 159.45,94.48 v1(159.78,94.16) UV8.G6 ; UV8.J11 v1(163.67,92.86) ; v1(162.37,95.46) 162.05,95.13 UV8.F9 ; UV8.L8 UV8.L7 v1(160.43,91.56) 160.1,91.88 UV8.L6 ; UV8.G9 v1(162.37,94.16) ; UZ8.11 v1(185.65,35.88) ; UI4.21 189.92,94.45 v1(189.52,94.05) ; UZ3.11 274.61,58.79 v1(274.69,58.71) ; UV8.K5 v1(159.13,92.21) ; UV16.28 174.73,94.85 174.26,95.32 v1(174.26,95.47)
  TOP w0.254: CZ65.2 284.4,92.46 v1(283.31,92.46) ; UV8.C13 164.65,97.08 v1(164.97,96.76) 164.65,96.43 UV8.D13 ; RPE10.6 271.31,63.57 v1(271.36,63.52) 270.92,63.07 RPE10.5 ; RPE10.7 270.99,64.07 v1(271.36,64.44) 271.23,64.57 RPE10.8 ; v1(287.06,60.28) 287.06,60.06 286.74,59.74 UN1.5 ; UC7.7 107.04,39.23 v1(107,39.27) ; UE1.B27 250.09,78.94 250.28,79.14 v1(250.49,79.14) ; v1(165.62,96.76) 165.3,96.43 UV8.D14 ; v1(299.15,40.96) 298.46,40.96 298.08,41.34 JLED1.10 ; UN3.5 303.44,51.32 302.96,51.81 v1(302.87,51.81) ; UI3.14 307.12,79.92 307.38,80.18 307.62,80.18 v1(307.67,80.23) ; CZ64.2 181.22,79.07 UZ7.5 ; v1(292.58,57.84) 292.7,57.72 UN2.3 ; v1(165.62,97.41) UV8.C14
  TOP w0.279: JXDP1.37 92.56,27.53 v1(92.24,27.84) ; JXDP1.49 94.95,24.53 v1(95.69,23.78) ; JXDP1.50 98.35,24.53 97.94,24.12 v1(97.89,24.12) ; v1(95.4,22.14) 95.29,22.03 JXDP1.59 ; v1(102.29,32.86) 102.29,33.28 101.92,33.64 100.7,33.64 100.58,33.53 JXDP1.14 ; v1(97.56,31.22) 97.59,31.24 97.71,31.24 98.02,31.56 98.02,31.69 98.36,32.03 JXDP1.20 ; JXDP1.25 92.44,30.53 92.11,30.85 v1(92.11,31.31) ; JXDP1.26 100.9,30.53 v1(100.97,30.46) ; JXDP1.38 97.93,27.53 97.78,27.37 v1(97.78,25.95) ; JXDP1.32 v1(97.92,29.03)
  TOP w0.305: JXDP1.13 93.67,33.55 92.39,33.55 92.27,33.43 v1(92.21,33.43) ; v1(97.92,36.57) 97.96,36.53 JXDP1.2 ; UE2.B18 261.85,64.36 262.34,64.85 v1(262.52,64.85) ; v1(92.11,31.31) 92.11,31.69 92.45,32.03 JXDP1.19 ; JXDP1.8 97.79,35.03 96.81,36.01 96.81,36.52 v1(96.75,36.58) ; JUSH1.3 236.33,13.3 236.17,13.13 v1(236.17,12.91) 236.27,12.8 JUSH1.2 ; UE2.B66 v1(260.85,55.57) ; UE2.B54 v1(254.85,55.57) ; JUSH1.20 v1(238.1,21.8) ; v1(238.11,20.87) 238.11,20.44 237.98,20.3 JUSH1.17 ; UN1.15 284.77,56.73 v1(285.05,56.45) 285.27,56.67 UN1.16 ; JXDP1.31 92.31,29.03 92.18,28.9 92.18,28.03 92.24,27.97 v1(92.24,27.84) ; v1(92.11,36.64) 92.23,36.53 JXDP1.1 ; UE2.B60 v1(257.85,55.57) ; UN1.13 282.62,57.74 282.45,57.91 282.45,58.2 v1(282.49,58.24) UN1.12 ; v1(261.15,59.96) 261.15,60.09 261.57,60.5 UE2.B11 ; JKBTP1.2 234.23,36.24 v1(234.54,36.55) 234.35,36.74 JKBTP1.1 ; JKBTP1.15 232.69,29.74 v1(232.66,29.77) 233.13,30.24 JKBTP1.14 ; JXDP1.7 v1(92.14,35.03) ; v1(282.45,59.3) 282.51,59.24 UN1.10
  TOP w0.356: v1(141.85,5.7) 142.46,5.09 142.46,3.92 142.61,3.76 UD1.3 ; 55.71,104.87 56.04,104.55 UI1.1 ; UZ1.18 188.85,65.59 189.19,65.93 190.36,65.93 190.75,66.32 v1(190.75,66.44)
  TOP w0.381: v1(178.4,81.9) 178.28,82.02 QZ10.4 ; DI1.3 74.71,105.58 v1(74.79,105.65) ; v1(191.99,67.38) 191.99,66.54 192.94,65.59 UZ1.11 ; UZ5.2 244.27,53.98 244.77,53.98 245.01,53.74 UZ6.3 ; v1(161.86,57.46) 161.86,57.3 161.38,56.82 CC58.2 ; UC6.3 189.19,49.23 189.36,49.06 v1(189.67,49.06) ; UC4.3 176.2,60.15 176.06,60.29 176.06,61.23 176.1,61.27 ; v1(205.16,4.88) 205.16,4.52 204.46,3.81 CD51.2 ; v1(279.51,61.03) 279.25,60.76 QN1.4 ; RC174.2 184.82,50.28 184.51,50.6 184.51,51.19 184.21,51.49 UC5.3 ; CC59.2 v1(163.08,65.37) ; RC152.2 161.14,52.25 161.14,51.07 161.63,50.57 v1(161.84,50.57) ; UZ11.3 285.05,49.48 v1(284.84,49.7) ; UZ1.4 194.82,61.04 195.16,61.38 v1(195.16,61.67) ; CC44.2 161.53,63.85 161.64,63.74 v1(162,63.74) 162.24,63.74 162.37,63.87 CC43.2 ; UC8.3 168.59,41.86 167.92,42.53 167.27,42.53 v1(167.22,42.59) ; v1(168.85,86.48) 169.24,86.09 QV21.1 ; DE1.2 91.47,57.32 v1(91.8,58.07) ; UZ1.8 194.65,63.64 196.01,62.27 v1(196.23,62.27) ; CC49.2 157.31,56.4 CC48.2
  TOP w0.406: v1(294.91,44.31) 294.91,44.24 295.29,43.85 UZ10.3 ; v1(284.02,83.02) 284.02,83.23 283.87,83.38 UL2.3 ; UZ1.25 188.94,61.04 189.5,60.48 189.5,60.21 v1(189.9,59.81) ; 55.71,104.87 v1(55.71,105.64)
  TOP w0.432: QV21.1 169.85,86.09 170.07,85.87 170.07,85.16 170.44,84.79 QV21.4
  TOP w0.457: QE2.1 261.26,67.96 v1(261.09,68.14) ; v1(176.61,84.67) 176.61,84.25 QZ10.1 ; QE2.4 v1(262.56,70.08) ; QN1.1 v1(281.15,58.52)
  TOP w0.508: v1(196.79,57.57) 196.43,57.93 CC9.1 ; CV126.2 172.3,95.7 172.68,96.08 v1(173.01,96.08) ; CV90.2 v1(152.15,84.36) ; CR3.2 303.15,61.03 v1(303,61.18) ; JSPK1.5 v1(34.57,87.6) ; RE277.1 262.42,70.63 262.56,70.49 v1(262.56,70.08) ; CD28.2 v1(154.03,1.62) ; JTAG1.2 245.21,59.5 v1(244.77,59.06) ; CL19.2 CL18.2 v1(288.82,102.05) ; CR1.2 v1(317.18,62.77) ; CC33.2 145.52,55.39 v1(145.31,55.18) ; v1(264.27,78.67) 263.88,79.06 CE4.2 RE85.2 ; v1(232.26,39.36) 231.74,38.84 JKBTP1.17 ; CZ42.2 CZ43.2 187.17,40.29 v1(186.64,40.82) ; v1(193.13,9.45) 193.08,9.51 CD37.2 ; CZ64.2 181.48,78.68 v1(181.94,78.22) ; v1(126.02,9.45) 126.02,9.46 CD9.2 ; RC181.2 170.98,78.45 v1(170.17,79.26) ; v1(67.21,104.83) 67.58,105.2 CV377.2 ; CE38.2 264.71,68.71 264.97,68.98 265.82,68.98 ; CD10.2 122.72,4.04 v1(122.2,4.56) ; v1(268.44,78.68) 268.44,78.39 267.96,77.9 CZ49.2 CZ23.2 ; RR8.2 308.39,56.78 v1(308.8,56.38) ; v1(259.09,69) 259.12,68.98 CE13.2 CE14.2 ; CZ4.2 184.26,67.66 184.26,68.02 v1(184.25,68.04) ; CR10.1 310.93,70.13 v1(310.38,70.69) 309.92,70.23 CR4.2 ; v1(159.18,79.63) 159.55,79.26 CC47.2 ; v1(206.25,5.23) 206.25,4.99 206.69,4.55 206.69,4.51 207.56,3.65 RD20.2 CD56.2 CD55.2 ; CA53.2 v1(35.45,96.33) ; CV380.2 v1(252.22,112.92) ; RN19.1 291.9,52.69 v1(291.4,53.19) ; CD43.2 193.59,4.43 v1(193.13,4.88) ; v1(188.25,52.17) 187.87,51.79 RC304.2 ; CC78.2 CC70.2 ; CC70.2 v1(158.62,62.84) ; CC70.2 159.65,63.48 CC60.2 ; JLED1.11 292.4,38.58 v1(292.57,38.41) ; RE65.2 245.24,56.96 v1(244.72,56.44) 245.21,55.95 CE30.2 ; PQ816.3 v1(131.47,96.34) ; v1(120.47,9.45) 120.69,9.68 CD16.2 ; CD27.2 153.2,11.92 v1(152.67,12.45) 152.18,11.97 CD26.2 ; CD31.2 150.66,14.54 v1(150.2,15) 149.64,14.44 CD32.2 ; v1(191.96,89.8) 191.91,89.75 191.88,89.75 191.4,89.27 CI414.2 ; 265.82,68.98 v1(265.85,69) ; 265.82,68.98 265.72,68.87 RE77.2 ; v1(239.9,100.28) 240.23,99.95 CL27.2 ; C316.2 178.97,119.95 v1(178.99,119.94) ; RC183.2 v1(115.99,58.49) ; CL16.2 307.57,89.25 307.44,89.12 v1(307.44,88.52) ; v1(197.22,65.8) 197.25,65.8 197.35,65.71 CZ5.2 ; v1(301.73,79.63) 302.16,79.63 CI19.2 ; RC80.2 176.1,61.27 176.07,61.29 175.79,61.29 175.54,61.04 v1(175.22,61.04) 175.22,61.18 174.88,61.52 174.27,61.52 174.03,61.28 RC303.2 ; v1(119,62.37) 119.18,62.55 RC123.2 ; RD21.2 210.6,1.75 v1(210.56,1.71) ; D20.1 178.75,109.01 v1(178.98,108.78) ; CE32.2 91.54,58.33 v1(91.8,58.07) ; v1(174.29,1.67) 174.49,1.87 174.49,2.38 CD35.2 ; RV1.2 89.59,99.38 v1(89.75,99.55) ; CV66.2 135.08,96.84 v1(134.52,96.28) ; CD38.2 191.3,9.78 v1(190.85,9.33) ; RE88.2 244.36,70.73 245.21,69.88 v1(245.21,69.71) ; CD15.2 117.13,9.75 v1(116.84,9.45) ; RE24.2 CE5.2 v1(243.57,84.01) ; PC514.1 106.29,64.23 v3(106.64,63.87) ; v1(248.26,59.71) 248.31,59.76 CE18.2 ; YV2.4 v1(150.81,89.3) ; CZ30.2 235.39,34.91 v1(235.37,34.94) ; CE23.2 248.96,65.5 249.56,66.09 250.06,66.09 250.18,65.98 v1(250.18,65.9) 249.97,65.7 CE19.2 ; v1(161.82,58.16) 161.37,58.16 161.14,57.93 CC63.2 ; RE86.1 248.72,60.77 248.29,61.2 v1(248.29,61.74) 248.34,61.79 RE56.1 ; RC185.2 v1(115.99,59.5) ; PC710.2 84.86,75.95 v3(85.51,75.3) ; RV76.2 160.82,86.32 v1(161.34,85.8) 161.84,86.3 RV77.2 ; RR5.2 316.26,60.77 316.75,60.28 316.75,59.83 v1(316.67,59.76) CR15.1 ; v1(197.14,61.67) 197.35,61.47 CZ7.2 ; C311.2 155.49,117.06 155.33,116.91 v1(155.37,116.91) ; CE7.2 v1(256.71,69.34) 257.09,68.96 RE78.2 ; CC37.2 156.02,58.46 155.62,58.46 v1(155.5,58.34) ; v1(199.99,9.45) 200.44,9.91 CD40.2 ; PC741.1 76.9,74.56 v1(76.71,74.75) ; CV124.2 176.31,88.76 v1(176.92,88.15) 177.33,88.56 CV125.2 ; v1(257.42,103.77) 257.42,103.85 257.14,104.13 RV33.2 ; v1(155.58,98.64) 155.58,98.88 154.29,100.17 RV79.2 ; CC24.2 165.57,45.48 v1(166.28,46.19) ; CZ10.2 RZ10.1 v1(241.03,12.47) ; CD30.2 138.77,1.92 138.98,1.72 139.66,1.72 v1(139.69,1.74) ; MIC1.2 v1(246.23,114.33) ; CC80.2 177.84,39.73 v1(177.41,39.3) 176.82,39.88 RC175.2 ; CD6.2 97.83,1.97 98.03,1.77 v1(98.06,1.77) ; v1(268.17,56.37) 268.08,56.45 CE16.2 CE12.2 ; CV10.2 v1(82.08,94.77) ; CD59.2 CD58.2 228.38,2.47 228.82,2.03 v1(228.82,1.74) ; CV374.2 163.31,88.65 v1(162.88,89.08) ; v1(254.22,66.58) 254.22,66.64 255,67.43 CE34.2 254.83,67.66 254.38,67.66 253.7,68.34 CE36.2 ; v1(170.47,59.66) 170.47,59.41 170.84,59.04 171.28,59.04 CC100.1 ; v1(255.77,105.36) 255.77,105.02 255.21,104.46 RV32.2 ; v1(302.56,56.45) 302.93,56.09 RN7.2 ; RC128.1 v1(116,60.52) ; MIC1.3 v1(244.58,114.35) ; CE3.2 255.44,70.12 v1(255.6,69.95) ; CD49.2 189.52,9.51 v1(189.47,9.45) ; v1(190.59,53.99) 190.79,53.79 CC10.1 ; CZ66.2 283.5,90.74 283.65,90.59 284.31,90.59 284.98,89.93 CZ67.2 285.53,89.6 286.55,88.59 286.55,87.15 v1(286.54,87.14) 286.54,86.38 286.19,86.03 285.17,86.03 284.98,85.84 RL12.2 ; v1(261.02,49.92) 261.02,50.54 CE28.2 ; CV51.2 255.13,105.88 255.31,106.06 CV54.2 255.35,106.58 v1(256.29,106.58) ; v1(154.19,79.12) 154.7,79.63 CC77.2 ; v1(120.46,4.88) 121.2,4.15 CD12.2 ; CA41.2 v1(35,100.62) ; v1(170.89,94.45) 170.89,94.24 RV75.2 ; CD2.2 115.61,4.32 v1(115.05,4.88) ; CC12.1 164.62,43.09 163.74,43.97 163.74,45.11 v1(163.9,45.27) ; CV69.2 143.87,93.3 v1(142.42,93.3) 142.15,93.03 RV61.2 ; CD44.2 191.55,4.05 v1(190.85,4.76) ; RE58.2 259.12,50.49 v1(258.61,49.98) 258.1,50.49 CE15.2 ; v1(90.51,14.66) 90.3,14.44 90.3,14.43 89.95,14.09 RD7.2 ; v1(248.25,55.02) 248.25,54.96 248.53,54.68 CE25.2 ; CN4.2 302.91,48.88 v1(302.87,48.85) CN3.1 ; CC50.2 158.55,54.3 v1(158.64,54.21) 159.04,54.61 CC72.2 ; RV3.1 v1(79.57,98.82) ; v1(104.46,26.36) 104.33,26.23 CC18.2 ; v1(180.84,81.49) CZ39.1 ; v1(255.52,50.05) 255.56,50.09 CE17.2 CE20.2 ; PR104.2 PR106.1 v3(223.43,61.79) ; UV24.2 84.37,95.07 v1(83.96,94.67) ; CZ28.2 v1(237.69,30.04) ; CR23.2 307.99,71.55 PC1.2 309.91,71.91 v1(310.06,72.06) ; v1(172.47,111.75) 173.41,110.81 C33.2 ; CV50.2 v1(270.29,109.68) ; CL25.2 245.49,108.79 v1(245.67,108.97) ; v1(51.57,94.99) 52.05,95.46 PQ832.3 ; CC26.2 151.63,55.37 v1(151.81,55.18) ; RE55.1 v1(258.1,68.99) ; CC62.2 159.64,59.27 v1(159.63,59.29) ; RV72.1 136.79,94.83 137.62,94.01 v1(138.61,94.01) ; RR2.1 v1(302.7,66.36) ; CZ24.2 266.48,73.54 266.45,73.5 v1(266.45,73.03) ; CV59.2 v1(264.91,113.02) ; CE8.2 v1(263.88,75) ; v1(87.58,101.98) 87.58,101.96 86.42,100.8 CV9.2 ; RV20.2 v1(99.91,102.24) ; CD7.2 119.16,4.41 v1(118.69,4.88) ; v1(155.5,63.21) 155.99,63.71 RC142.1 ; v1(95.36,95.42) 95.69,95.75 CZ1.2 ; CD1.2 88.94,10.3 88.67,10.04 88.01,10.04 v1(87.92,10.12) CD5.2 ; CE11.2 260.13,47.73 259.56,47.16 v1(259.56,47.14) ; RD14.1 v1(133.9,1.72) ; v1(163.26,77.79) 163.26,78.39 CC55.2 ; v1(95.28,102.86) 95.28,102.99 95.86,103.57 CV23.2 ; RI14.1 v1(306.11,83.72) ; v1(143.48,54.38) 143.1,54.76 CC32.2 ; CD17.2 128.05,1.92 128.33,1.64 v1(128.33,1.53) ; v1(266.03,48.19) 266.22,48.38 CE44.2 266.22,49.93 265.72,50.42 CE45.2 ; RN16.1 v1(295.29,63.26) ; DI2.1 v1(57.42,101.03) ; CC61.2 161.18,55.9 CC57.2 ; CC61.2 CC73.2 ; CC61.2 CC58.2 ; CR35.2 305,56.06 v1(305.5,56.56) 304.98,57.08 RR11.2 ; CZ38.2 169.47,82.54 170.08,82.54 v1(170.29,82.32) ; CC51.2 158.28,79.02 v1(158.03,79.28) ; v1(185.66,88.04) v4(186.36,88.74) 186.89,89.27 CI417.2 ; CZ63.2 273.09,56.03 273.38,55.74 273.98,55.74 v1(274.1,55.87) CZ62.2 ; CV57.2 v1(268.26,109.72) ; RC140.2 180.85,65.86 181.7,65.86 v1(181.7,65.85) ; v1(269.93,81.9) CL13.1 270.9,81.9 271.55,82.55 CL14.1 ; v1(167.21,85.66) 167.53,85.98 CV101.2 ; v1(70.35,76.29) 70.35,75.89 70.56,75.67 72.26,75.67 72.8,75.14 PC737.2 ; CC52.2 172.58,55.39 172.09,54.89 v1(171.75,54.89) ; v1(175.79,107.22) 175.79,107.85 175.56,108.08 C317.2 ; UV4.2 v1(272.71,111.25) ; CE9.2 v1(245.99,79.33) ; CZ40.2 CZ41.2 185.14,40.66 v1(184.91,40.88) ; RC174.2 184.82,50.12 v1(185.37,49.57) ; v1(274.09,64.25) 273.76,64.25 RZ38.1 ; v1(182.33,61.2) 182.41,61.28 CZ6.2 ; RC191.2 v1(119.09,56.45) 118.96,56.33 118.96,55.7 119.23,55.44 RC188.2 ; CZ46.2 v1(217.4,93.91) 217.44,93.94 218.12,93.94 218.41,93.65 CZ47.2 ; v1(113.69,65.22) 113.63,65.15 CC20.2 ; v1(194.96,9.45) 194.86,9.56 CD42.2 ; CR2.2 v1(316.62,61.69) ; RC91.1 184.57,43.16 v1(184.24,42.83) ; CR19.1 v1(316.6,63.85) ; v1(31.95,103.42) 32.56,102.81 QA1.3 32.28,102.3 v1(32.28,100.59) ; CR31.2 310.68,56.63 311.09,56.23 v1(311.39,56.23) 311.7,56.53 CR6.2 ; CD48.2 189.78,4.63 v1(189.47,4.94) ; v1(37.6,94.05) CA30.2 36.8,94.06 CA33.2 ; CD4.2 115.35,9.76 v1(115.05,9.45) ; RD24.2 v1(160.82,10.14) ; v1(30.58,87.07) 29.16,87.07 28.74,87.49 CA19.2 CA24.2 CA23.2 CA22.2 ; CV83.2 149.2,98.36 v1(148.78,98.78) ; RL9.2 266.99,90.76 265.79,89.55 v1(265.79,89.41) ; v3(216.19,42.87) 216.83,43.5 PR310.2 ; v1(124.25,4.88) 124.5,4.63 CD18.2 ; CV8.2 84.62,101.42 84.84,101.64 v1(84.84,101.88) ; v1(194.96,4.88) 195.11,4.74 CD47.2 ; JKBTP1.18 v1(230.53,25.99) ; v1(271.34,69.46) 271.34,69.71 271.01,70.04 270.59,70.04 270.56,70.07 RZ40.1 ; CC49.2 155.8,56.4 155.33,55.93 v1(155.33,55.45) ; v1(165.01,4.65) 165.65,4.02 RD25.2 ; CV62.2 CV61.2 143.19,94.43 142.84,94.07 v1(142.39,94.07) ; RL13.2 272.38,80.85 v1(272.28,80.75) ; RA2.2 13.06,96.88 12.48,96.31 11.9,96.31 v1(11.47,95.87) 11.47,95.8 v1(11.02,95.35) 10.43,94.76 CA31.2 ; v1(88.18,15.97) 86.91,14.7 RD6.2 ; v1(297.03,88.39) 296.01,89.41 CL21.2 ; CC83.2 122.42,62.23 122.73,61.92 v1(122.73,61.89) ; CC64.2 161.14,59.16 161.47,59.49 v1(161.81,59.49) ; v3(223.81,67.78) 223.81,67.44 PC119.2 ; CC21.2 103.87,24.2 105.63,25.95 v1(107.19,25.95) ; CC19.2 89.23,26.23 v1(88.81,25.81) 89.41,25.21 CC22.2 ; v1(86.96,1.86) 87.88,2.78 PC4.2 ; CZ25.2 173.47,81.6 v1(173.13,81.94) ; CD52.2 200.7,4.18 v1(199.99,4.88) ; CC15.1 159.32,39.3 v1(159.54,39.51) ; v1(82.99,102.45) 83.54,103 QV4.3 ; YL1.4 267.06,80.38 v1(267.77,79.67) ; CD45.2 198.67,4.34 v1(198.51,4.5) ; CE10.2 v1(270.24,55.06) ; v1(267.7,84.5) 267.77,84.5 268.86,83.41 YL1.2 ; RD15.1 RD16.1 151.17,12.5 v1(151.37,12.7) ; v1(195.82,96.65) CI419.2 CI416.2 ; PD1.1 v1(75.04,7.9) ; v1(300.57,54.3) 300.77,54.5 RN23.2 ; RN25.2 292.95,59.68 v1(293.28,59.35) ; v1(203.55,9.45) 204,9.91 CD50.2 ; CI415.2 195.82,93.54 196.22,93.93 v1(196.42,93.93) ; v1(86.94,92.78) 86.94,94.19 87.27,94.52 QV2.3 ; CC40.2 160.46,60.98 160.92,60.98 v1(160.96,60.94) 161.18,61.15 CC69.2 CC53.2 ; CR14.1 v1(317.25,58.49) ; v1(285.39,78.23) 285.39,78.58 285.28,78.69 CL15.2 ; CZ36.2 276.14,56 275.91,55.77 v1(275.07,55.77) 275.12,55.82 CZ37.2 ; CR34.2 v1(314.05,57.28) ; RV73.2 158.12,86.13 v1(158.12,85.75) ; v1(27.56,80.58) DA6.1 ; CC71.2 156.97,60.82 v1(156.92,60.77) ; CI418.2 v1(183.22,92.97) ; v1(314.76,68.1) 314.76,68.09 CR22.1 ; RE20.1 v1(250.99,69.81) ; CV379.2 v1(253.58,112.97) ; CZ12.2 v1(241.66,18.86) ; CC56.2 164.45,78.71 v1(163.85,79.32) ; CZ44.2 v1(215.37,93.98) 216.1,93.98 216.38,93.7 CZ45.2 ; CE31.2 270.74,62.35 v1(270.84,62.45) ; v1(155.45,60.7) 155.66,60.48 CC68.2 ; CV113.2 v1(154.1,87.24) ; v1(186.31,66.41) 186.26,66.36 CZ9.2 ; v1(160.74,48.57) 161.3,48 161.3,45.02 162.88,43.45 CC13.1 CC14.1 ; RV89.2 v1(159.8,85.8) ; v1(147.36,108.87) 147.36,109.24 147.1,109.49 C318.2 ; CI422.2 v1(311.14,87.09) ; DV5.1 v1(256.32,112.94) ; CE40.2 270.54,59.97 v1(270.93,59.97) ; DV6.1 v1(260.39,113.41) ; PR102.1 PR105.1 v3(223.43,65.85) ; v1(302.25,58.26) 302.48,58.49 CR17.1 ; CI17.2 310.43,76.94 v1(310.5,76.86) ; CL17.2 303.63,89.23 v1(304.51,88.36) ; CV55.2 257.09,106.28 257.14,106.23 CV52.2 257.07,105.48 256.36,104.76 v1(256.36,104.45) ; JRTC1.4 v1(323.4,64.77) ; v1(299.94,52.44) 299.85,52.53 CN29.2 ; PR114.2 220.16,58.45 v3(220.07,58.36) ; v1(219.94,15.6) 220.56,14.98 RD28.2 ; v3(58.65,85.6) 58.65,86.17 58.34,86.48 PR18.2 ; RV34.2 v1(259.02,104.46) ; v1(152.95,1.96) CD24.2 CD25.2 ; CN1.2 v1(285.34,54.23) ; RV78.2 v1(162.85,85.8) ; CD33.2 163.87,10.06 v1(164.41,9.51) 164.88,9.98 CD34.2 ; CL26.2 247.22,98.3 v1(247.22,97.94) ; CD11.2 117.39,4.34 v1(116.84,4.88) ; v1(258.9,105.48) CV53.2 259.68,106.15 259.37,106.45 CV56.2 ; v1(252.41,89.27) 251.59,90.1 251.05,90.1 RZ27.2 ; CV144.2 184.14,94.88 184.45,95.2 v1(184.45,95.56) ; v3(122.5,100.31) 123.13,99.68 PR814.1 ; CD46.2 196.63,9.61 v1(196.79,9.45) ; CD14.2 113.83,4.69 v1(113.64,4.88) ; CV127.2 172.3,92.53 173.13,91.71 v1(173.13,91.65) ; CD22.2 CD23.2 131.1,2.31 v1(130.49,1.7) ; v1(303,61.81) 303.23,62.04 CR13.1 ; CI421.2 v1(53.53,105.78) ; CZ29.2 v1(236.97,28.34) ; RN21.1 v1(299.25,63.95) ; RC171.2 185.5,59.25 v1(185.62,59.12) ; CI7.2 v1(55.4,101.65) ; CD39.2 198.41,9.93 v1(198.51,9.84) ; CC30.2 131.17,37.79 CC31.2 131.17,38.95 131.66,39.45 CC28.2 131.66,40.39 132.19,40.92 132.7,40.92 133.45,41.67 133.45,42.28 133.29,42.44 v1(133.29,42.47) ; v1(27.72,84.65) DA7.1 ; v1(153.85,90.29) 153.75,90.19 CV115.2 ; v1(172.02,101.23) 171.95,101.16 RV74.2 CV96.2 ; v1(177.56,102.02) 177.58,102 v4(177.58,100.14) CV128.2 ; CZ51.2 CZ53.2 v1(284.98,102.48) ; v1(112.21,9.39) 112.55,9.39 113.32,10.16 CD13.2 ; v1(118.69,9.45) 118.91,9.68 CD8.2 ; v1(146.19,87.95) 147.04,87.1 YV2.2 ; R271.2 v1(156.5,116.91) ; CC65.2 158.74,59.76 v1(158.31,60.19) ; RN9.1 v1(296.2,52.03) 296.09,51.92 295.43,51.92 295.19,52.16 RN11.1 ; v1(160.99,60.26) 161.01,60.24 CC54.2 ; RC129.1 v1(116,61.53) ; CV94.2 v1(148.7,99.63) ; CC17.2 v1(105.5,32.37) ; JRTC1.3 v1(325.54,72.75) ; v1(323.2,99.28) SW3.3 ; CR8.1 v1(303.01,63.06) ; CZ35.2 v1(242.05,55.29) ; v1(138.61,93.25) 137.63,92.27 CV70.2 ; v1(19.62,89.88) 20.32,90.58 CA49.1 ; CZ48.2 v1(299.76,46.19) ; PC3.2 71.62,9.38 v1(71.84,9.16) ; CZ31.2 v1(235.29,37.86) ; CV87.2 v1(154.2,87.89) ; v1(241.03,15.94) CZ11.2 ; PC810.1 v3(94.11,71.62) ; JRTC1.2 v1(325.13,68.95) ; JUSH1.22 v1(234.01,22.84) ; RE21.1 v1(257.98,69.98) ; v1(315.96,65.5) CR21.1 ; CC66.2 v1(159.3,60.18) ; CD3.2 124.24,9.46 v1(124.25,9.45) ; v1(246.93,52.8) 247.13,52.59 CZ34.2 ; CZ27.2 v1(237.71,33.59) ; v1(127.36,9.45) 127.8,9.9 CD19.2 ; v1(300.81,60.85) 300.38,61.28 RN13.1 ; PD2.1 v1(72.72,5.59) ; CC35.2 v1(168.44,36.31) ; v1(266.09,85.24) 266.42,85.58 CL3.2 ; MIC1.1 v1(247.88,114.28) ; CN2.2 v1(288.79,56.54) ; CD41.2 197.14,4.53 v1(196.79,4.88) ; RC243.2 v1(170.47,36.16) 170.51,36.2 171.18,36.2 171.49,36.5 RC242.2 ; PR525.2 107.77,76.1 v3(107.23,76.65) ; SW3.1 v1(324.5,94.06) ; v1(53.56,96.21) 53.66,96.1 PR844.2 ; CE6.2 244.83,76.41 244.6,76.41 244.21,76.01 v1(244.21,75.77) 244.35,75.63 RE17.1 ; CA54.2 v1(37.58,93.03) ; CV58.2 v1(267.2,113.13) ; v1(219.11,12.92) 220.03,12 CD64.2 CD63.2 ; CL20.2 v1(300.2,88.45) ; CE2.2 v1(257.14,88.03) ; CD29.2 154.42,12.59 v1(154.47,12.64) ; v1(70.27,104.83) 69.9,105.2 CV378.2 ; JLED1.12 v1(300.18,36.82) ; RC305.2 101.28,20.63 v1(100.2,19.55) ; CZ50.2 v1(270.41,76.22) ; RE82.1 263.69,49.65 CE29.2 v1(264.31,49.6) ; CD61.2 v1(229.65,1.81) ; UZ5.2 v1(243.18,52.89) ; CC25.2 147.92,55.18 v1(147.91,55.18)
  GND1 w0.203: 92.73,112.76 JHDMI1.17 ; JHDMI1.17 93.2,112.64 ; JHDMI1.17 92.73,113.68 ; JHDMI1.17 93.66,112.76 ; JHDMI1.17 93.66,113.68 ; JHDMI1.17 93.2,113.8 ; JHDMI1.8 89.16,112.18 ; JHDMI1.8 88.23,112.18 ; JHDMI1.8 88.7,112.3 ; JHDMI1.8 88.23,111.26 ; JHDMI1.8 88.7,111.14 ; JHDMI1.8 89.16,111.26 ; 53.22,115.3 H1.1 ; H1.1 55.05,113.47 ; H1.1 53.71,116.64 ; H1.1 56.39,113.96 ; H1.1 53.71,113.96 ; H1.1 56.39,116.64 ; H1.1 56.88,115.3 ; H1.1 55.05,117.13 ; JDOCK1.155 171.7,118.12 ; JDOCK1.155 169.6,117.15 ; JDOCK1.155 170.65,117.15 ; JDOCK1.155 171.7,119.1 ; JDOCK1.155 169.6,119.1 ; JDOCK1.155 171.7,117.15 ; JDOCK1.155 170.65,119.1 ; JDOCK1.155 169.6,118.12 ; 73.1,109.59 JUSB1.10 ; JUSB1.10 74.05,109.59 ; JUSB1.10 75,109.59 ; JUSB1.10 75,111.45 ; JUSB1.10 75,113.3 ; JUSB1.10 74.05,113.3 ; 319.3,25.17 H3.1 ; H3.1 320.64,25.66 ; H3.1 320.64,28.34 ; H3.1 317.96,25.66 ; H3.1 317.47,27 ; H3.1 321.13,27 ; H3.1 319.3,28.83 ; H3.1 317.96,28.34 ; JDOCK1.154 159.7,119.1 ; JDOCK1.154 158.65,117.15 ; JDOCK1.154 158.65,119.1 ; JDOCK1.154 157.6,118.12 ; JDOCK1.154 159.7,117.15 ; JDOCK1.154 157.6,117.15 ; JDOCK1.154 159.7,118.12 ; JDOCK1.154 157.6,119.1 ; H17.1 280.59,72.92 ; H17.1 277.61,72.92 ; H17.1 281.13,74.41 ; H17.1 277.61,75.9 ; H17.1 277.07,74.41 ; H17.1 280.59,75.9 ; H17.1 279.1,76.44 ; H17.1 279.1,72.38 ; 98.95,117.72 JHDMI1.23 ; JHDMI1.23 98.95,120.88 ; JHDMI1.23 100.03,117.72 ; JHDMI1.23 100.03,119.3 ; JHDMI1.23 97.87,117.72 ; JHDMI1.23 97.87,120.88 ; JHDMI1.23 97.87,119.3 ; JHDMI1.23 100.03,120.88 ; 66.2,109.78 JUSB1.7 ; JUSB1.7 66.77,111.09 ; JUSB1.7 65.63,109.95 ; JUSB1.7 65.46,110.52 ; JUSB1.7 66.94,110.52 ; JUSB1.7 66.77,109.95 ; JUSB1.7 65.63,111.09 ; 224.8,116.84 JUSB2.12 ; JUSB2.12 224.8,119.66 ; JUSB2.12 225.75,116.84 ; JUSB2.12 225.75,119.66 ; JUSB2.12 224.8,118.25 ; H11.1 119.4,49.22 ; H11.1 120.04,47.52 ; H11.1 117.7,45.18 ; H11.1 117.7,49.86 ; H11.1 116,45.82 ; H11.1 115.36,47.52 ; H11.1 116,49.22 ; H11.1 119.4,45.82 ; JUSB3.13 324.08,76.4 ; JUSB3.13 321.72,75.62 ; JUSB3.13 321.72,76.4 ; JUSB3.13 322.9,75.62 ; JUSB3.13 324.08,75.62 ; SW1.4 229.45,72.64 ; SW1.4 229.21,73.4 ; SW1.4 228.45,71.64 ; SW1.4 227.69,73.4 ; SW1.4 227.69,71.88 ; SW1.4 228.45,73.65 ; SW1.4 227.44,72.64 ; SW1.4 229.21,71.88 ; 220.31,114.46 H6.1 ; H6.1 222.99,117.14 ; H6.1 223.48,115.8 ; H6.1 221.65,117.63 ; H6.1 220.31,117.14 ; H6.1 221.65,113.97 ; H6.1 222.99,114.46 ; H6.1 219.82,115.8 ; 158.65,112.94 JDOCK1.158 ; JDOCK1.158 157.39,114.2 ; JDOCK1.158 159.91,114.2 ; JDOCK1.158 159.59,115.14 ; JDOCK1.158 158.65,115.46 ; JDOCK1.158 159.59,113.26 ; JDOCK1.158 157.71,115.14 ; JDOCK1.158 157.71,113.26 ; JUSB1.4 63.44,109.02 ; JUSB1.4 62.7,108.28 ; JUSB1.4 62.13,108.45 ; JUSB1.4 61.96,109.02 ; JUSB1.4 63.27,109.59 ; JUSB1.4 63.27,108.45 ; H13.1 180.7,45.82 ; H13.1 179,45.18 ; H13.1 177.3,45.82 ; H13.1 177.3,49.22 ; H13.1 179,49.86 ; H13.1 176.66,47.52 ; H13.1 181.34,47.52 ; H13.1 180.7,49.22 ; JUSB3.4 314.58,86.97 ; JUSB3.4 313.31,88.24 ; JUSB3.4 313.95,88.43 ; JUSB3.4 313.95,86.77 ; JUSB3.4 313.31,86.97 ; JUSB3.4 313.12,87.6 ; 229.36,109.02 JUSB2.4 ; JUSB2.4 230.67,108.45 ; JUSB2.4 230.84,109.02 ; JUSB2.4 229.53,108.45 ; JUSB2.4 230.1,108.28 ; JUSB2.4 230.67,109.59 ; JUSB3.10 314.98,89.67 ; JUSB3.10 314.98,90.5 ; JUSB3.10 313.65,91.33 ; JUSB3.10 312.32,89.67 ; JUSB3.10 312.32,90.5 ; JUSB3.10 314.98,91.33 ; JUSB3.10 312.32,91.33 ; JUSB3.10 313.65,89.67 ; H15.1 247.97,94.34 ; H15.1 246.48,94.88 ; H15.1 244.99,91.36 ; H15.1 246.48,90.82 ; H15.1 244.45,92.85 ; H15.1 247.97,91.36 ; H15.1 248.51,92.85 ; H15.1 244.99,94.34 ; JCRT1.16 252.25,117.34 ; JCRT1.16 253.3,117.34 ; JCRT1.16 253.3,115.9 ; JCRT1.16 251.2,115.9 ; JCRT1.16 251.2,114.46 ; JCRT1.16 252.25,114.46 ; JCRT1.16 253.3,114.46 ; JCRT1.16 251.2,117.34 ; 266.36,116.28 JCRT1.5 ; JCRT1.5 266.36,117.32 ; JCRT1.5 267.54,116.8 ; JCRT1.5 267.4,116.28 ; JCRT1.5 267.4,117.32 ; 145.85,113.4 JDOCK1.157 ; JDOCK1.157 145.6,114.2 ; JDOCK1.157 146.65,115.25 ; JDOCK1.157 147.45,113.4 ; JDOCK1.157 146.65,113.15 ; JDOCK1.157 145.85,115 ; JDOCK1.157 147.45,115 ; JUSB3.12 324.08,91.8 ; JUSB3.12 322.9,92.58 ; JUSB3.12 324.08,92.58 ; JUSB3.12 321.72,92.58 ; JUSB3.12 321.72,91.8 ; JDOCK1.156 189.21,117.15 ; JDOCK1.156 189.21,118.12 ; JDOCK1.156 189.21,119.1 ; JDOCK1.156 185.09,117.15 ; JDOCK1.156 185.09,118.12 ; JDOCK1.156 187.15,119.1 ; JDOCK1.156 185.09,119.1 ; JDOCK1.156 187.15,117.15 ; JDOCK1.153 144.21,118.12 ; JDOCK1.153 142.15,119.1 ; JDOCK1.153 144.21,119.1 ; JDOCK1.153 140.09,118.12 ; JDOCK1.153 142.15,117.15 ; JDOCK1.153 144.21,117.15 ; JDOCK1.153 140.09,119.1 ; 258.35,116.28 JCRT1.7 ; JCRT1.7 259.38,117.32 ; JCRT1.7 258.87,116.14 ; JCRT1.7 258.35,117.32 ; JCRT1.7 259.38,116.28 ; 196.39,119.33 H8.1 ; H8.1 199.56,117.99 ; H8.1 198.22,117.5 ; H8.1 198.22,121.16 ; H8.1 196.88,120.67 ; H8.1 199.56,120.67 ; H8.1 200.05,119.33 ; H8.1 196.88,117.99 ; JCRT1.17 273.4,115.9 ; JCRT1.17 273.4,117.34 ; JCRT1.17 273.4,114.46 ; JCRT1.17 271.3,117.34 ; JCRT1.17 271.3,114.46 ; JCRT1.17 272.35,117.34 ; JCRT1.17 271.3,115.9 ; JCRT1.17 272.35,114.46 ; 188.82,112.22 JDOCK1.152 ; JDOCK1.152 187.77,116.18 ; JDOCK1.152 188.82,116.18 ; JDOCK1.152 189.88,114.2 ; JDOCK1.152 189.88,112.22 ; JDOCK1.152 187.77,112.22 ; JDOCK1.152 187.77,114.2 ; JDOCK1.152 189.88,116.18 ; 140.09,110.27 JDOCK1.161 ; JDOCK1.161 144.21,109.3 ; JDOCK1.161 144.21,110.27 ; JDOCK1.161 142.15,111.25 ; JDOCK1.161 142.15,109.3 ; JDOCK1.161 140.09,111.25 ; JDOCK1.161 144.21,111.25 ; JDOCK1.161 140.09,109.3 ; 182.65,113.15 JDOCK1.160 ; JDOCK1.160 183.7,114.2 ; JDOCK1.160 181.85,113.4 ; JDOCK1.160 181.85,115 ; JDOCK1.160 182.65,115.25 ; JDOCK1.160 183.45,113.4 ; JDOCK1.160 183.45,115 ; JUSB2.11 225.75,113.3 ; JUSB2.11 224.8,109.59 ; JUSB2.11 224.8,111.45 ; JUSB2.11 224.8,113.3 ; JUSB2.11 225.75,109.59 ; JUSB2.11 226.7,109.59 ; 241.45,116.84 JUSB2.13 ; JUSB2.13 242.4,118.25 ; JUSB2.13 241.45,119.66 ; JUSB2.13 242.4,116.84 ; JUSB2.13 242.4,119.66 ; JUSB1.13 75,116.84 ; JUSB1.13 74.05,119.66 ; JUSB1.13 74.05,116.84 ; JUSB1.13 75,118.25 ; JUSB1.13 75,119.66 ; 177.3,73.02 H10.1 ; H10.1 179,73.66 ; H10.1 177.3,69.62 ; H10.1 180.7,69.62 ; H10.1 179,68.98 ; H10.1 176.66,71.32 ; H10.1 180.7,73.02 ; H10.1 181.34,71.32 ; JDOCK1.162 159.7,111.25 ; JDOCK1.162 159.7,110.27 ; JDOCK1.162 158.65,109.3 ; JDOCK1.162 157.6,110.27 ; JDOCK1.162 157.6,109.3 ; JDOCK1.162 159.7,109.3 ; JDOCK1.162 158.65,111.25 ; JDOCK1.162 157.6,111.25 ; H24.1 20.02,79.28 ; H24.1 20.02,82.32 ; H24.1 18.5,78.72 ; H24.1 20.58,80.8 ; H24.1 16.98,79.28 ; 57.4,109.59 JUSB1.11 ; JUSB1.11 58.35,109.59 ; JUSB1.11 57.4,111.45 ; JUSB1.11 58.35,113.3 ; JUSB1.11 57.4,113.3 ; JUSB1.11 59.3,109.59 ; JLOM1.14 306.49,117.25 ; JLOM1.14 305.58,113.75 ; JLOM1.14 306.49,115.5 ; JLOM1.14 306.49,113.75 ; JLOM1.14 305.58,117.25 ; H18.1 85.15,62.03 ; H18.1 83.52,60.4 ; H18.1 83.95,59.2 ; H18.1 86.78,60.4 ; H18.1 83.95,61.6 ; H18.1 86.35,59.2 ; H18.1 86.35,61.6 ; H18.1 85.15,58.77 ; JDOCK1.164 187.15,111.25 ; JDOCK1.164 187.15,109.3 ; JDOCK1.164 185.09,110.27 ; JDOCK1.164 189.21,110.27 ; JDOCK1.164 185.09,109.3 ; JDOCK1.164 185.09,111.25 ; JDOCK1.164 189.21,111.25 ; JDOCK1.164 189.21,109.3 ; 240.5,109.59 JUSB2.10 ; JUSB2.10 241.45,109.59 ; JUSB2.10 242.4,113.3 ; JUSB2.10 242.4,109.59 ; JUSB2.10 241.45,113.3 ; JUSB2.10 242.4,111.45 ; 58.31,4.49 H22.1 ; H22.1 60.99,1.81 ; H22.1 59.65,4.98 ; H22.1 61.48,3.15 ; H22.1 57.82,3.15 ; H22.1 58.31,1.81 ; H22.1 59.65,1.32 ; H22.1 60.99,4.49 ; JHDMI1.11 90.66,112.76 ; JHDMI1.11 90.2,113.8 ; JHDMI1.11 90.66,113.68 ; JHDMI1.11 90.2,112.64 ; JHDMI1.11 89.73,112.76 ; JHDMI1.11 89.73,113.68 ; 233.99,71.88 SW1.5 ; SW1.5 233.99,73.4 ; SW1.5 235.75,72.64 ; SW1.5 234.75,71.64 ; SW1.5 235.51,71.88 ; SW1.5 233.74,72.64 ; SW1.5 234.75,73.65 ; SW1.5 235.51,73.4 ; 261.16,116.14 JCRT1.8 ; JCRT1.8 260.64,117.32 ; JCRT1.8 260.64,116.28 ; JCRT1.8 261.67,117.32 ; JCRT1.8 261.67,116.28 ; H7.1 132.69,120.76 ; H7.1 131.35,121.25 ; H7.1 131.35,117.59 ; H7.1 132.69,118.08 ; H7.1 129.52,119.42 ; H7.1 130.01,120.76 ; H7.1 133.18,119.42 ; H7.1 130.01,118.08 ; 85.23,111.26 JHDMI1.2 ; JHDMI1.2 85.23,112.18 ; JHDMI1.2 85.11,111.72 ; JHDMI1.2 86.16,111.26 ; JHDMI1.2 86.16,112.18 ; JHDMI1.2 85.7,111.14 ; JHDMI1.2 85.7,112.3 ; 169.39,114.2 JDOCK1.159 ; JDOCK1.159 169.71,113.26 ; JDOCK1.159 171.59,113.26 ; JDOCK1.159 170.65,112.94 ; JDOCK1.159 170.65,115.46 ; JDOCK1.159 169.71,115.14 ; JDOCK1.159 171.59,115.14 ; JDOCK1.159 171.91,114.2 ; JHDMI1.20 83.32,112.32 ; JHDMI1.20 81.57,112.32 ; JHDMI1.20 83.32,110.57 ; JHDMI1.20 83.32,114.07 ; JHDMI1.20 82.45,110.57 ; JHDMI1.20 81.57,110.57 ; 87.2,112.64 JHDMI1.5 ; JHDMI1.5 86.73,112.76 ; JHDMI1.5 87.66,112.76 ; JHDMI1.5 87.2,113.8 ; JHDMI1.5 87.66,113.68 ; JHDMI1.5 86.73,113.68 ; JUSB3.7 316.08,83.47 ; JUSB3.7 314.81,84.74 ; JUSB3.7 316.08,84.74 ; JUSB3.7 314.62,84.1 ; JUSB3.7 314.81,83.47 ; H9.1 108.99,114.46 ; H9.1 106.31,114.46 ; H9.1 105.82,115.8 ; H9.1 107.65,113.97 ; H9.1 107.65,117.63 ; H9.1 106.31,117.14 ; H9.1 109.48,115.8 ; H9.1 108.99,117.14 ; 313.65,76.87 JUSB3.11 ; JUSB3.11 313.65,78.53 ; JUSB3.11 314.98,78.53 ; JUSB3.11 312.32,78.53 ; JUSB3.11 312.32,77.7 ; JUSB3.11 314.98,77.7 ; JUSB3.11 314.98,76.87 ; JUSB3.11 312.32,76.87 ; H2.1 259.28,29.8 ; H2.1 257.65,28.17 ; H2.1 256.02,29.8 ; H2.1 256.45,31 ; H2.1 258.85,31 ; H2.1 257.65,31.43 ; H2.1 258.85,28.6 ; H2.1 256.45,28.6 ; 116,69.62 H12.1 ; H12.1 116,73.02 ; H12.1 117.7,73.66 ; H12.1 119.4,69.62 ; H12.1 115.36,71.32 ; H12.1 119.4,73.02 ; H12.1 120.04,71.32 ; H12.1 117.7,68.98 ; 265.74,116.14 JCRT1.10 ; JCRT1.10 266.25,116.28 ; JCRT1.10 265.22,117.32 ; JCRT1.10 265.22,116.28 ; JCRT1.10 266.25,117.32 ; H4.1 239.32,4.77 ; H4.1 237.55,5.43 ; H4.1 237.55,0.57 ; H4.1 235.78,1.23 ; H4.1 239.98,3 ; H4.1 235.12,3 ; H4.1 239.32,1.23 ; H4.1 235.78,4.77 ; 80.45,117.72 JHDMI1.22 ; JHDMI1.22 79.37,119.3 ; JHDMI1.22 81.53,120.88 ; JHDMI1.22 81.53,119.3 ; JHDMI1.22 79.37,120.88 ; JHDMI1.22 80.45,120.88 ; JHDMI1.22 79.37,117.72 ; JHDMI1.22 81.53,117.72 ; JDOCK1.145 141.53,112.22 ; JDOCK1.145 140.47,112.22 ; JDOCK1.145 140.47,116.18 ; JDOCK1.145 139.42,112.22 ; JDOCK1.145 141.53,114.2 ; JDOCK1.145 141.53,116.18 ; 233.03,109.95 JUSB2.7 ; JUSB2.7 233.6,109.78 ; JUSB2.7 234.17,111.09 ; JUSB2.7 234.34,110.52 ; JUSB2.7 234.17,109.95 ; JUSB2.7 233.03,111.09 ; JUSB2.7 232.86,110.52 ; 256.06,116.28 JCRT1.6 ; JCRT1.6 256.58,116.14 ; JCRT1.6 257.09,116.28 ; JCRT1.6 257.09,117.32 ; JCRT1.6 256.06,117.32 ; JCRT1.6 255.91,116.8 ; JDOCK1.163 171.7,109.3 ; JDOCK1.163 171.7,111.25 ; JDOCK1.163 171.7,110.27 ; JDOCK1.163 170.65,109.3 ; JDOCK1.163 169.6,110.27 ; JDOCK1.163 169.6,109.3 ; JDOCK1.163 170.65,111.25 ; JDOCK1.163 169.6,111.25 ; H19.1 284.82,109.88 ; H19.1 285.48,111.64 ; H19.1 280.62,111.64 ; H19.1 281.28,113.41 ; H19.1 283.05,114.07 ; H19.1 284.82,113.41 ; H19.1 283.05,109.22 ; H19.1 281.28,109.88 ; 286.53,113.75 JLOM1.16 ; JLOM1.16 285.61,115.5 ; JLOM1.16 286.53,117.25 ; JLOM1.16 285.61,113.75 ; JLOM1.16 285.61,117.25 ; 96.07,110.57 JHDMI1.21 ; JHDMI1.21 97.82,112.32 ; JHDMI1.21 96.95,110.57 ; JHDMI1.21 97.82,110.57 ; JHDMI1.21 96.07,114.07 ; JHDMI1.21 96.07,112.32 ; 57.4,119.66 JUSB1.12 ; JUSB1.12 57.4,118.25 ; JUSB1.12 58.35,119.66 ; JUSB1.12 57.4,116.84 ; JUSB1.12 58.35,116.84
  IN1 w0.508: v1(11.47,95.87) 11.47,98.38 14.43,101.34 30.4,101.34 31.95,102.89 v1(31.95,103.42) 34.79,103.42 v1(35.26,102.95) 38.33,102.95 40.34,104.96 41.16,104.96 v1(41.33,104.79)
  GND2 w0.203: SW1.4 229.21,71.88 ; SW1.4 227.69,71.88 ; SW1.4 228.45,73.65 ; SW1.4 229.21,73.4 ; SW1.4 228.45,71.64 ; SW1.4 229.45,72.64 ; SW1.4 227.44,72.64 ; SW1.4 227.69,73.4 ; JHDMI1.20 83.32,110.57 ; JHDMI1.20 81.57,110.57 ; JHDMI1.20 82.45,110.57 ; JHDMI1.20 81.57,112.32 ; JHDMI1.20 83.32,114.07 ; JHDMI1.20 83.32,112.32 ; JDOCK1.159 171.59,113.26 ; JDOCK1.159 169.71,113.26 ; JDOCK1.159 170.65,112.94 ; JDOCK1.159 170.65,115.46 ; JDOCK1.159 169.39,114.2 ; JDOCK1.159 171.91,114.2 ; JDOCK1.159 171.59,115.14 ; JDOCK1.159 169.71,115.14 ; H22.1 60.99,1.81 ; H22.1 59.65,4.98 ; H22.1 57.82,3.15 ; H22.1 59.65,1.32 ; H22.1 58.31,1.81 ; H22.1 60.99,4.49 ; H22.1 58.31,4.49 ; H22.1 61.48,3.15 ; 88.23,111.26 JHDMI1.8 ; JHDMI1.8 88.23,112.18 ; JHDMI1.8 89.16,111.26 ; JHDMI1.8 88.7,111.14 ; JHDMI1.8 88.7,112.3 ; JHDMI1.8 89.16,112.18 ; 157.6,111.25 JDOCK1.162 ; JDOCK1.162 158.65,111.25 ; JDOCK1.162 159.7,111.25 ; JDOCK1.162 159.7,110.27 ; JDOCK1.162 157.6,109.3 ; JDOCK1.162 159.7,109.3 ; JDOCK1.162 157.6,110.27 ; JDOCK1.162 158.65,109.3 ; 179,45.18 H13.1 ; H13.1 177.3,45.82 ; H13.1 176.66,47.52 ; H13.1 181.34,47.52 ; H13.1 180.7,49.22 ; H13.1 177.3,49.22 ; H13.1 179,49.86 ; H13.1 180.7,45.82 ; H10.1 180.7,69.62 ; H10.1 177.3,69.62 ; H10.1 180.7,73.02 ; H10.1 181.34,71.32 ; H10.1 177.3,73.02 ; H10.1 179,73.66 ; H10.1 179,68.98 ; H10.1 176.66,71.32 ; JDOCK1.157 146.65,115.25 ; JDOCK1.157 145.85,113.4 ; JDOCK1.157 145.85,115 ; JDOCK1.157 146.65,113.15 ; JDOCK1.157 147.45,115 ; JDOCK1.157 147.45,113.4 ; JDOCK1.157 145.6,114.2 ; H19.1 285.48,111.64 ; H19.1 281.28,109.88 ; H19.1 283.05,109.22 ; H19.1 284.82,113.41 ; H19.1 283.05,114.07 ; H19.1 281.28,113.41 ; H19.1 284.82,109.88 ; H19.1 280.62,111.64 ; 115.36,71.32 H12.1 ; H12.1 117.7,68.98 ; H12.1 116,69.62 ; H12.1 117.7,73.66 ; H12.1 119.4,69.62 ; H12.1 120.04,71.32 ; H12.1 119.4,73.02 ; H12.1 116,73.02 ; JCRT1.7 259.38,117.32 ; JCRT1.7 258.87,116.14 ; JCRT1.7 258.35,116.28 ; JCRT1.7 259.38,116.28 ; JCRT1.7 258.35,117.32 ; 83.95,59.2 H18.1 ; H18.1 86.35,61.6 ; H18.1 83.95,61.6 ; H18.1 86.78,60.4 ; H18.1 86.35,59.2 ; H18.1 83.52,60.4 ; H18.1 85.15,62.03 ; H18.1 85.15,58.77 ; 169.6,109.3 JDOCK1.163 ; JDOCK1.163 169.6,111.25 ; JDOCK1.163 171.7,111.25 ; JDOCK1.163 171.7,109.3 ; JDOCK1.163 171.7,110.27 ; JDOCK1.163 170.65,111.25 ; JDOCK1.163 170.65,109.3 ; JDOCK1.163 169.6,110.27 ; H17.1 279.1,76.44 ; H17.1 280.59,72.92 ; H17.1 279.1,72.38 ; H17.1 277.61,75.9 ; H17.1 280.59,75.9 ; H17.1 281.13,74.41 ; H17.1 277.07,74.41 ; H17.1 277.61,72.92 ; JUSB1.4 63.27,109.59 ; JUSB1.4 63.27,108.45 ; JUSB1.4 62.13,108.45 ; JUSB1.4 63.44,109.02 ; JUSB1.4 61.96,109.02 ; JUSB1.4 62.7,108.28 ; 79.37,119.3 JHDMI1.22 ; JHDMI1.22 80.45,117.72 ; JHDMI1.22 81.53,120.88 ; JHDMI1.22 81.53,119.3 ; JHDMI1.22 79.37,120.88 ; JHDMI1.22 79.37,117.72 ; JHDMI1.22 80.45,120.88 ; JHDMI1.22 81.53,117.72 ; 313.65,89.67 JUSB3.10 ; JUSB3.10 313.65,91.33 ; JUSB3.10 314.98,91.33 ; JUSB3.10 314.98,89.67 ; JUSB3.10 312.32,89.67 ; JUSB3.10 312.32,90.5 ; JUSB3.10 314.98,90.5 ; JUSB3.10 312.32,91.33 ; 115.36,47.52 H11.1 ; H11.1 117.7,49.86 ; H11.1 120.04,47.52 ; H11.1 119.4,45.82 ; H11.1 119.4,49.22 ; H11.1 116,45.82 ; H11.1 117.7,45.18 ; H11.1 116,49.22 ; JCRT1.16 253.3,115.9 ; JCRT1.16 252.25,114.46 ; JCRT1.16 252.25,117.34 ; JCRT1.16 251.2,117.34 ; JCRT1.16 251.2,115.9 ; JCRT1.16 251.2,114.46 ; JCRT1.16 253.3,114.46 ; JCRT1.16 253.3,117.34 ; JDOCK1.152 188.82,116.18 ; JDOCK1.152 188.82,112.22 ; JDOCK1.152 187.77,116.18 ; JDOCK1.152 189.88,114.2 ; JDOCK1.152 189.88,116.18 ; JDOCK1.152 187.77,114.2 ; JDOCK1.152 189.88,112.22 ; JDOCK1.152 187.77,112.22 ; 260.64,117.32 JCRT1.8 ; JCRT1.8 261.67,117.32 ; JCRT1.8 260.64,116.28 ; JCRT1.8 261.67,116.28 ; JCRT1.8 261.16,116.14 ; 233.03,111.09 JUSB2.7 ; JUSB2.7 233.6,109.78 ; JUSB2.7 232.86,110.52 ; JUSB2.7 233.03,109.95 ; JUSB2.7 234.17,111.09 ; JUSB2.7 234.34,110.52 ; JUSB2.7 234.17,109.95 ; JUSB3.11 313.65,78.53 ; JUSB3.11 314.98,77.7 ; JUSB3.11 312.32,77.7 ; JUSB3.11 312.32,78.53 ; JUSB3.11 314.98,76.87 ; JUSB3.11 312.32,76.87 ; JUSB3.11 314.98,78.53 ; JUSB3.11 313.65,76.87 ; JUSB1.11 59.3,109.59 ; JUSB1.11 58.35,113.3 ; JUSB1.11 57.4,113.3 ; JUSB1.11 58.35,109.59 ; JUSB1.11 57.4,111.45 ; JUSB1.11 57.4,109.59 ; JDOCK1.145 141.53,114.2 ; JDOCK1.145 139.42,112.22 ; JDOCK1.145 140.47,116.18 ; JDOCK1.145 141.53,112.22 ; JDOCK1.145 141.53,116.18 ; JDOCK1.145 140.47,112.22 ; 85.23,112.18 JHDMI1.2 ; JHDMI1.2 86.16,112.18 ; JHDMI1.2 86.16,111.26 ; JHDMI1.2 85.7,111.14 ; JHDMI1.2 85.7,112.3 ; JHDMI1.2 85.11,111.72 ; JHDMI1.2 85.23,111.26 ; JLOM1.16 286.53,117.25 ; JLOM1.16 285.61,115.5 ; JLOM1.16 286.53,113.75 ; JLOM1.16 285.61,113.75 ; JLOM1.16 285.61,117.25 ; 142.15,117.15 JDOCK1.153 ; JDOCK1.153 142.15,119.1 ; JDOCK1.153 140.09,118.12 ; JDOCK1.153 144.21,117.15 ; JDOCK1.153 144.21,118.12 ; JDOCK1.153 144.21,119.1 ; JDOCK1.153 140.09,119.1 ; JCRT1.10 266.25,117.32 ; JCRT1.10 265.74,116.14 ; JCRT1.10 265.22,116.28 ; JCRT1.10 265.22,117.32 ; JCRT1.10 266.25,116.28 ; 256.06,117.32 JCRT1.6 ; JCRT1.6 257.09,116.28 ; JCRT1.6 257.09,117.32 ; JCRT1.6 255.91,116.8 ; JCRT1.6 256.58,116.14 ; JCRT1.6 256.06,116.28 ; 53.71,116.64 H1.1 ; H1.1 53.71,113.96 ; H1.1 55.05,117.13 ; H1.1 53.22,115.3 ; H1.1 56.39,113.96 ; H1.1 56.88,115.3 ; H1.1 56.39,116.64 ; H1.1 55.05,113.47 ; 129.52,119.42 H7.1 ; H7.1 130.01,118.08 ; H7.1 132.69,120.76 ; H7.1 133.18,119.42 ; H7.1 131.35,121.25 ; H7.1 131.35,117.59 ; H7.1 130.01,120.76 ; H7.1 132.69,118.08 ; 235.78,1.23 H4.1 ; H4.1 235.78,4.77 ; H4.1 237.55,0.57 ; H4.1 239.98,3 ; H4.1 239.32,1.23 ; H4.1 239.32,4.77 ; H4.1 237.55,5.43 ; H4.1 235.12,3 ; 96.07,114.07 JHDMI1.21 ; JHDMI1.21 96.95,110.57 ; JHDMI1.21 97.82,110.57 ; JHDMI1.21 96.07,110.57 ; JHDMI1.21 97.82,112.32 ; JHDMI1.21 96.07,112.32 ; 319.3,25.17 H3.1 ; H3.1 317.47,27 ; H3.1 321.13,27 ; H3.1 317.96,25.66 ; H3.1 320.64,28.34 ; H3.1 320.64,25.66 ; H3.1 317.96,28.34 ; H3.1 319.3,28.83 ; 271.3,117.34 JCRT1.17 ; JCRT1.17 273.4,115.9 ; JCRT1.17 273.4,114.46 ; JCRT1.17 272.35,117.34 ; JCRT1.17 271.3,114.46 ; JCRT1.17 273.4,117.34 ; JCRT1.17 272.35,114.46 ; JCRT1.17 271.3,115.9 ; 196.39,119.33 H8.1 ; H8.1 199.56,120.67 ; H8.1 196.88,117.99 ; H8.1 198.22,117.5 ; H8.1 196.88,120.67 ; H8.1 199.56,117.99 ; H8.1 198.22,121.16 ; H8.1 200.05,119.33 ; JUSB2.10 242.4,111.45 ; JUSB2.10 241.45,113.3 ; JUSB2.10 242.4,113.3 ; JUSB2.10 242.4,109.59 ; JUSB2.10 241.45,109.59 ; JUSB2.10 240.5,109.59 ; JUSB2.12 225.75,119.66 ; JUSB2.12 224.8,116.84 ; JUSB2.12 225.75,116.84 ; JUSB2.12 224.8,119.66 ; JUSB2.12 224.8,118.25 ; JHDMI1.5 87.2,113.8 ; JHDMI1.5 86.73,113.68 ; JHDMI1.5 87.66,112.76 ; JHDMI1.5 86.73,112.76 ; JHDMI1.5 87.66,113.68 ; JHDMI1.5 87.2,112.64 ; 224.8,111.45 JUSB2.11 ; JUSB2.11 225.75,109.59 ; JUSB2.11 225.75,113.3 ; JUSB2.11 224.8,109.59 ; JUSB2.11 224.8,113.3 ; JUSB2.11 226.7,109.59 ; JHDMI1.11 90.66,113.68 ; JHDMI1.11 89.73,113.68 ; JHDMI1.11 90.66,112.76 ; JHDMI1.11 89.73,112.76 ; JHDMI1.11 90.2,112.64 ; JHDMI1.11 90.2,113.8 ; 185.09,111.25 JDOCK1.164 ; JDOCK1.164 185.09,109.3 ; JDOCK1.164 189.21,111.25 ; JDOCK1.164 189.21,109.3 ; JDOCK1.164 185.09,110.27 ; JDOCK1.164 187.15,109.3 ; JDOCK1.164 187.15,111.25 ; JDOCK1.164 189.21,110.27 ; 233.99,73.4 SW1.5 ; SW1.5 233.99,71.88 ; SW1.5 233.74,72.64 ; SW1.5 235.51,71.88 ; SW1.5 235.75,72.64 ; SW1.5 235.51,73.4 ; SW1.5 234.75,71.64 ; SW1.5 234.75,73.65 ; JHDMI1.23 98.95,120.88 ; JHDMI1.23 98.95,117.72 ; JHDMI1.23 100.03,120.88 ; JHDMI1.23 100.03,119.3 ; JHDMI1.23 97.87,119.3 ; JHDMI1.23 100.03,117.72 ; JHDMI1.23 97.87,117.72 ; JHDMI1.23 97.87,120.88 ; JUSB3.12 322.9,92.58 ; JUSB3.12 324.08,91.8 ; JUSB3.12 321.72,91.8 ; JUSB3.12 321.72,92.58 ; JUSB3.12 324.08,92.58 ; JUSB1.12 58.35,119.66 ; JUSB1.12 58.35,116.84 ; JUSB1.12 57.4,119.66 ; JUSB1.12 57.4,118.25 ; JUSB1.12 57.4,116.84 ; JDOCK1.155 171.7,117.15 ; JDOCK1.155 169.6,119.1 ; JDOCK1.155 170.65,117.15 ; JDOCK1.155 169.6,117.15 ; JDOCK1.155 171.7,119.1 ; JDOCK1.155 169.6,118.12 ; JDOCK1.155 170.65,119.1 ; JDOCK1.155 171.7,118.12 ; 220.31,114.46 H6.1 ; H6.1 220.31,117.14 ; H6.1 221.65,117.63 ; H6.1 219.82,115.8 ; H6.1 222.99,117.14 ; H6.1 222.99,114.46 ; H6.1 223.48,115.8 ; H6.1 221.65,113.97 ; 185.09,118.12 JDOCK1.156 ; JDOCK1.156 185.09,117.15 ; JDOCK1.156 187.15,119.1 ; JDOCK1.156 189.21,119.1 ; JDOCK1.156 187.15,117.15 ; JDOCK1.156 189.21,118.12 ; JDOCK1.156 189.21,117.15 ; JDOCK1.156 185.09,119.1 ; JDOCK1.160 183.7,114.2 ; JDOCK1.160 183.45,113.4 ; JDOCK1.160 182.65,115.25 ; JDOCK1.160 181.85,115 ; JDOCK1.160 183.45,115 ; JDOCK1.160 182.65,113.15 ; JDOCK1.160 181.85,113.4 ; 322.9,75.62 JUSB3.13 ; JUSB3.13 324.08,76.4 ; JUSB3.13 324.08,75.62 ; JUSB3.13 321.72,75.62 ; JUSB3.13 321.72,76.4 ; H24.1 20.02,82.32 ; H24.1 18.5,78.72 ; H24.1 16.98,79.28 ; H24.1 20.02,79.28 ; H24.1 20.58,80.8 ; 92.73,113.68 JHDMI1.17 ; JHDMI1.17 93.66,112.76 ; JHDMI1.17 93.66,113.68 ; JHDMI1.17 93.2,112.64 ; JHDMI1.17 92.73,112.76 ; JHDMI1.17 93.2,113.8 ; H2.1 257.65,31.43 ; H2.1 257.65,28.17 ; H2.1 256.45,28.6 ; H2.1 256.02,29.8 ; H2.1 256.45,31 ; H2.1 259.28,29.8 ; H2.1 258.85,28.6 ; H2.1 258.85,31 ; JCRT1.5 267.54,116.8 ; JCRT1.5 267.4,117.32 ; JCRT1.5 266.36,116.28 ; JCRT1.5 266.36,117.32 ; JCRT1.5 267.4,116.28 ; JDOCK1.158 159.91,114.2 ; JDOCK1.158 158.65,115.46 ; JDOCK1.158 159.59,113.26 ; JDOCK1.158 157.71,115.14 ; JDOCK1.158 159.59,115.14 ; JDOCK1.158 157.39,114.2 ; JDOCK1.158 157.71,113.26 ; JDOCK1.158 158.65,112.94 ; 105.82,115.8 H9.1 ; H9.1 106.31,114.46 ; H9.1 107.65,113.97 ; H9.1 107.65,117.63 ; H9.1 106.31,117.14 ; H9.1 109.48,115.8 ; H9.1 108.99,114.46 ; H9.1 108.99,117.14 ; JLOM1.14 306.49,117.25 ; JLOM1.14 305.58,117.25 ; JLOM1.14 306.49,115.5 ; JLOM1.14 305.58,113.75 ; JLOM1.14 306.49,113.75 ; JDOCK1.161 144.21,110.27 ; JDOCK1.161 142.15,109.3 ; JDOCK1.161 140.09,110.27 ; JDOCK1.161 142.15,111.25 ; JDOCK1.161 144.21,109.3 ; JDOCK1.161 140.09,111.25 ; JDOCK1.161 140.09,109.3 ; JDOCK1.161 144.21,111.25 ; 65.63,111.09 JUSB1.7 ; JUSB1.7 65.63,109.95 ; JUSB1.7 66.77,111.09 ; JUSB1.7 65.46,110.52 ; JUSB1.7 66.2,109.78 ; JUSB1.7 66.77,109.95 ; JUSB1.7 66.94,110.52 ; 229.36,109.02 JUSB2.4 ; JUSB2.4 230.67,109.59 ; JUSB2.4 229.53,108.45 ; JUSB2.4 230.1,108.28 ; JUSB2.4 230.67,108.45 ; JUSB2.4 230.84,109.02 ; 314.81,83.47 JUSB3.7 ; JUSB3.7 316.08,83.47 ; JUSB3.7 314.81,84.74 ; JUSB3.7 316.08,84.74 ; JUSB3.7 314.62,84.1 ; JUSB2.13 241.45,119.66 ; JUSB2.13 242.4,119.66 ; JUSB2.13 242.4,116.84 ; JUSB2.13 242.4,118.25 ; JUSB2.13 241.45,116.84 ; JUSB1.13 75,116.84 ; JUSB1.13 74.05,119.66 ; JUSB1.13 75,118.25 ; JUSB1.13 75,119.66 ; JUSB1.13 74.05,116.84 ; JDOCK1.154 159.7,118.12 ; JDOCK1.154 158.65,117.15 ; JDOCK1.154 157.6,117.15 ; JDOCK1.154 159.7,117.15 ; JDOCK1.154 159.7,119.1 ; JDOCK1.154 158.65,119.1 ; JDOCK1.154 157.6,119.1 ; JDOCK1.154 157.6,118.12 ; JUSB1.10 75,111.45 ; JUSB1.10 75,113.3 ; JUSB1.10 74.05,109.59 ; JUSB1.10 75,109.59 ; JUSB1.10 74.05,113.3 ; JUSB1.10 73.1,109.59 ; 313.31,88.24 JUSB3.4 ; JUSB3.4 314.58,86.97 ; JUSB3.4 313.12,87.6 ; JUSB3.4 313.95,88.43 ; JUSB3.4 313.31,86.97 ; JUSB3.4 313.95,86.77 ; H15.1 247.97,94.34 ; H15.1 246.48,90.82 ; H15.1 248.51,92.85 ; H15.1 244.45,92.85 ; H15.1 247.97,91.36 ; H15.1 244.99,91.36 ; H15.1 244.99,94.34 ; H15.1 246.48,94.88
  IN3 w0.508: v3(17.49,93.94) 17.49,93.51 19.27,91.73 19.62,91.73 20.15,91.2 20.15,90.41 v1(19.62,89.88) 18.29,88.55 v3(18.29,88.32) 18.3,88.31 v3(18.3,86.26) 18.3,85.82 19.37,84.75 21.12,84.75 v1(21.6,84.27)
  VCC w0.203: 224.8,113.3 JUSB2.11 ; JUSB2.11 226.7,109.59 ; JUSB2.11 225.75,109.59 ; JUSB2.11 224.8,109.59 ; JUSB2.11 225.75,113.3 ; JUSB2.11 224.8,111.45 ; 220.31,114.46 H6.1 ; H6.1 223.48,115.8 ; H6.1 222.99,117.14 ; H6.1 221.65,113.97 ; H6.1 219.82,115.8 ; H6.1 222.99,114.46 ; H6.1 220.31,117.14 ; H6.1 221.65,117.63 ; JUSB3.13 324.08,75.62 ; JUSB3.13 324.08,76.4 ; JUSB3.13 322.9,75.62 ; JUSB3.13 321.72,75.62 ; JUSB3.13 321.72,76.4 ; 321.72,92.58 JUSB3.12 ; JUSB3.12 321.72,91.8 ; JUSB3.12 324.08,91.8 ; JUSB3.12 322.9,92.58 ; JUSB3.12 324.08,92.58 ; 53.71,116.64 H1.1 ; H1.1 53.22,115.3 ; H1.1 53.71,113.96 ; H1.1 56.39,116.64 ; H1.1 56.88,115.3 ; H1.1 55.05,113.47 ; H1.1 56.39,113.96 ; H1.1 55.05,117.13 ; JUSB3.11 314.98,76.87 ; JUSB3.11 314.98,78.53 ; JUSB3.11 314.98,77.7 ; JUSB3.11 312.32,76.87 ; JUSB3.11 313.65,78.53 ; JUSB3.11 312.32,77.7 ; JUSB3.11 312.32,78.53 ; JUSB3.11 313.65,76.87 ; JHDMI1.8 89.16,111.26 ; JHDMI1.8 88.23,111.26 ; JHDMI1.8 88.7,111.14 ; JHDMI1.8 88.7,112.3 ; JHDMI1.8 88.23,112.18 ; JHDMI1.8 89.16,112.18 ; JUSB1.13 74.05,119.66 ; JUSB1.13 74.05,116.84 ; JUSB1.13 75,116.84 ; JUSB1.13 75,119.66 ; JUSB1.13 75,118.25 ; JUSB2.12 225.75,119.66 ; JUSB2.12 225.75,116.84 ; JUSB2.12 224.8,116.84 ; JUSB2.12 224.8,118.25 ; JUSB2.12 224.8,119.66 ; JHDMI1.11 90.66,112.76 ; JHDMI1.11 90.2,113.8 ; JHDMI1.11 90.66,113.68 ; JHDMI1.11 89.73,112.76 ; JHDMI1.11 90.2,112.64 ; JHDMI1.11 89.73,113.68 ; 62.13,108.45 JUSB1.4 ; JUSB1.4 63.27,108.45 ; JUSB1.4 63.44,109.02 ; JUSB1.4 61.96,109.02 ; JUSB1.4 63.27,109.59 ; JUSB1.4 62.7,108.28 ; 58.35,116.84 JUSB1.12 ; JUSB1.12 57.4,119.66 ; JUSB1.12 57.4,116.84 ; JUSB1.12 58.35,119.66 ; JUSB1.12 57.4,118.25 ; JUSB3.7 316.08,84.74 ; JUSB3.7 314.62,84.1 ; JUSB3.7 314.81,83.47 ; JUSB3.7 314.81,84.74 ; JUSB3.7 316.08,83.47 ; 58.35,109.59 JUSB1.11 ; JUSB1.11 59.3,109.59 ; JUSB1.11 57.4,113.3 ; JUSB1.11 58.35,113.3 ; JUSB1.11 57.4,111.45 ; JUSB1.11 57.4,109.59 ; JLOM1.14 306.49,113.75 ; JLOM1.14 305.58,113.75 ; JLOM1.14 305.58,117.25 ; JLOM1.14 306.49,115.5 ; JLOM1.14 306.49,117.25 ; 281.28,109.88 H19.1 ; H19.1 280.62,111.64 ; H19.1 283.05,114.07 ; H19.1 285.48,111.64 ; H19.1 284.82,113.41 ; H19.1 281.28,113.41 ; H19.1 284.82,109.88 ; H19.1 283.05,109.22 ; JUSB2.4 230.67,108.45 ; JUSB2.4 230.67,109.59 ; JUSB2.4 229.53,108.45 ; JUSB2.4 230.84,109.02 ; JUSB2.4 229.36,109.02 ; JUSB2.4 230.1,108.28 ; JUSB2.13 241.45,119.66 ; JUSB2.13 242.4,119.66 ; JUSB2.13 242.4,116.84 ; JUSB2.13 241.45,116.84 ; JUSB2.13 242.4,118.25 ; JCRT1.16 253.3,115.9 ; JCRT1.16 251.2,115.9 ; JCRT1.16 253.3,117.34 ; JCRT1.16 253.3,114.46 ; JCRT1.16 252.25,117.34 ; JCRT1.16 251.2,117.34 ; JCRT1.16 251.2,114.46 ; JCRT1.16 252.25,114.46 ; JHDMI1.17 93.66,113.68 ; JHDMI1.17 93.2,113.8 ; JHDMI1.17 93.2,112.64 ; JHDMI1.17 92.73,112.76 ; JHDMI1.17 93.66,112.76 ; JHDMI1.17 92.73,113.68 ; JCRT1.5 267.4,117.32 ; JCRT1.5 267.54,116.8 ; JCRT1.5 267.4,116.28 ; JCRT1.5 266.36,116.28 ; JCRT1.5 266.36,117.32 ; 79.37,120.88 JHDMI1.22 ; JHDMI1.22 81.53,120.88 ; JHDMI1.22 80.45,117.72 ; JHDMI1.22 81.53,119.3 ; JHDMI1.22 81.53,117.72 ; JHDMI1.22 79.37,119.3 ; JHDMI1.22 80.45,120.88 ; JHDMI1.22 79.37,117.72 ; 265.74,116.14 JCRT1.10 ; JCRT1.10 265.22,117.32 ; JCRT1.10 266.25,117.32 ; JCRT1.10 265.22,116.28 ; JCRT1.10 266.25,116.28 ; JHDMI1.5 87.66,113.68 ; JHDMI1.5 87.66,112.76 ; JHDMI1.5 87.2,112.64 ; JHDMI1.5 86.73,112.76 ; JHDMI1.5 86.73,113.68 ; JHDMI1.5 87.2,113.8 ; 286.53,113.75 JLOM1.16 ; JLOM1.16 285.61,115.5 ; JLOM1.16 285.61,117.25 ; JLOM1.16 285.61,113.75 ; JLOM1.16 286.53,117.25 ; H9.1 108.99,117.14 ; H9.1 105.82,115.8 ; H9.1 109.48,115.8 ; H9.1 106.31,114.46 ; H9.1 107.65,113.97 ; H9.1 108.99,114.46 ; H9.1 107.65,117.63 ; H9.1 106.31,117.14 ; JUSB2.10 241.45,113.3 ; JUSB2.10 242.4,113.3 ; JUSB2.10 242.4,109.59 ; JUSB2.10 241.45,109.59 ; JUSB2.10 240.5,109.59 ; JUSB2.10 242.4,111.45 ; JCRT1.17 272.35,117.34 ; JCRT1.17 272.35,114.46 ; JCRT1.17 271.3,114.46 ; JCRT1.17 271.3,115.9 ; JCRT1.17 273.4,115.9 ; JCRT1.17 273.4,117.34 ; JCRT1.17 273.4,114.46 ; JCRT1.17 271.3,117.34 ; 260.64,116.28 JCRT1.8 ; JCRT1.8 261.67,116.28 ; JCRT1.8 261.67,117.32 ; JCRT1.8 260.64,117.32 ; JCRT1.8 261.16,116.14 ; JUSB2.7 234.34,110.52 ; JUSB2.7 234.17,111.09 ; JUSB2.7 234.17,109.95 ; JUSB2.7 233.6,109.78 ; JUSB2.7 232.86,110.52 ; JUSB2.7 233.03,111.09 ; JUSB2.7 233.03,109.95 ; 73.1,109.59 JUSB1.10 ; JUSB1.10 75,109.59 ; JUSB1.10 74.05,109.59 ; JUSB1.10 75,113.3 ; JUSB1.10 75,111.45 ; JUSB1.10 74.05,113.3 ; 96.95,110.57 JHDMI1.21 ; JHDMI1.21 96.07,112.32 ; JHDMI1.21 96.07,114.07 ; JHDMI1.21 96.07,110.57 ; JHDMI1.21 97.82,110.57 ; JHDMI1.21 97.82,112.32 ; 256.06,117.32 JCRT1.6 ; JCRT1.6 256.06,116.28 ; JCRT1.6 257.09,116.28 ; JCRT1.6 255.91,116.8 ; JCRT1.6 257.09,117.32 ; JCRT1.6 256.58,116.14 ; H11.1 119.4,49.22 ; H11.1 117.7,49.86 ; H11.1 115.36,47.52 ; H11.1 119.4,45.82 ; H11.1 120.04,47.52 ; H11.1 116,45.82 ; H11.1 117.7,45.18 ; H11.1 116,49.22 ; 98.95,117.72 JHDMI1.23 ; JHDMI1.23 100.03,119.3 ; JHDMI1.23 97.87,119.3 ; JHDMI1.23 97.87,117.72 ; JHDMI1.23 100.03,120.88 ; JHDMI1.23 100.03,117.72 ; JHDMI1.23 98.95,120.88 ; JHDMI1.23 97.87,120.88 ; 313.31,86.97 JUSB3.4 ; JUSB3.4 313.31,88.24 ; JUSB3.4 314.58,86.97 ; JHDMI1.2 85.7,112.3 ; JHDMI1.2 85.23,111.26 ; JHDMI1.2 86.16,111.26 ; JHDMI1.2 85.7,111.14 ; JHDMI1.2 85.11,111.72 ; JHDMI1.2 86.16,112.18 ; JHDMI1.2 85.23,112.18 ; 313.65,89.67 JUSB3.10 ; JUSB3.10 312.32,91.33 ; JUSB3.10 314.98,89.67 ; JUSB3.10 313.65,91.33 ; JUSB3.10 314.98,91.33 ; JUSB3.10 312.32,89.67 ; JUSB3.10 312.32,90.5 ; JUSB3.10 314.98,90.5 ; 66.2,109.78 JUSB1.7 ; JUSB1.7 65.46,110.52 ; JUSB1.7 66.77,111.09 ; JUSB1.7 66.77,109.95 ; JUSB1.7 65.63,111.09 ; JUSB1.7 66.94,110.52 ; JUSB1.7 65.63,109.95 ; 81.57,112.32 JHDMI1.20 ; JHDMI1.20 83.32,114.07 ; JHDMI1.20 82.45,110.57 ; JHDMI1.20 83.32,112.32 ; JHDMI1.20 83.32,110.57 ; JHDMI1.20 81.57,110.57 ; 258.87,116.14 JCRT1.7 ; JCRT1.7 259.38,116.28 ; JCRT1.7 258.35,117.32 ; JCRT1.7 258.35,116.28 ; JCRT1.7 259.38,117.32
  GND3 w0.203: 256.06,116.28 JCRT1.6 ; JCRT1.6 256.58,116.14 ; JCRT1.6 257.09,116.28 ; JCRT1.6 255.91,116.8 ; JCRT1.6 256.06,117.32 ; JCRT1.6 257.09,117.32 ; 157.6,118.12 JDOCK1.154 ; JDOCK1.154 159.7,119.1 ; JDOCK1.154 159.7,118.12 ; JDOCK1.154 159.7,117.15 ; JDOCK1.154 157.6,117.15 ; JDOCK1.154 158.65,117.15 ; JDOCK1.154 158.65,119.1 ; JDOCK1.154 157.6,119.1 ; JUSB2.4 230.67,108.45 ; JUSB2.4 229.53,108.45 ; JUSB2.4 229.36,109.02 ; JUSB2.4 230.67,109.59 ; JUSB2.4 230.1,108.28 ; JUSB2.4 230.84,109.02 ; H6.1 221.65,117.63 ; H6.1 220.31,117.14 ; H6.1 221.65,113.97 ; H6.1 219.82,115.8 ; H6.1 222.99,114.46 ; H6.1 223.48,115.8 ; H6.1 220.31,114.46 ; H6.1 222.99,117.14 ; JDOCK1.160 183.45,113.4 ; JDOCK1.160 183.45,115 ; JDOCK1.160 182.65,115.25 ; JDOCK1.160 181.85,115 ; JDOCK1.160 181.85,113.4 ; JDOCK1.160 183.7,114.2 ; JDOCK1.160 182.65,113.15 ; JUSB2.11 226.7,109.59 ; JUSB2.11 224.8,109.59 ; JUSB2.11 224.8,111.45 ; JUSB2.11 225.75,109.59 ; JUSB2.11 225.75,113.3 ; JUSB2.11 224.8,113.3 ; 140.09,118.12 JDOCK1.153 ; JDOCK1.153 144.21,119.1 ; JDOCK1.153 142.15,119.1 ; JDOCK1.153 144.21,118.12 ; JDOCK1.153 144.21,117.15 ; JDOCK1.153 140.09,119.1 ; JDOCK1.153 142.15,117.15 ; H18.1 85.15,62.03 ; H18.1 83.95,61.6 ; H18.1 83.52,60.4 ; H18.1 83.95,59.2 ; H18.1 85.15,58.77 ; H18.1 86.35,61.6 ; H18.1 86.78,60.4 ; H18.1 86.35,59.2 ; H8.1 199.56,120.67 ; H8.1 196.39,119.33 ; H8.1 196.88,120.67 ; H8.1 196.88,117.99 ; H8.1 198.22,117.5 ; H8.1 200.05,119.33 ; H8.1 198.22,121.16 ; H8.1 199.56,117.99 ; JUSB1.11 58.35,113.3 ; JUSB1.11 57.4,109.59 ; JUSB1.11 58.35,109.59 ; JUSB1.11 59.3,109.59 ; JUSB1.11 57.4,113.3 ; JUSB1.11 57.4,111.45 ; 244.45,92.85 H15.1 ; H15.1 246.48,90.82 ; H15.1 248.51,92.85 ; H15.1 246.48,94.88 ; H15.1 247.97,91.36 ; H15.1 244.99,94.34 ; H15.1 247.97,94.34 ; H15.1 244.99,91.36 ; H1.1 55.05,117.13 ; H1.1 56.88,115.3 ; H1.1 56.39,113.96 ; H1.1 55.05,113.47 ; H1.1 53.22,115.3 ; H1.1 53.71,113.96 ; H1.1 53.71,116.64 ; H1.1 56.39,116.64 ; 179,68.98 H10.1 ; H10.1 180.7,73.02 ; H10.1 177.3,69.62 ; H10.1 181.34,71.32 ; H10.1 176.66,71.32 ; H10.1 180.7,69.62 ; H10.1 177.3,73.02 ; H10.1 179,73.66 ; 321.72,75.62 JUSB3.13 ; JUSB3.13 321.72,76.4 ; JUSB3.13 322.9,75.62 ; JUSB3.13 324.08,75.62 ; JUSB3.13 324.08,76.4 ; 131.35,117.59 H7.1 ; H7.1 129.52,119.42 ; H7.1 132.69,120.76 ; H7.1 130.01,120.76 ; H7.1 132.69,118.08 ; H7.1 130.01,118.08 ; H7.1 131.35,121.25 ; H7.1 133.18,119.42 ; JUSB3.12 324.08,91.8 ; JUSB3.12 321.72,91.8 ; JUSB3.12 321.72,92.58 ; JUSB3.12 322.9,92.58 ; JUSB3.12 324.08,92.58 ; JHDMI1.8 88.7,112.3 ; JHDMI1.8 89.16,111.26 ; JHDMI1.8 89.16,112.18 ; JHDMI1.8 88.23,111.26 ; JHDMI1.8 88.23,112.18 ; JHDMI1.8 88.7,111.14 ; JCRT1.5 267.4,116.28 ; JCRT1.5 267.4,117.32 ; JCRT1.5 266.36,117.32 ; JCRT1.5 266.36,116.28 ; JCRT1.5 267.54,116.8 ; JHDMI1.23 100.03,119.3 ; JHDMI1.23 100.03,117.72 ; JHDMI1.23 97.87,119.3 ; JHDMI1.23 97.87,117.72 ; JHDMI1.23 97.87,120.88 ; JHDMI1.23 98.95,120.88 ; JHDMI1.23 98.95,117.72 ; JHDMI1.23 100.03,120.88 ; 177.3,49.22 H13.1 ; H13.1 180.7,45.82 ; H13.1 179,49.86 ; H13.1 177.3,45.82 ; H13.1 179,45.18 ; H13.1 180.7,49.22 ; H13.1 181.34,47.52 ; H13.1 176.66,47.52 ; JUSB1.10 75,109.59 ; JUSB1.10 75,113.3 ; JUSB1.10 73.1,109.59 ; JUSB1.10 74.05,109.59 ; JUSB1.10 75,111.45 ; JUSB1.10 74.05,113.3 ; JDOCK1.158 159.59,113.26 ; JDOCK1.158 159.59,115.14 ; JDOCK1.158 159.91,114.2 ; JDOCK1.158 157.71,113.26 ; JDOCK1.158 157.71,115.14 ; JDOCK1.158 158.65,112.94 ; JDOCK1.158 157.39,114.2 ; JDOCK1.158 158.65,115.46 ; JUSB3.10 313.65,91.33 ; JUSB3.10 314.98,90.5 ; JUSB3.10 312.32,90.5 ; JUSB3.10 312.32,89.67 ; JUSB3.10 314.98,89.67 ; JUSB3.10 312.32,91.33 ; JUSB3.10 314.98,91.33 ; JUSB3.10 313.65,89.67 ; 233.99,71.88 SW1.5 ; SW1.5 233.74,72.64 ; SW1.5 235.51,71.88 ; SW1.5 235.75,72.64 ; SW1.5 234.75,73.65 ; SW1.5 233.99,73.4 ; SW1.5 234.75,71.64 ; SW1.5 235.51,73.4 ; H22.1 61.48,3.15 ; H22.1 57.82,3.15 ; H22.1 60.99,4.49 ; H22.1 58.31,4.49 ; H22.1 59.65,4.98 ; H22.1 60.99,1.81 ; H22.1 58.31,1.81 ; H22.1 59.65,1.32 ; 261.16,116.14 JCRT1.8 ; JCRT1.8 260.64,116.28 ; JCRT1.8 261.67,116.28 ; JCRT1.8 260.64,117.32 ; JCRT1.8 261.67,117.32 ; H9.1 108.99,114.46 ; H9.1 106.31,114.46 ; H9.1 107.65,117.63 ; H9.1 105.82,115.8 ; H9.1 109.48,115.8 ; H9.1 108.99,117.14 ; H9.1 106.31,117.14 ; H9.1 107.65,113.97 ; 169.71,115.14 JDOCK1.159 ; JDOCK1.159 171.59,115.14 ; JDOCK1.159 171.91,114.2 ; JDOCK1.159 169.71,113.26 ; JDOCK1.159 170.65,115.46 ; JDOCK1.159 170.65,112.94 ; JDOCK1.159 171.59,113.26 ; JDOCK1.159 169.39,114.2 ; JUSB2.13 242.4,119.66 ; JUSB2.13 242.4,116.84 ; JUSB2.13 241.45,119.66 ; JUSB2.13 241.45,116.84 ; JUSB2.13 242.4,118.25 ; 312.32,76.87 JUSB3.11 ; JUSB3.11 313.65,76.87 ; JUSB3.11 314.98,76.87 ; JUSB3.11 313.65,78.53 ; JUSB3.11 314.98,77.7 ; JUSB3.11 314.98,78.53 ; JUSB3.11 312.32,77.7 ; JUSB3.11 312.32,78.53 ; 145.6,114.2 JDOCK1.157 ; JDOCK1.157 146.65,113.15 ; JDOCK1.157 145.85,115 ; JDOCK1.157 147.45,113.4 ; JDOCK1.157 146.65,115.25 ; JDOCK1.157 145.85,113.4 ; JDOCK1.157 147.45,115 ; 286.53,113.75 JLOM1.16 ; JLOM1.16 286.53,117.25 ; JLOM1.16 285.61,115.5 ; JLOM1.16 285.61,117.25 ; JLOM1.16 285.61,113.75 ; H19.1 284.82,109.88 ; H19.1 285.48,111.64 ; H19.1 280.62,111.64 ; H19.1 284.82,113.41 ; H19.1 283.05,109.22 ; H19.1 283.05,114.07 ; H19.1 281.28,113.41 ; H19.1 281.28,109.88 ; 61.96,109.02 JUSB1.4 ; JUSB1.4 63.27,108.45 ; JUSB1.4 63.44,109.02 ; JUSB1.4 63.27,109.59 ; JUSB1.4 62.13,108.45 ; JUSB1.4 62.7,108.28 ; 256.02,29.8 H2.1 ; H2.1 256.45,28.6 ; H2.1 258.85,31 ; H2.1 258.85,28.6 ; H2.1 256.45,31 ; H2.1 257.65,28.17 ; H2.1 257.65,31.43 ; H2.1 259.28,29.8 ; 87.2,112.64 JHDMI1.5 ; JHDMI1.5 86.73,113.68 ; JHDMI1.5 87.66,113.68 ; JHDMI1.5 87.66,112.76 ; JHDMI1.5 87.2,113.8 ; JHDMI1.5 86.73,112.76 ; JUSB1.13 75,118.25 ; JUSB1.13 75,119.66 ; JUSB1.13 75,116.84 ; JUSB1.13 74.05,116.84 ; JUSB1.13 74.05,119.66 ; JDOCK1.145 140.47,116.18 ; JDOCK1.145 139.42,112.22 ; JDOCK1.145 141.53,112.22 ; JDOCK1.145 141.53,114.2 ; JDOCK1.145 140.47,112.22 ; JDOCK1.145 141.53,116.18 ; JDOCK1.152 189.88,112.22 ; JDOCK1.152 189.88,116.18 ; JDOCK1.152 187.77,112.22 ; JDOCK1.152 189.88,114.2 ; JDOCK1.152 188.82,112.22 ; JDOCK1.152 187.77,114.2 ; JDOCK1.152 188.82,116.18 ; JDOCK1.152 187.77,116.18 ; 279.1,72.38 H17.1 ; H17.1 277.07,74.41 ; H17.1 277.61,72.92 ; H17.1 281.13,74.41 ; H17.1 280.59,75.9 ; H17.1 280.59,72.92 ; H17.1 277.61,75.9 ; H17.1 279.1,76.44 ; JUSB2.10 242.4,113.3 ; JUSB2.10 241.45,109.59 ; JUSB2.10 240.5,109.59 ; JUSB2.10 242.4,111.45 ; JUSB2.10 241.45,113.3 ; JUSB2.10 242.4,109.59 ; 81.57,110.57 JHDMI1.20 ; JHDMI1.20 81.57,112.32 ; JHDMI1.20 82.45,110.57 ; JHDMI1.20 83.32,114.07 ; JHDMI1.20 83.32,112.32 ; JHDMI1.20 83.32,110.57 ; H12.1 117.7,73.66 ; H12.1 116,73.02 ; H12.1 116,69.62 ; H12.1 117.7,68.98 ; H12.1 119.4,69.62 ; H12.1 115.36,71.32 ; H12.1 120.04,71.32 ; H12.1 119.4,73.02 ; JDOCK1.161 142.15,111.25 ; JDOCK1.161 142.15,109.3 ; JDOCK1.161 140.09,109.3 ; JDOCK1.161 140.09,111.25 ; JDOCK1.161 144.21,109.3 ; JDOCK1.161 144.21,111.25 ; JDOCK1.161 144.21,110.27 ; JDOCK1.161 140.09,110.27 ; 235.78,4.77 H4.1 ; H4.1 237.55,0.57 ; H4.1 239.98,3 ; H4.1 235.78,1.23 ; H4.1 237.55,5.43 ; H4.1 239.32,1.23 ; H4.1 239.32,4.77 ; H4.1 235.12,3 ; 185.09,109.3 JDOCK1.164 ; JDOCK1.164 187.15,111.25 ; JDOCK1.164 189.21,109.3 ; JDOCK1.164 189.21,110.27 ; JDOCK1.164 187.15,109.3 ; JDOCK1.164 185.09,110.27 ; JDOCK1.164 185.09,111.25 ; JDOCK1.164 189.21,111.25 ; JHDMI1.2 85.7,112.3 ; JHDMI1.2 85.23,112.18 ; JHDMI1.2 86.16,112.18 ; JHDMI1.2 85.11,111.72 ; JHDMI1.2 85.23,111.26 ; JHDMI1.2 85.7,111.14 ; JHDMI1.2 86.16,111.26 ; 314.81,84.74 JUSB3.7 ; JUSB3.7 316.08,84.74 ; JUSB3.7 314.62,84.1 ; JUSB3.7 314.81,83.47 ; JUSB3.7 316.08,83.47 ; 313.31,86.97 JUSB3.4 ; JUSB3.4 314.58,86.97 ; JUSB3.4 313.31,88.24 ; JUSB3.4 313.12,87.6 ; JUSB3.4 313.95,88.43 ; JUSB3.4 313.95,86.77 ; 272.35,114.46 JCRT1.17 ; JCRT1.17 271.3,115.9 ; JCRT1.17 273.4,115.9 ; JCRT1.17 271.3,114.46 ; JCRT1.17 271.3,117.34 ; JCRT1.17 272.35,117.34 ; JCRT1.17 273.4,114.46 ; JCRT1.17 273.4,117.34 ; 65.46,110.52 JUSB1.7 ; JUSB1.7 66.77,109.95 ; JUSB1.7 66.94,110.52 ; JUSB1.7 66.2,109.78 ; JUSB1.7 65.63,109.95 ; JUSB1.7 65.63,111.09 ; JUSB1.7 66.77,111.09 ; 252.25,114.46 JCRT1.16 ; JCRT1.16 253.3,115.9 ; JCRT1.16 251.2,115.9 ; JCRT1.16 252.25,117.34 ; JCRT1.16 251.2,114.46 ; JCRT1.16 253.3,114.46 ; JCRT1.16 251.2,117.34 ; JCRT1.16 253.3,117.34 ; 258.35,116.28 JCRT1.7 ; JCRT1.7 258.35,117.32 ; JCRT1.7 259.38,116.28 ; JCRT1.7 259.38,117.32 ; JCRT1.7 258.87,116.14 ; 169.6,119.1 JDOCK1.155 ; JDOCK1.155 170.65,119.1 ; JDOCK1.155 169.6,118.12 ; JDOCK1.155 171.7,119.1 ; JDOCK1.155 171.7,118.12 ; JDOCK1.155 171.7,117.15 ; JDOCK1.155 169.6,117.15 ; JDOCK1.155 170.65,117.15 ; 169.6,110.27 JDOCK1.163 ; JDOCK1.163 171.7,109.3 ; JDOCK1.163 169.6,111.25 ; JDOCK1.163 170.65,109.3 ; JDOCK1.163 171.7,110.27 ; JDOCK1.163 169.6,109.3 ; JDOCK1.163 170.65,111.25 ; JDOCK1.163 171.7,111.25 ; 185.09,119.1 JDOCK1.156 ; JDOCK1.156 185.09,118.12 ; JDOCK1.156 189.21,119.1 ; JDOCK1.156 189.21,118.12 ; JDOCK1.156 185.09,117.15 ; JDOCK1.156 187.15,119.1 ; JDOCK1.156 187.15,117.15 ; JDOCK1.156 189.21,117.15 ; 57.4,116.84 JUSB1.12 ; JUSB1.12 57.4,119.66 ; JUSB1.12 57.4,118.25 ; JUSB1.12 58.35,116.84 ; JUSB1.12 58.35,119.66 ; JCRT1.10 266.25,116.28 ; JCRT1.10 265.22,117.32 ; JCRT1.10 265.22,116.28 ; JCRT1.10 266.25,117.32 ; JCRT1.10 265.74,116.14 ; SW1.4 229.21,71.88 ; SW1.4 229.21,73.4 ; SW1.4 228.45,73.65 ; SW1.4 228.45,71.64 ; SW1.4 227.69,71.88 ; SW1.4 229.45,72.64 ; SW1.4 227.44,72.64 ; SW1.4 227.69,73.4 ; 90.2,112.64 JHDMI1.11 ; JHDMI1.11 90.66,112.76 ; JHDMI1.11 89.73,112.76 ; JHDMI1.11 90.66,113.68 ; JHDMI1.11 90.2,113.8 ; JHDMI1.11 89.73,113.68 ; 96.07,112.32 JHDMI1.21 ; JHDMI1.21 96.95,110.57 ; JHDMI1.21 96.07,114.07 ; JHDMI1.21 97.82,110.57 ; JHDMI1.21 96.07,110.57 ; JHDMI1.21 97.82,112.32 ; H3.1 320.64,28.34 ; H3.1 317.47,27 ; H3.1 317.96,25.66 ; H3.1 321.13,27 ; H3.1 317.96,28.34 ; H3.1 319.3,25.17 ; H3.1 320.64,25.66 ; H3.1 319.3,28.83 ; H11.1 120.04,47.52 ; H11.1 117.7,49.86 ; H11.1 119.4,45.82 ; H11.1 117.7,45.18 ; H11.1 116,49.22 ; H11.1 116,45.82 ; H11.1 115.36,47.52 ; H11.1 119.4,49.22 ; 80.45,117.72 JHDMI1.22 ; JHDMI1.22 81.53,117.72 ; JHDMI1.22 80.45,120.88 ; JHDMI1.22 81.53,119.3 ; JHDMI1.22 79.37,120.88 ; JHDMI1.22 79.37,119.3 ; JHDMI1.22 81.53,120.88 ; JHDMI1.22 79.37,117.72 ; 16.98,79.28 H24.1 ; H24.1 18.5,78.72 ; H24.1 20.02,82.32 ; H24.1 20.58,80.8 ; H24.1 20.02,79.28 ; JDOCK1.162 158.65,111.25 ; JDOCK1.162 159.7,110.27 ; JDOCK1.162 157.6,109.3 ; JDOCK1.162 158.65,109.3 ; JDOCK1.162 159.7,109.3 ; JDOCK1.162 159.7,111.25 ; JDOCK1.162 157.6,111.25 ; JDOCK1.162 157.6,110.27 ; JUSB2.7 234.34,110.52 ; JUSB2.7 233.03,109.95 ; JUSB2.7 234.17,111.09 ; JUSB2.7 233.6,109.78 ; JUSB2.7 233.03,111.09 ; JUSB2.7 234.17,109.95 ; JUSB2.7 232.86,110.52 ; 92.73,113.68 JHDMI1.17 ; JHDMI1.17 93.66,113.68 ; JHDMI1.17 93.2,112.64 ; JHDMI1.17 93.2,113.8 ; JHDMI1.17 92.73,112.76 ; JHDMI1.17 93.66,112.76 ; 305.58,113.75 JLOM1.14 ; JLOM1.14 305.58,117.25 ; JLOM1.14 306.49,113.75 ; JLOM1.14 306.49,117.25 ; JLOM1.14 306.49,115.5 ; 224.8,119.66 JUSB2.12 ; JUSB2.12 224.8,118.25 ; JUSB2.12 224.8,116.84 ; JUSB2.12 225.75,116.84 ; JUSB2.12 225.75,119.66
  BOTTOM w0.102: v4(27.56,79.86) v1(27.56,80.58) ; v4(122.72,61.28) 122.73,61.29 v1(122.73,61.89) ; v4(222.54,85.03) 222.61,85.03 v1(223.09,84.55) ; v4(55.41,102.3) 55.41,101.67 v1(55.4,101.65) ; v1(82.08,94.77) 82.3,94.55 v4(82.72,94.55) ; v3(223.43,61.79) v4(223.43,61.15) ; v4(224.45,67.76) 223.84,67.76 v3(223.81,67.78) ; v3(216.19,42.87) v4(216.19,42.23)
  BOTTOM w0.127: v1(215.37,93.98) 216.41,93.98 v4(216.62,94.2) ; v4(35,101.23) v1(35,100.62) ; v1(170.89,94.45) v4(171.41,93.93)
  BOTTOM w0.152: UC1.AY18 158.45,47.08 v1(158.38,47.01) ; UC1.AY26 153.32,46.9 v1(153.14,46.73) ; UC1.AY53 136.65,46.92 v1(136.43,46.7) ; v1(129.49,54.13) 129.64,54.28 UC1.AJ63 ; UC1.AY57 134.22,47.02 v1(134.2,47) ; v1(150.8,46.94) 150.88,47.03 UC1.AY30 ; UC1.AY22 156.02,47.08 v1(156.12,46.98) ; UC1.AG62 UC1.AG61
  BOTTOM w0.178: UC1.AG62 UC1.AG63 129.73,55.63 v1(129.65,55.55) ; v1(152.83,70.99) 152.45,70.61 UC1.A28 ; UC1.AN63 130.68,51.85 129.51,51.85 v1(129.31,51.65)
  BOTTOM w0.203: UV7.52 145.63,95.45 v1(145.67,95.48) ; v1(169.93,48.77) 169.93,48.87 169.22,49.58 UC1.AU1 ; v1(138.34,46.31) 138.06,46.59 138.06,47.87 UC1.AY51 ; v1(129.02,68.8) 129.16,68.66 129.58,68.66 129.98,68.26 UC1.D63 130.41,68.2 UC1.D62 ; v1(133.46,65.94) 133.65,66.13 UC1.H57 133.78,66.28 133.78,66.69 133.61,66.87 UC1.F58 133.61,67.49 133.33,67.76 133.33,67.76 133.08,68 UC1.D59 ; UC1.G3 167.32,65.69 167.32,65.69 v1(167.27,65.64) 167.26,65.62 166.95,65.62 166.38,66.2 UC1.G5 ; PU500.29 104.41,67.62 104.6,67.43 v3(104.6,66.72) ; v1(140.28,93.26) 140.28,92.7 140.05,92.46 UV7.11 ; UV7.19 136.85,90.89 136.53,90.57 v1(136.51,90.57) ; v1(159.83,47.07) 159.83,47.9 UC1.AY16 159.76,47.97 UC1.AW16 UC1.AV16 ; v1(129.61,59.21) 129.67,59.25 130.3,59.25 UC1.Y63
  BOTTOM w0.254: JEDP1.39 82.39,101.85 v1(82.99,102.45) ; UC1.F20 157.81,66.98 157.48,67.31 v1(157.39,67.31) ; v1(168,50.65) 168,50.78 167.71,51.06 UC1.AP3 ; v1(162.69,46.7) 162.61,46.78 UC1.AY11 ; v1(146.18,66.53) 146.18,66.53 UC1.F38 UC1.D38 ; UC1.V7 165.05,60.25 165.29,60.49 v1(165.29,60.53) ; UC1.H13 161.4,65.66 v1(161.09,65.97) ; UC1.AV8 164.09,48.91 163.79,48.6 v1(163.73,48.6) ; JDOCK1.58 160.9,119.24 v1(160.57,119.57) ; v1(132.69,65.69) 132.96,65.42 UC1.J59 ; v1(164.74,57.81) 164.74,57.88 UC1.AB7 ; UC1.AG1 169.41,55.52 v1(169.63,55.3) ; v1(166.56,69.62) 166.59,69.58 UC1.B4 ; UI5.6 164.36,103.15 v1(164.68,102.83) ; UC1.T58 133.24,61.88 133.24,61.99 UC1.P59 132.96,62.38 v1(132.66,62.68) ; JDOCK1.26 151.9,116.83 152.44,116.3 152.44,115.99 v1(152.53,115.9) ; UC1.A56 134.84,69.97 134.84,70.89 v1(134.68,71.05) ; v1(167.86,119.55) 167.89,119.55 168.4,119.04 JDOCK1.88 ; UC1.AB22 156.47,58.24 156.86,58.24 ; UC1.AD21 157.3,57.17 156.83,57.64 156.83,58.22 156.86,58.24 ; UC1.AP10 163.33,51.58 163.61,51.87 v1(163.77,51.87) ; v1(169.75,61.67) 169.59,61.51 UC1.T1 ; v1(160.79,70.83) 160.79,70.79 160.95,70.63 UC1.A14 ; v1(166.69,107.18) 166.9,107.39 JDOCK1.81 ; UC1.B26 153.38,68.93 UC1.C27 152.9,68.93 v1(152.65,68.68) ; 156.86,58.24 v1(156.9,58.28) ; UC1.AN7 165.25,52.17 165.54,52.46 v1(165.66,52.46) ; UC1.AE58 134.21,56.3 v1(134.25,56.27) ; v1(160.74,48.57) 161.08,48.91 UC1.AV14 ; v1(165.52,119.45) 165.4,119.33 JDOCK1.76 ; v1(169.51,64.77) 169.4,64.77 169.14,64.51 UC1.K1 ; UC1.AW37 146.65,48.26 v1(146.99,48.59) 147.3,48.91 UC1.AV36 ; JDOCK1.75 165.4,111.45 v1(165.44,111.5) ; UC1.D26 UC1.F26 v1(153.71,66.51) ; v1(174.92,119.83) 174.92,119.53 174.4,119.01 JDOCK1.108 ; v1(157.44,119.98) 157.53,119.98 157.9,119.61 JDOCK1.50 ; UC1.E17 160.09,67.62 160.15,67.55 v1(160.19,67.55) ; UC1.AL57 134.34,53.32 v1(134.08,53.06) ; 178.23,111.84 177.61,111.84 177.4,111.63 JDOCK1.119 ; 178.23,111.84 178.4,111.67 JDOCK1.123 ; 178.23,111.84 v1(178.23,111.79) ; UC1.A11 162.62,70.79 v1(162.65,70.82) ; v1(150.28,120.67) 150.4,120.54 JDOCK1.20 ; v1(153.11,52.97) 153.46,53.32 UC1.AL26 ; v1(131.36,64.18) 131.66,63.88 UC1.L61 ; UC1.U61 131.66,60.88 v1(131.36,61.18) ; v1(162.4,119.5) JDOCK1.64 ; v1(156.27,67.91) 156.2,67.91 ; 156.2,67.91 156.3,67.81 UC1.D21 ; 156.2,67.91 156.15,67.91 156.15,67.91 UC1.D23 155.46,68.45 v1(155.16,68.75) 154.96,68.95 UC1.B24 ; UC1.L7 165.05,63.96 165.33,64.24 v1(165.33,64.35) ; JDOCK1.43 v1(156.4,111.57) ; v1(134.15,60.2) 134.15,60.21 UC1.V58 ; JDOCK1.37 154.9,111.33 v1(155.33,111.76) ; v1(139.89,70.54) 139.92,70.52 UC1.A48 139.92,69.8 ; v1(136.15,66.51) UC1.F54 UC1.D54 ; v1(168.03,68.53) 168.03,68.52 168.33,68.22 UC1.D2 ; JDOCK1.57 160.9,111.29 160.67,111.52 160.24,111.52 v1(160.17,111.46) 160.27,111.36 160.27,111.28 160.4,111.15 JDOCK1.55 ; JSATA1.12 v1(308.5,42.01) ; v1(172.47,111.75) 172.47,111.74 172.9,111.3 JDOCK1.101 ; UC1.AL46 141.38,53.32 v1(141.64,53.05) 141.91,53.32 UC1.AL45 ; v1(182.92,112.46) 182.92,112.21 181.9,111.19 JDOCK1.137 ; UC1.B24 UC1.A24 ; UC1.B24 154.64,68.93 UC1.C25 UC1.D25 ; UC1.AA58 134.15,58.9 v1(134.16,58.91) ; JDOCK1.120 177.4,119.1 177.85,119.55 178.6,119.55 v1(178.99,119.94) ; v1(161.1,67.99) 161.46,68.35 UC1.D14 161.06,68.86 UC1.C14 ; UC1.B60 132.32,69.28 132.5,69.1 132.5,68.99 v1(132.52,68.96) ; UC1.AP20 158.12,51.37 v1(157.79,51.04) ; JDOCK1.82 v1(166.9,119.49) ; JDOCK1.1 v1(145.9,111.85) ; RPC20.6 167.68,79.14 v1(167.96,79.42) 168.18,79.19 RPC20.7 ; v1(134.08,51.04) 134.4,51.37 UC1.AP57 ; UC1.A28 UC1.B28 ; v1(166,67.95) 166,68.07 166.31,68.38 UC1.D5 ; v1(129.77,61.94) 130.13,62.3 UC1.P63 130.43,62.23 130.93,62.23 UC1.P62 ; UC1.AP26 153.46,51.37 v1(153.14,51.04) ; v1(165.06,107.22) 165.06,104.64 164.88,104.46 UI5.5 ; v1(180.75,119.74) 180.57,119.74 180.4,119.57 JDOCK1.132 ; UC1.D46 UC1.F46 v1(141.17,66.52) ; UC1.AW42 143.48,48.26 v1(143.84,48.62) 144.13,48.91 UC1.AV41 ; UC1.D27 153.05,68.28 v1(152.65,68.68) ; UC1.G8 164.85,66.69 v1(164.98,66.69) 165.05,66.69 UC1.G6 ; UC1.E11 162.57,67.66 162.89,67.97 v1(162.97,67.97) 162.98,67.97 162.98,68.05 162.58,68.45 UC1.D12 162.63,68.83 UC1.C11 ; JDOCK1.49 157.9,111.19 v1(157.65,111.45) 157.65,111.44 157.4,111.19 JDOCK1.47 ; v1(162,63.74) 161.97,63.74 UC1.L13 162.06,64.53 UC1.K12 ; v1(151.2,66.53) UC1.F30 UC1.D30 ; JDOCK1.102 172.9,119.42 172.54,119.78 v1(172.03,119.78) ; JDOCK1.126 178.9,119.02 179.5,119.62 v1(179.6,119.62) ; JDOCK1.87 v1(168.4,111.57) ; UC1.G3 167.68,65.95 167.97,65.66 167.97,65.64 v1(167.98,65.62) ; v1(175.79,107.22) 175.9,107.32 JDOCK1.113 ; v1(154.37,120.63) 154.37,120.35 153.4,119.38 JDOCK1.32 ; v1(163.61,111.46) 163.66,111.46 163.9,111.22 JDOCK1.69 ; JDOCK1.70 163.9,119.18 163.68,119.4 163.68,119.42 163.54,119.56 v1(163.45,119.56) ; UC1.D42 UC1.F42 v1(143.68,66.53) ; JDOCK1.95 171.4,111.14 171.16,111.38 v1(171.16,111.55) ; UC1.A18 158.22,70.39 158.22,71.15 v1(158.19,71.17) ; v1(171.27,116.21) 171.4,116.34 JDOCK1.96 ; 82.66,69.03 82.66,69.66 83.17,70.17 83.17,72.96 v3(85.51,75.3) 87.15,76.94 PC704.2 ; JDOCK1.107 174.4,111.7 174.22,111.88 174.22,111.89 v1(174.17,111.94) ; UC1.AL10 163.33,53.39 163.77,52.95 v1(163.79,52.95) ; v1(131.36,58.18) 131.66,57.88 UC1.AC61 ; UC1.A52 137.34,69.98 137.34,70.54 137.17,70.7 v1(137.17,70.81) ; JDOCK1.91 169.4,111.44 169.51,111.55 v1(169.67,111.55) ; UC1.AY6 165.61,47.16 v1(165.74,47.03) ; JDOCK1.8 147.4,119.44 v1(146.27,120.58) ; UC1.F50 v1(138.66,66.55) ; v1(167.98,53.65) 167.68,53.94 UC1.AK3 ; UC1.L58 v1(134.37,64.11) ; UC1.H17 159.65,65.66 159.27,66.04 159.27,66.03 v1(159.27,66.03) ; JSATA1.7 v1(306,40.1) ; UC1.D29 152.16,68.68 v1(152.65,68.68) ; v1(169.46,52.55) 169.44,52.52 UC1.AM1 ; v1(167.34,59.65) 167.68,60 UC1.V3 ; JDOCK1.19 v1(150.4,108.91) ; v1(156.8,64.46) 156.42,64.84 UC1.J22 ; UC1.AD3 167.68,57.01 167.88,56.81 167.88,56.71 v1(167.93,56.66) ; UC1.AD63 129.94,57.06 v1(129.8,57.19) ; JDOCK1.31 v1(153.4,108.91) ; UC1.AR5 166.18,50.86 166.52,50.52 v1(166.55,50.52) ; v1(163.08,65.37) 163.44,65.01 UC1.J10 ; UC1.J63 129.9,65.3 v1(129.78,65.42) ; v1(156.82,66.73) 156.82,66.72 156.57,66.47 UC1.G22 ; UC1.F61 131.95,67.06 v1(131.95,67.19) ; UC1.AJ35 v1(147.91,55.18) ; UC1.N3 167.97,62.77 v1(167.97,62.68) ; UC1.G18 158.67,66.32 v1(158.35,65.99) ; UC1.D34 UC1.F34 v1(148.69,66.56) ; v1(166.69,56.69) 166.69,56.61 166.36,56.28 UC1.AE5 ; UC1.AW4 167.06,48.22 UC1.AY4 167.06,47.36 167.53,46.89 v1(167.67,46.89) ; UC1.AA1 v1(169.52,58.52) ; JDOCK1.38 154.9,117.24 155.23,116.91 v1(155.37,116.91) ; v1(132.9,47.05) 132.9,47.05 UC1.AY59 ; v1(181.72,119.69) 181.9,119.51 JDOCK1.138 ; v1(175.9,119.48) JDOCK1.114 ; JDOCK1.7 147.4,108.82 147.36,108.78 v1(147.36,108.87) ; UC1.B20 157.47,69.25 UC1.C20 157.53,68.98 v1(157.99,68.98) 158.42,68.98 UC1.C18 158.88,68.63 UC1.D18 ; JDOCK1.13 v1(148.9,108.8) ; JEDP1.15 94.39,101.86 94.4,101.87 ; JSATA1.14 v1(309.5,42.03) ; JSATA1.4 v1(304.5,40.09) ; JSATA1.18 v1(311.5,42.1) ; JDOCK1.25 v1(151.9,108.94) ; JDOCK1.125 178.9,111.3 179.04,111.45 180,111.45 180.4,111.04 JDOCK1.131 v1(180.4,108.72) ; v1(163.98,67.93) 164.13,67.93 164.65,68.45 UC1.D8 ; JDOCK1.44 156.4,117.01 v1(156.5,116.91) ; JDOCK1.61 161.9,111.45 v1(161.96,111.51) 162.4,111.07 JDOCK1.63 ; JSATA1.1 v1(303,42.03) ; UC1.D37 146.77,68.28 ; v1(132.66,59.68) 132.96,59.38 UC1.Y59 ; v1(146.94,53.08) 147.18,53.32 UC1.AL36 ; JDOCK1.14 148.9,120.04 v1(148.26,120.68)
  BOTTOM w0.305: JNGFF1.49 283.85,39.95 283.97,39.83 285.27,39.83 285.36,39.92 285.36,40.88 JNGFF1.55 285.35,42.01 v1(285.57,42.23) ; v1(270.04,42.24) 269.85,42.05 JNGFF1.1 ; v1(180.92,7.22) 181.76,8.06 181.76,9.85 181.16,10.45 JDIMM2.55 ; v1(293.46,84.65) 293.41,84.6 ; 293.41,84.6 292.91,84.1 JNGFF2.3 ; 293.41,84.6 JNGFF2.5 ; v1(282.46,42.98) 282.35,42.87 JNGFF1.43 282.35,39.83 282.05,39.54 281.06,39.54 280.85,39.75 JNGFF1.37 ; v1(290.41,91.75) 290.82,91.75 290.97,91.6 JNGFF2.25 ; JNGFF2.37 290.66,94.6 v1(290.47,94.78) ; v1(92.74,8.75) 92.74,8.76 91.96,9.54 ; v1(91.09,7.6) 91.1,7.6 91.37,7.87 ; JNGFF2.63 291.18,101.1 v1(290.93,101.35) 291.18,101.6 JNGFF2.65 ; JDIMM1.61 106.96,10.32 107.38,9.9 107.38,9.29 v1(106.84,8.75) ; JDIMM2.173 218.96,12.77 v1(219.11,12.92) ; v1(224.08,1.68) 224.06,1.71 JDIMM2.190 ; JDIMM1.19 94.36,9.68 ; 94.36,9.68 94.36,9.67 ; 94.36,9.68 95.28,8.76 v1(95.28,8.75) ; JNGFF2.19 291.16,90.1 290.99,89.93 v1(290.36,89.93) ; v1(278.57,43.37) 277.85,42.65 JNGFF1.25 277.85,39.91 278.12,39.64 279.13,39.64 279.35,39.86 JNGFF1.31 ; v1(108.13,7.67) 107.86,7.94 107.86,9.88 108.16,10.18 JDIMM1.65 ; v1(220.49,1.68) 220.46,1.71 JDIMM2.178 ; v1(268.9,36.62) 269.13,36.85 JLPDE1.9 ; JDIMM1.3 89.56,10.41 ; JNGFF2.49 290.9,97.6 v1(290.63,97.87) ; 97.96,9.96 97.13,9.13 v1(97.13,9.13) ; 97.96,9.96 JDIMM1.31 ; 97.96,9.96 97.96,9.96 ; JNGFF1.10 274.1,49.55 v1(274.14,49.6) ; JDIMM2.127 205.16,12.47 v1(204.81,12.82) ; JNGFF1.7 v1(271.35,39.66) ; v1(277.19,49.61) 277.1,49.52 JNGFF1.22 ; JNGFF2.31 290.48,93.1 v1(290.4,93.02) ; JNGFF1.67 288.35,42.45 ; JDIMM2.25 172.16,9.49 v1(171.41,8.75) ; v1(89.67,8.75) 89.03,9.38 89.03,9.88 89.56,10.4 ; JNGFF2.43 290.67,96.1 v1(290.42,95.85) ; JDIMM1.11 91.96,9.54 ; 91.96,9.54 91.96,9.53 ; JAPS1.8 229.69,79.52 229.97,79.8 230.47,79.8 230.71,79.56 230.71,78.96 JAPS1.10 v1(230.69,78.12) ; JNGFF1.16 v1(275.6,49.57) ; v1(231.76,78.12) 231.69,78.19 JAPS1.12 231.69,79.59 231.92,79.82 232.48,79.82 232.69,79.6 JAPS1.14 ; JNGFF1.28 278.6,47.69 278.26,47.35 277.22,47.35 v1(277.16,47.3) ; v1(217.21,12.83) 217.16,12.78 JDIMM2.167 ; JDEG1.10 v1(279.52,36.83) ; JNGFF1.15 275.35,42.1 274.99,42.46 v1(274.99,42.74) ; JDIMM2.168 217.46,2.05 v1(217.8,1.71) ; JNGFF2.11 v1(290.56,86.1) ; JDIMM2.19 170.36,12.51 170.61,12.77 v1(171.61,12.77) ; JNGFF1.21 v1(276.85,42.4) ; v1(218.88,4.99) 218.66,4.77 JDIMM2.172 ; JNGFF1.61 v1(286.85,42.17) ; JDIMM1.9 91.36,7.87
  BOTTOM w0.33: JDIMM2.156 213.86,1.73 v1(213.89,1.71) ; v1(215.68,1.71) 215.66,1.73 JDIMM2.162
  BOTTOM w0.356: v1(139.69,1.74) 139.66,1.77 JDIMM1.162 ; JDIMM2.38 176.06,4.42 v1(177.33,5.7) ; JDIMM1.66 108.46,1.67 v1(108.49,1.64) ; v1(135.48,12.72) 134.81,12.72 134.56,12.47 JDIMM1.145 ; v1(148.18,12.82) 147.76,12.4 JDIMM1.189 ; PU804.3 67.49,76.85 v3(67.48,76.84) ; JDIMM2.28 173.06,5.11 v1(173.25,5.3) ; v1(219.44,15.97) 219.44,15.95 219.11,15.62 219.11,14.4 220.76,12.76 JDIMM2.179 ; JDIMM1.49 103.36,9.89 ; JDIMM2.46 178.46,4.59 v1(178.8,4.93) ; JDIMM2.26 172.46,6.04 v1(173.26,6.84) ; v1(205.87,1.7) 205.87,1.73 205.46,2.14 ; JDIMM1.72 110.26,1.69 v1(110.28,1.66) ; v1(182.68,1.73) 182.66,1.76 JDIMM2.60 ; JDIMM2.14 168.86,1.94 v1(168.68,1.77) ; v1(212.22,1.68) 212.06,1.84 JDIMM2.150 ; JDIMM1.178 144.46,1.77 v1(144.49,1.74) ; v1(217.62,5.52) 218.19,4.95 218.19,4.49 218.06,4.36 JDIMM2.170 ; JDIMM1.196 149.86,1.97 v1(149.65,1.76) ; v1(102.17,6.84) 101.96,6.64 101.96,4.68 102.46,4.18 JDIMM1.46 ; 205.46,2.14 JDIMM2.128 ; 205.46,2.14 205.46,2.11 ; v1(174.79,7.22) 175.09,7.22 175.76,7.89 JDIMM2.37 ; JDIMM1.133 130.96,12.52 v1(131.18,12.74) ; v1(214.02,12.76) 213.08,12.76 212.96,12.63 JDIMM2.153 ; JDIMM2.196 225.86,1.73 v1(225.89,1.71) ; JDIMM2.32 174.26,1.69 v1(174.29,1.67) ; JDIMM2.161 215.36,12.46 214.99,12.82 v1(214.9,12.82) ; JDIMM1.155 137.56,9.46 v1(136.92,8.82) ; JDIMM2.61 182.96,12.37 v1(183.35,12.76) ; JDIMM2.48 179.06,4.48 179.49,4.9 179.49,6.12 v1(178.77,6.84) ; v3(61.76,77.92) 61.77,77.9 PQ806.4 ; v1(223.36,12.75) 223.16,12.55 JDIMM2.187 ; v1(97.12,4.99) 96.46,4.33 JDIMM1.26 ; JDIMM1.20 94.66,1.76 ; v1(210.56,1.71) 210.26,2.01 JDIMM2.144 ; JDIMM1.55 105.16,9.35 v1(104.55,8.75) ; v1(138.18,12.69) 139.15,12.69 139.36,12.48 JDIMM1.161 ; JDIMM1.187 147.16,10.35 147.54,9.97 147.54,9.38 v1(146.98,8.82) ; JDIMM1.48 103.06,4.54 v1(102.67,4.93) ; JDIMM1.136 131.86,4.38 132.25,4.77 132.25,5.22 v1(131.69,5.77) ; v1(184.49,1.64) 184.46,1.67 JDIMM2.66 ; v1(137.88,1.74) 137.86,1.77 JDIMM1.156 ; JDIMM1.138 132.46,4.14 132.75,4.43 132.75,6.57 v1(133.1,6.92) ; JDIMM1.25 96.16,12.52 95.92,12.75 v1(95.54,12.75) ; v1(141.55,12.67) 141.16,12.28 JDIMM1.167 ; JDIMM1.60 106.66,1.6 v1(106.69,1.58) ; v3(91.41,67.57) 91.37,67.52 PQ813.4 ; JDIMM1.190 148.06,1.77 v1(148.09,1.74) ; v1(168.14,12.76) 167.96,12.58 JDIMM2.11 ; JDIMM1.2 89.26,1.76 ; v1(208.86,9) 208.76,9.1 JDIMM2.139 ; v1(184.24,7.67) 184.16,7.75 JDIMM2.65 ; v1(136.81,12.82) 136.96,12.67 JDIMM1.153 ; JDIMM2.185 222.56,12.35 v1(222.16,12.76) ; JDIMM2.8 167.06,1.82 v1(166.97,1.73) ; v1(150.09,12.7) 149.95,12.7 149.56,12.31 JDIMM1.195 ; v3(87.39,66.31) 87.48,66.22 PQ813.1 ; v1(180.88,1.64) 180.86,1.67 JDIMM2.54 ; v1(214.29,7.68) 213.7,8.27 213.7,10.01 213.56,10.15 JDIMM2.155 ; v1(214.02,13.34) 212.6,13.34 212.36,13.1 JDIMM2.151 ; PQ806.1 65.68,79.2 v3(65.7,79.19) ; v1(222.29,1.68) 222.26,1.71 JDIMM2.184 ; v1(142.69,1.71) 142.66,1.73 JDIMM1.172 ; v1(133.1,9.2) 132.98,9.32 132.98,9.98 132.76,10.21 JDIMM1.139 ; v1(186.28,1.72) 186.26,1.74 JDIMM2.72 ; v1(141.8,1.77) 141.8,1.77 141.46,2.12 JDIMM1.168 ; JDIMM2.63 183.56,9.34 v1(182.97,8.75) ; JDIMM1.150 136.06,1.93 v1(135.84,1.71) ; v1(170.4,1.77) 170.66,2.03 JDIMM2.20 ; JDIMM2.44 177.86,1.73 v1(177.88,1.71) ; JDIMM1.144 134.26,2.08 v1(134.67,1.67) ; 99.75,12.56 99.42,12.89 98.76,12.89 ; v1(102.17,9.13) 102.36,9.32 102.78,9.32 103.35,9.89 ; JDIMM1.185 146.56,13.11 v1(146.76,13.31) ; JDIMM2.195 225.56,13.11 ; v1(165.29,1.73) 165.26,1.75 JDIMM2.2 ; v1(208.32,13.12) 207.38,13.12 206.96,12.7 JDIMM2.133 ; JDIMM1.8 91.06,1.76 ; JDIMM1.151 136.36,12.29 136.1,12.55 136.1,13.17 136,13.26 135.53,13.26 v1(135.47,13.33) ; JDIMM2.31 173.96,12.56 v1(174.14,12.74) ; JDIMM1.38 100.06,5.07 v1(100.69,5.7) ; v1(144.95,12.7) 144.76,12.51 JDIMM1.179 ; JDIMM2.13 168.56,10.38 168.07,9.9 168.07,9.55 v1(168.87,8.75) ; v1(101.18,1.62) 101.47,1.62 101.86,2 JDIMM1.44 ; v1(107.32,12.69) 107.56,12.45 JDIMM1.63 ; v1(101.26,12.79) 101.56,12.49 JDIMM1.43 ; JDIMM2.9 167.36,9.27 v1(167.22,9.13) ; JDIMM2.145 210.56,12.61 210.88,12.93 v1(211.39,12.93) ; v1(165.42,12.75) 165.56,12.61 JDIMM2.3 ; v1(146.28,1.74) 146.26,1.77 JDIMM1.184 ; JDIMM1.71 109.96,9.29 v1(109.42,8.75) ; v1(143.2,6.84) 142.46,6.1 142.46,4.73 142.06,4.33 JDIMM1.170 ; JDIMM1.13 92.56,12.78 ; v1(185.59,8.75) 186.13,9.29 186.13,9.79 185.96,9.97 JDIMM2.71 ; JDIMM2.43 177.56,12.43 v1(177.23,12.77) ; v1(104.55,5.7) 105.18,5.07 105.18,4.51 104.86,4.19 JDIMM1.54 ; v1(178.77,9.13) 179.36,9.72 JDIMM2.49 ; JDIMM1.14 92.86,1.76 ; JDIMM1.37 99.76,12.56 ; v1(223.19,8.82) 223.76,9.4 JDIMM2.189
  BOTTOM w0.381: CV88.2 160.85,94 160.68,94.16 v1(160.43,94.16) ; v1(88.11,72.96) 88.52,73.37 PQ817.1 ; v1(166.43,90.76) 166.43,91.33 CV97.2 ; UV12.7 175.11,103.62 175.36,103.37 v1(175.36,102.76) ; v1(311.09,82.11) 310.83,81.85 DI4.3 ; CV84.2 159.74,94.12 v1(159.78,94.16) ; CV98.2 164.43,92.75 v1(164.32,92.86) ; CC101.2 159.77,41.64 v1(159.77,42.14) ; PQ817.4 v1(91.31,74.67) ; PU806.3 v1(91.34,70.76) ; v1(35.45,96.33) 35.23,96.12 35.23,95.95 34.76,95.48 QA3.1 ; v1(36.23,97.83) 36.23,97.35 36.46,97.12 QA3.4 ; v1(185.27,103.74) 185.39,103.62 UV11.7 ; UI2.1 248.46,117.2 v1(249.02,117.76) ; v1(165.24,90.46) 164.13,91.57 CV92.2
  BOTTOM w0.406: PU1.2 v1(41.25,83.12) ; v1(221.31,104.14) 221.53,104.36 DI6.3
  BOTTOM w0.508: v1(139.32,85.45) 137.03,85.45 QV11.3 ; v1(27.91,94.8) 28,94.71 CA50.2 ; v1(197.6,103.74) 197.03,104.31 QV9.3 ; CL10.2 276.86,85.93 v1(277.74,85.93) ; CZ20.2 286.55,52.34 v1(286.55,52.9) ; v1(294.31,34.13) 294.12,34.32 CN13.2 CN14.2 ; v3(106.64,63.87) 106.46,64.05 PC510.1 ; v1(156.58,90.46) 156.53,90.52 CV91.2 ; v1(201.01,89.16) JSPI1.22 ; v3(100.32,62.7) 100.57,62.96 PC815.2 ; v3(50.77,83.57) 50.76,83.58 PR12.1 ; CL11.2 277.66,85.02 v1(277.75,85.11) ; CI3.2 66.36,102.48 v1(66.8,102.92) ; v1(281.44,82.73) 281.01,83.16 CZ55.2 CZ52.2 ; DV4.1 v1(101.19,98.8) ; JNGFF2.69 289.93,103.2 289.47,102.75 v1(289.47,102.05) ; CMOS1.1 228.97,77.05 v1(228.89,77.13) ; v1(161.72,96.76) 161.17,96.76 CV86.2 161.07,97.4 161.08,97.41 161.08,97.63 160.57,98.14 CV85.2 ; v1(315.4,74.09) 315.92,73.58 JSD1.26 ; JSD1.6 298.95,55 v1(299.09,55.13) ; v1(194.48,58.24) 193.92,58.8 CC6.2 ; v1(293.28,59.35) 293.28,59.04 293.66,58.66 CN24.2 ; CC5.2 167.69,42.12 v1(167.22,42.59) ; CC1.1 184.24,44.57 v1(183.78,45.02) ; v1(29.44,97.49) 28.92,98.01 PJP6.2 ; RV509.1 170.78,98.2 v1(171.04,97.93) ; v1(167.72,108.93) 167.93,108.71 C43.2 C42.2 ; 18.49,83.21 18.52,83.24 DA3.1 18.52,86.05 v3(18.3,86.26) ; 18.49,83.21 19.88,83.21 v1(20.83,82.26) ; 18.49,83.21 17.4,83.21 17.16,82.98 CA13.1 ; CV60.2 v1(136.18,87.63) ; RC21.2 v1(116.04,53.41) ; PC813.2 v3(99.35,62.68) ; v1(243.6,119.75) 243.81,119.53 CI10.2 ; CA12.2 8.85,96.26 v1(8.55,96.56) ; v1(235.92,83.48) 236.04,83.35 236.04,83.34 236.79,82.59 JAPS1.20 ; CC82.2 159.54,81.31 v1(158.81,81.31) ; v1(190.98,70.51) 191.45,70.04 CC7.2 ; v1(149.95,74.56) 148.93,75.58 RC241.2 RC240.2 ; PC22.2 v1(54.98,93.08) ; PR513.2 v3(98.72,72.2) ; CV89.2 163.33,94.81 163.02,95.12 v1(163.02,95.46) ; PC805.1 69.62,81.93 v3(69.63,81.92) ; v1(152.69,75.76) 152.69,76.37 152.82,76.49 CC67.2 ; RC131.2 RC130.2 RC132.2 126.68,39.89 125.77,39.89 125.77,39.92 v1(125.78,39.92) ; C319.2 176.57,106.44 v1(175.79,107.22) ; CZ2.2 102.68,97.26 v1(102.6,97.18) ; PR403.2 233.07,49.9 v3(233.46,50.29) ; v1(196.46,98.9) 196.46,99.01 196.58,99.14 CV118.2 ; PR401.2 v3(231.43,61.66) ; JSD1.21 297.49,59.03 v1(298.45,59.03) ; PC402.2 v3(232.45,61.66) ; JSD1.25 318.55,46.2 318.55,46.2 v1(318.99,46.64) ; JNGFF1.69 289.14,41.66 v1(288.34,42.46) ; v1(232.91,76.11) 232.63,76.39 CC4.1 ; CV114.2 152.95,91.23 153.85,90.32 v1(153.85,90.29) ; CA6.2 98.65,96.79 98.72,96.73 v1(98.72,96.61) ; v1(142.56,100.31) 142.56,100.07 142.19,99.7 RV67.1 ; CZ17.1 CZ18.1 v1(288.84,52.81) ; CD62.2 237.9,12.96 v1(238,13.06) ; v3(106.08,75.5) 106.08,76.08 PC500.1 ; v3(17.49,93.94) 18.25,93.18 DA1.1 ; v1(197.14,61.67) 197.94,62.47 UC3.4 ; v1(170.47,39.42) 170.47,39.99 CC3.1 ; PC214.2 PR209.2 261.65,43.45 261.91,43.18 v3(261.91,42.87) ; PC511.2 v3(99.86,66.74) ; JNGFF1.68 269.03,41.66 269.61,42.24 v1(270.04,42.24) ; v1(58.71,97.86) 59.14,98.29 PR15.2 ; RC183.2 v1(115.99,58.49) ; PC400.2 v3(230.42,61.66) ; v1(295.96,61.38) 296.68,62.1 JSD1.3 ; CD57.2 v1(237.02,8.85) ; CI420.2 190.84,94.36 v1(190.51,94.03) ; v1(279.6,87.9) 280.35,87.9 CL9.2 ; JFAN1.5 v1(86.82,49.88) ; v1(115.98,65.23) 117.23,65.23 117.51,64.95 RC218.2 ; v3(102.4,53.03) 102.15,52.77 PR858.2 ; JSD1.24 v1(304.45,72.48) ; v1(154.19,79.12) 154.84,79.12 CC11.1 ; PR874.2 108.74,55.72 109.94,56.92 v3(109.94,56.99) ; v1(150.9,93.33) 150.7,93.54 RV65.2 RV63.2 ; RA36.2 25.7,95.8 26.02,96.12 v1(26.02,96.22) ; PQ3.3 v3(51.49,82.59) ; RC187.2 RC178.2 162.04,39.91 162.31,39.64 v1(162.94,39.64) ; v3(109.36,58.28) 109.16,58.08 PC817.2 ; CL8.2 278.24,88.25 277.94,87.95 v1(277.72,87.95) ; v1(325.51,73.71) 325.13,74.1 JSD1.13 ; v1(146.19,87.95) 146.52,87.95 RV100.2 ; JSD1.17 320.85,45.46 v1(320.85,46.14) ; PR303.2 v3(212.51,44.77) ; v3(58.65,85.6) 58.65,85.6 PQ6.6 ; v1(220.84,48.07) 220.84,48.57 PC311.2 ; DA2.1 18.5,88.53 v3(18.29,88.32) ; JSD1.10 320.85,72.85 v1(320.85,72.85) ; RC185.2 v1(115.99,59.5) ; JAPS1.19 224.09,83.54 v1(223.09,84.55) ; CN15.2 v1(295.11,34.29) 295.14,34.27 295.71,34.27 296.09,34.65 CN16.2 ; v1(89.64,97.56) 89.73,97.47 RV2.2 ; PC21.2 v1(46.9,85.05) ; RC306.1 173.13,78.26 v1(173.55,78.68) ; PJPDC1.6 37.48,99.35 v1(38.61,100.47) ; v1(151.28,95.66) 151.19,95.57 RV64.2 RV62.2 ; RC139.1 RC181.2 170.98,78.39 170.37,79 170.37,79.06 v1(170.17,79.26) ; CA48.2 v1(30.84,90.93) ; PC309.2 v3(219.49,43.75) ; JSD1.22 v1(298.47,71.25) ; v1(302.79,84.57) 303.25,85.03 RZ33.2 ; RC186.1 160.82,78.73 159.92,79.63 v1(159.18,79.63) ; v1(200.47,52.43) 199.85,51.81 UC2.4 ; CV121.2 182.92,99.38 v1(183.54,98.76) 184.16,99.38 RV508.1 ; v1(218.4,106.58) 218.1,106.28 DI3.1 ; JLPDE1.12 v1(275.23,36.24) ; v1(304.6,44.19) 304.45,44.33 JSD1.23 ; PC310.2 v3(220.19,47.88) ; PC20.2 v1(55.75,98.28) ; PR308.2 v3(216.19,42.87) ; CV93.2 160.68,91.3 v1(160.43,91.56) ; v1(58.59,82.06) 58.37,82.27 PD5.1 ; v1(155.58,98.64) 155.74,98.81 UV9.4 ; RV50.2 134.15,87.62 v1(134.12,87.59) ; CA7.2 96.62,97.06 v1(97.13,96.55) 97.64,97.05 CA5.2 ; CC2.1 185.45,42.52 184.54,42.52 v1(184.24,42.83) ; v1(109.94,98.66) 109.38,99.22 QV7.3 ; CZ68.2 v1(236.12,15.66) ; CI11.2 v1(250.42,118.47) ; CA46.2 v1(30.71,90.15) ; v1(311.47,77.85) 310.53,77.85 310.34,78.04 DI5.1 ; v1(159.28,82.04) 160.43,83.19 CC81.2 ; R268.2 C310.2 156.5,106.37 154.85,108.02 v1(154.85,108.91) ; JNGFF2.68 291.22,82.49 291.22,82.2 v1(290.25,81.22) ; RC184.2 v1(116.01,57.47) ; v1(214.71,89.13) 214.71,89.05 214.71,89.04 JSPI1.21 ; CI12.2 v1(249.69,114.62) ; PC505.1 v3(98.46,67.63) ; v1(161.73,90.87) 161.48,90.62 159.75,90.62 CV99.2 159.27,90.59 159.22,90.64 CV95.2 158.43,90.64 CV100.2 ; v1(270.99,53.14) 270.99,53.06 270.71,52.78 270.71,52.77 270.29,52.35 CZ16.2 CZ15.2 ; v1(158.03,79.28) 157.72,78.97 CC8.1 ; PU400.1 v3(233.08,51.5) ; RV70.1 132.19,93.54 131.81,93.92 v1(131.81,94.1) ; v1(161.87,102.77) 161.66,102.99 CI38.2 ; RC128.1 v1(116,60.52) ; PC215.2 v3(263.94,36.01) ; v1(226.62,97.61) 226.15,97.15 JSIM1.7 224.04,97.15 223.51,97.68 C263.2 ; CA45.2 28.49,92.79 28.6,92.9 CA10.2 v1(27.85,93.61) 27.55,93.31 CA47.2 ; JDEG1.12 v1(285.17,34.65) ; JLPDE1.11 v1(267.49,34.49) ; JSATA1.22 v1(314.66,36.94) ; PC816.2 v3(109.39,59.12) ; PC209.1 v3(263.84,32.62) ; JFAN1.1 v1(87.11,54.37) ; CA11.2 28.35,95.65 v1(27.86,96.13) ; v1(106.95,50.25) 107.28,50.58 PR745.2 ; JEDP1.45 v1(79.49,100.57) ; v1(146.19,105.19) 146.19,104.31 RV68.1 ; v1(28.41,103.67) 28.13,103.67 27.66,103.2 RA35.2 ; JDEG1.11 v1(277.42,36.23) ; JSATA1.21 v1(313.55,42.21) ; v3(258.33,41.32) 258.43,41.42 PC212.2 ; PC211.2 v3(263.79,33.85) ; v1(27.1,96.15) 26.2,97.06 26.2,97.92 25.65,98.47 RA37.2 ; QV10.3 183.57,104.03 v1(183.88,103.71) ; JSD1.20 v1(298.67,47.7) ; PC507.1 v3(107.73,63.88) ; PC501.2 v3(107.23,76.65) ; v1(236,8.88) CD60.2
  vias: v1(5.6,97.32) v1(6.64,96.43) v1(9.36,100.09) v1(9.44,98.03) v1(9.92,102.45) v1(13.22,102.45) v1(16.83,102.45) v1(19.93,102.45) v1(21.12,77.31) v1(21.58,106.29) v1(24.27,102.45) v1(24.83,106.31) v1(25.41,94.82) v1(25.62,105.17) v1(26.68,93.51) v1(26.71,94.81) v1(27.17,106.26) v1(27.72,77.31) v1(28.33,104.54) v1(34.38,77.31) v1(34.56,104.49) v1(34.86,79.14) v1(35.06,94.64) v1(35.65,92.36) v1(39.23,106.37) v1(40.25,85.21) v1(40.84,85.21) v1(40.88,84.61) v1(41.14,84.08) v1(41.19,77.31) v1(41.45,85.21) v1(41.47,84.58) v1(41.78,84.08) v1(42.05,85.19) v1(42.08,84.61) v1(43.24,107) v1(47.13,109.74) v1(47.84,77.26) v1(50.25,113.81) v1(52.62,116.27) v1(53,113.6) v1(53.01,98.17) v1(54.46,105.78) v1(54.78,117.92) v1(55.03,112.72) v1(55.08,105.78) v1(55.26,5.3) v1(55.26,0.73) v1(55.56,119.62) v1(57.32,116.65) v1(57.32,113.99) v1(57.37,75.58) v1(57.42,121.22) v1(57.7,4) v1(57.82,1.84) v1(58.74,114.44) v1(59.6,5.27) v1(59.73,1.08) v1(60.59,110.91) v1(60.92,7.38) v1(61.38,1.97) v1(61.51,73.95) v1(61.51,4.13) v1(63.23,0.57) v1(63.82,101.58) v1(64.43,101.58) v1(65.01,101.55) v1(66.21,71.39) v1(68.67,69.61) v1(70.47,0.5) v1(70.57,68.09) v1(71.07,1.91) v1(71.89,14.82) v1(72.29,3.36) v1(72.33,1.18) v1(72.63,110.43) v1(73.33,2) v1(73.67,114.67) v1(74.26,64.25) v1(74.88,120.51) v1(75.18,1.25) v1(75.86,121.68) v1(76.54,20.41) v1(76.87,1.62) v1(77.43,59.78) v1(78.09,0.5) v1(78.98,1.45) v1(79.67,121.2) v1(80.73,28.79) v1(80.89,52.34) v1(81.45,117.21) v1(81.45,1.54) v1(82.33,46.4) v1(82.4,107.9) v1(82.61,37.38) v1(83.35,61.28) v1(83.48,59.38) v1(83.44,1.48) v1(83.73,114.09) v1(85.13,62.3) v1(85.13,58.49) v1(85.61,110.75) v1(85.71,0.5) v1(86.55,88.59) v1(86.58,87.92) v1(86.78,61.41) v1(86.78,59.5) v1(87.58,88.57) v1(87.59,87.91) v1(88.51,87.91) v1(89.12,30.52) v1(89.28,1.73) v1(89.67,7.22) v1(89.67,5.7) v1(90.35,99.41) v1(91.09,5.32) v1(91.08,1.73) v1(91.61,16.42) v1(92.39,102.21) v1(92.54,12.77) v1(92.74,7.22) v1(92.74,5.7) v1(92.89,1.73) v1(93.14,13.2) v1(93.33,0.5) v1(94.03,53.99) v1(94.69,1.73) v1(94.93,114.09) v1(95.28,7.22) v1(95.28,5.7) v1(97.13,6.84) v1(97.98,115.43) v1(98.16,121.1) v1(98.48,107.85) v1(98.48,107.27) v1(98.41,8.75) v1(98.41,7.22) v1(98.41,5.7) v1(98.75,12.9) v1(100.69,8.75) v1(100.69,7.22) v1(100.95,0.5) v1(101.46,121.68) v1(102.79,102.4) v1(104.55,7.22) v1(105.38,15.43) v1(105.7,116.53) v1(105.84,15.89) v1(106.21,114.37) v1(106.34,16.39) v1(106.79,36.64) v1(106.78,16.82) v1(106.84,7.22) v1(106.84,5.7) v1(107.48,117.92) v1(107.86,113.73) v1(108.13,5.39) v1(108.57,0.5) v1(109.39,116.91) v1(109.42,7.22) v1(109.42,5.7) v1(109.51,114.75) v1(112.19,4.87) v1(112.21,7.87) v1(112.21,6.35) v1(112.36,121.25) v1(112.81,113.78) v1(113.64,7.87) v1(113.64,6.35) v1(115.05,7.93) v1(115.05,6.41) v1(115.15,108.65) v1(116.19,0.5) v1(116.84,7.93) v1(116.84,6.41) v1(118.69,7.93) v1(118.69,6.41) v1(120.47,7.93) v1(120.47,6.41) v1(120.69,106.37) v1(121.16,8.69) v1(121.96,9.84) v1(121.96,7.55) v1(121.96,6.79) v1(122.85,5.64) v1(123.81,0.5) v1(124.25,7.93) v1(124.25,6.41) v1(124.72,53.14) v1(125.08,59.37) v1(125.61,52.63) v1(125.92,108.37) v1(125.94,64.92) v1(125.94,57.33) v1(126.08,60.79) v1(126.02,7.93) v1(126.02,6.41) v1(126.02,4.88) v1(126.43,66.41) v1(126.69,50.86) v1(126.88,52.32) v1(127.26,57.37) v1(127.36,7.93) v1(127.36,6.41) v1(127.51,48.19) v1(127.71,59.25) v1(127.76,50.48) v1(127.83,64.89) v1(128.21,66.41) v1(128.44,112.92) v1(129.16,62.59) v1(129.18,49.77) v1(129.32,120.34) v1(129.44,9.45) v1(129.44,7.93) v1(129.44,6.41) v1(129.58,118.18) v1(129.82,1.6) v1(130.24,44.25) v1(130.65,42.7) v1(131.36,121.61) v1(131.36,117.29) v1(131.47,53.03) v1(131.45,45.46) v1(131.43,0.5) v1(131.6,1.68) v1(131.69,8.82) v1(131.69,7.3) v1(131.78,79.29) v1(131.78,78.7) v1(131.76,74.25) v1(131.96,44) v1(132.54,50.72) v1(132.88,72.81) v1(133.06,54.48) v1(133.13,118.3) v1(133.26,120.46) v1(133.29,45.27) v1(134,94.71) v1(134.01,93.53) v1(134.05,79.34) v1(134.04,78.7) v1(134.54,75.47) v1(134.62,73.01) v1(134.69,43.81) v1(134.64,8.82) v1(134.64,7.3) v1(134.64,5.77) v1(134.85,121.67) v1(135.03,68.76) v1(135.47,48.72) v1(135.98,52.99) v1(135.98,51.04) v1(136.02,45.21) v1(136.68,79.4) v1(136.68,78.82) v1(136.88,53.8) v1(136.88,52.99) v1(136.92,52.39) v1(136.91,51.81) v1(136.92,7.3) v1(136.92,5.77) v1(137.17,68.72) v1(137.48,82.82) v1(137.48,82.18) v1(137.48,81.45) v1(137.48,80.76) v1(137.83,52.99) v1(138.19,7.68) v1(138.19,5.39) v1(138.52,82.84) v1(138.52,82.21) v1(138.52,81.47) v1(138.52,80.79) v1(139.05,0.5) v1(139.1,48.61) v1(139.32,79.33) v1(139.33,78.73) v1(139.46,8.82) v1(139.46,7.3) v1(139.46,5.77) v1(139.57,54.39) v1(139.74,51.04) v1(139.89,68.73) v1(139.89,45.08) v1(140.25,94.05) v1(140.69,54.39) v1(140.69,52.29) v1(140.68,48.61) v1(141.11,99.37) v1(141.14,98.11) v1(141.64,82.74) v1(141.64,82.08) v1(141.64,81.42) v1(141.64,80.76) v1(141.78,103.55) v1(141.78,79.35) v1(141.77,78.72) v1(141.85,8.75) v1(141.85,7.22) v1(142,121.68) v1(142.25,48.61) v1(142.31,47.24) v1(142.58,68.76) v1(142.6,50.39) v1(142.62,82.74) v1(142.62,82.08) v1(142.62,81.42) v1(142.62,80.76) v1(142.84,98.28) v1(143.2,9.13) v1(143.26,12.64) v1(143.51,102.19) v1(143.55,51.74) v1(143.83,47.3) v1(144.4,100.43) v1(144.52,54.39) v1(144.68,79.35) v1(144.68,78.73) v1(144.64,8.75) v1(144.64,7.22) v1(144.64,5.7) v1(144.78,102.75) v1(145.01,98.47) v1(145.29,73.8) v1(145.29,71.91) v1(145.25,68.57) v1(145.28,52.99) v1(145.4,48.61) v1(145.35,45.9) v1(145.48,97.4) v1(145.96,54.29) v1(145.96,51.04) v1(146.66,71.9) v1(146.9,79.07) v1(146.9,78.49) v1(146.91,51.84) v1(146.98,7.3) v1(146.98,5.77) v1(147.2,46.16) v1(147.21,102.29) v1(147.27,85.42) v1(147.37,68.75) v1(147.65,73.33) v1(147.86,51.69) v1(148.23,71.26) v1(148.35,7.68) v1(148.35,5.39) v1(148.55,48.61) v1(148.59,45.71) v1(148.64,111.75) v1(148.66,43.74) v1(148.71,54.36) v1(148.82,72.43) v1(148.82,53.06) v1(148.82,50.46) v1(149.21,102.26) v1(149.62,121.68) v1(149.67,51.62) v1(149.8,68.72) v1(149.75,54.29) v1(149.75,8.82) v1(149.75,7.3) v1(149.75,5.77) v1(149.85,73.22) v1(150.3,116) v1(150.58,72.15) v1(150.69,45.14) v1(150.62,43.36) v1(150.95,8.39) v1(151.3,102.22) v1(151.23,54.29) v1(151.23,52.99) v1(151.24,51.04) v1(151.6,72.48) v1(151.69,38.64) v1(151.69,38.01) v1(151.69,37.39) v1(152.13,48.72) v1(152.28,43.74) v1(152.27,41.4) v1(152.34,120.67) v1(152.78,113.46) v1(153.29,72.49) v1(153.37,13.15) v1(154.29,0.5) v1(154.37,44.44) v1(154.37,42.67) v1(154.59,47) v1(155.03,101.73) v1(155.04,54.29) v1(155.04,53.64) v1(155.04,52.99) v1(155.04,51.69) v1(155.04,50.39) v1(155.37,61.46) v1(155.41,62.28) v1(155.7,114.01) v1(155.89,52.99) v1(155.89,51.04) v1(156.08,83.47) v1(156.13,0.55) v1(156.28,44.7) v1(156.28,42.92) v1(156.3,2.44) v1(156.38,6.76) v1(156.72,83.47) v1(157.24,121.68) v1(157.23,48.67) v1(157.53,107.15) v1(157.76,52.92) v1(157.86,44) v1(158.2,61.18) v1(158.24,71.78) v1(158.42,62.2) v1(158.69,102.01) v1(158.62,4.04) v1(159.14,89.21) v1(159.3,107.14) v1(159.77,43.85) v1(159.98,60.15) v1(160.27,59.26) v1(160.27,50.28) v1(160.32,53.53) v1(160.46,112.68) v1(160.41,89.07) v1(161.01,2.44) v1(161.16,0.51) v1(161.58,82.21) v1(161.54,74.89) v1(162.19,50.1) v1(162.71,115.53) v1(162.99,113.08) v1(163.27,101.64) v1(163.73,49.26) v1(164.68,80.22) v1(164.6,0.5) v1(164.74,115.64) v1(164.72,100.14) v1(164.86,121.68) v1(165.14,101.64) v1(165.8,8.75) v1(165.8,7.22) v1(165.8,5.7) v1(166.45,80.16) v1(166.51,93.26) v1(166.61,97.39) v1(166.73,115.41) v1(167.06,90.46) v1(167.26,95.11) v1(167.22,7.6) v1(167.22,5.32) v1(167.54,102.1) v1(167.74,45.57) v1(167.93,95.57) v1(168.87,7.22) v1(168.87,5.7) v1(171.13,64.95) v1(171.41,7.22) v1(171.41,5.7) v1(171.68,50.39) v1(171.62,48.7) v1(171.72,102.85) v1(172.17,46.79) v1(172.35,1.77) v1(172.48,121.68) v1(172.72,108.27) v1(173.26,9.13) v1(173.88,57.67) v1(174.24,97.54) v1(174.79,8.75) v1(174.79,5.7) v1(175.55,98.58) v1(177.33,8.75) v1(177.33,7.22) v1(178.09,94.05) v1(178.85,79.82) v1(179.18,94.08) v1(179.84,0.5) v1(180.1,121.68) v1(180.92,8.75) v1(180.92,5.7) v1(181.08,87.99) v1(181.23,101.87) v1(181.71,87.99) v1(182.35,87.99) v1(182.98,87.99) v1(182.97,7.22) v1(182.97,5.7) v1(183.34,101.27) v1(184.24,5.39) v1(184.33,88.01) v1(184.96,88.01) v1(184.96,35.85) v1(185.59,7.22) v1(185.59,5.7) v1(185.66,89.92) v1(186.27,35.87) v1(187.46,0.5) v1(187.72,121.68) v1(187.91,97.37) v1(188.07,9.45) v1(188.07,7.93) v1(188.07,6.41) v1(188.07,4.88) v1(189.13,101.84) v1(189.47,7.93) v1(189.47,6.41) v1(189.89,97.83) v1(190.04,42.42) v1(190.7,42.43) v1(190.85,7.8) v1(190.85,6.28) v1(191.08,101.82) v1(193.13,7.93) v1(193.13,6.41) v1(194.79,121.67) v1(194.92,93.92) v1(194.96,7.93) v1(194.96,6.41) v1(195.08,0.5) v1(195.33,101.78) v1(196.38,120.34) v1(196.51,118.18) v1(196.79,7.93) v1(196.79,6.41) v1(197.1,5.64) v1(198.16,121.35) v1(198.29,117.29) v1(198.51,7.55) v1(198.51,6.79) v1(198.96,5.64) v1(199.41,8.69) v1(199.94,120.59) v1(199.99,7.93) v1(199.99,6.41) v1(200.06,118.3) v1(200.75,116.22) v1(201.82,110.3) v1(201.82,9.45) v1(201.82,7.93) v1(201.82,6.41) v1(202.7,0.5) v1(203.55,7.93) v1(203.55,6.41) v1(205.16,9.45) v1(205.16,7.93) v1(205.16,6.41) v1(205.3,107.13) v1(207.38,1.65) v1(207.45,8.62) v1(207.45,7.09) v1(207.45,5.57) v1(208.1,1.58) v1(208.86,6.71) v1(208.89,1.59) v1(209.61,106.44) v1(210.32,0.5) v1(210.8,8.62) v1(210.8,7.09) v1(210.8,5.57) v1(211.66,85.85) v1(212.05,15.64) v1(212.29,85.85) v1(212.46,49.63) v1(212.48,15.2) v1(212.93,14.75) v1(212.96,8.82) v1(212.96,7.3) v1(212.96,5.77) v1(213.39,14.3) v1(213.83,108.35) v1(214.29,5.39) v1(215.56,8.82) v1(215.56,7.3) v1(215.56,5.77) v1(215.77,89.28) v1(216.24,112.21) v1(216.5,117.39) v1(216.64,89.28) v1(217.34,121.53) v1(217.45,89.28) v1(217.62,8.57) v1(217.62,7.04) v1(217.94,0.5) v1(218.89,8.95) v1(218.89,6.66) v1(219.75,116.65) v1(220,114.49) v1(221.03,8.57) v1(221.03,7.04) v1(221.03,5.52) v1(221.53,117.92) v1(221.65,113.73) v1(221.91,37.4) v1(223.19,7.3) v1(223.19,5.77) v1(223.3,114.62) v1(223.43,116.78) v1(224.32,121.63) v1(224.48,7.68) v1(224.48,5.39) v1(225.54,13.14) v1(225.56,0.5) v1(225.75,8.82) v1(225.75,7.3) v1(225.75,5.77) v1(226.16,15.69) v1(227.06,8.79) v1(227.23,6.25) v1(227.86,106.31) v1(228,110.89) v1(228.1,48.47) v1(228.8,108.79) v1(229.34,48.47) v1(229.68,92.79) v1(230.01,92.31) v1(230.37,11.39) v1(231.6,92.83) v1(232.58,9.24) v1(232.61,3.27) v1(233.18,0.5) v1(233.53,92.81) v1(235.15,1.68) v1(235.29,4.54) v1(236.12,106.17) v1(237.5,5.72) v1(237.7,93.63) v1(238.4,8.69) v1(239.18,110.91) v1(239.33,5.04) v1(239.95,1.77) v1(240.75,8.61) v1(241.06,114.54) v1(241.36,7.03) v1(243.08,99.68) v1(243.1,102.85) v1(243.12,8.69) v1(243.25,106.07) v1(244.4,7.24) v1(244.49,12.22) v1(244.51,121.68) v1(244.5,9.01) v1(244.86,106.1) v1(245.05,24.2) v1(245.05,16.58) v1(245.13,99.64) v1(245.34,109.61) v1(245.55,102.79) v1(246.22,99.55) v1(246.37,86.96) v1(246.96,86.98) v1(247.28,119.7) v1(247.28,119.12) v1(247.28,118.53) v1(247.24,109.6) v1(247.22,106.22) v1(247.46,102.82) v1(247.54,62.36) v1(247.57,61.76) v1(247.82,26.81) v1(248.32,121.63) v1(248.76,106.09) v1(249.14,109.63) v1(251.5,121.66) v1(253.1,80.66) v1(253.1,79.5) v1(253.11,78.31) v1(254.29,26.81) v1(254.43,80.61) v1(254.42,79.44) v1(254.44,78.31) v1(254.95,117.26) v1(255.54,80.6) v1(255.54,79.45) v1(255.55,78.31) v1(255.94,30.67) v1(256.2,28.64) v1(256.58,60.77) v1(256.58,58.11) v1(256.6,59.49) v1(257.59,31.69) v1(257.59,27.88) v1(257.84,60.84) v1(257.85,59.5) v1(257.87,58.11) v1(257.9,49.44) v1(259.25,30.8) v1(259.25,28.77) v1(259.36,59.46) v1(259.37,58.11) v1(262.55,29) v1(264.48,104.7) v1(265.46,103.98) v1(265.47,30.75) v1(266.15,87.12) v1(266.75,87.11) v1(267.27,45.28) v1(267.56,60.04) v1(268.2,60.04) v1(268.27,73.99) v1(268.8,117.26) v1(268.9,73.98) v1(269.34,106.21) v1(269.49,73.99) v1(269.46,38.62) v1(270.41,46.68) v1(270.62,86.6) v1(270.99,46.7) v1(271.03,104.82) v1(271.44,107.25) v1(272.12,30.75) v1(273.09,118.13) v1(273.16,104.18) v1(273.57,121.68) v1(273.95,100.82) v1(274.05,119.83) v1(274.02,60.53) v1(274.1,67.63) v1(274.61,60.52) v1(275.32,60.52) v1(275.45,103.66) v1(276.07,93.65) v1(276.21,115.26) v1(276.36,66.06) v1(276.67,93.65) v1(276.83,90.49) v1(277.28,93.64) v1(277.76,86.77) v1(277.81,111.65) v1(277.91,93.63) v1(278.3,90.4) v1(278.36,86.77) v1(278.37,85.92) v1(278.36,85.09) v1(278.47,30.75) v1(278.99,86.77) v1(278.98,85.96) v1(278.97,85.12) v1(279.9,115.26) v1(280.58,112.84) v1(280.96,109.92) v1(281.31,49.63) v1(282.68,96.32) v1(282.61,49.67) v1(282.99,114.37) v1(282.99,109.03) v1(284.82,30.75) v1(285.15,110.05) v1(285.41,112.84) v1(285.69,120.61) v1(285.66,118.51) v1(285.95,50.17) v1(286.4,118.25) v1(286.72,77.59) v1(286.7,76.95) v1(286.73,76.3) v1(286.93,99.55) v1(287.19,120.61) v1(287.24,113.07) v1(287.25,69.81) v1(287.35,98.95) v1(287.55,99.52) v1(287.82,71.36) v1(289.33,98.64) v1(290.04,73.89) v1(291.91,74.07) v1(292.99,30.76) v1(295.44,57.72) v1(296.48,30.76) v1(297.04,86.32) v1(297.74,86.35) v1(298.39,86.32) v1(298.93,43.08) v1(299.86,65.67) v1(300.27,56.99) v1(300.53,59.17) v1(302.16,68.05) v1(302.17,67.43) v1(302.37,60.11) v1(302.39,59.45) v1(302.35,42.05) v1(302.4,30.75) v1(302.74,87.51) v1(302.92,38.15) v1(304.15,83.44) v1(304.17,81.73) v1(304.19,52.19) v1(304.98,70.84) v1(305.73,118.2) v1(307,77.99) v1(307.02,110.3) v1(307.4,106.1) v1(308.13,109.62) v1(308.23,64.9) v1(308.28,63.81) v1(308.28,62.74) v1(309.07,104.98) v1(309.63,64.95) v1(309.66,63.82) v1(309.66,62.72) v1(309.77,110.01) v1(310.02,30.75) v1(310.64,63.78) v1(310.65,62.69) v1(310.71,64.94) v1(311.02,85.42) v1(311.01,84.79) v1(311.01,84.19) v1(311.01,83.58) v1(311.42,105.6) v1(312.13,107.8) v1(312.41,103.11) v1(312.79,68.01) v1(312.97,67.38) v1(313.07,70.6) v1(313.65,70.61) v1(314.38,64.24) v1(314.4,65.55) v1(315.94,91.56) v1(315.94,78.93) v1(316.09,30.52) v1(316.95,75.22) v1(317.41,27.88) v1(317.54,25.85) v1(317.89,92.45) v1(318.58,102.43) v1(318.94,96.71) v1(319.19,29.02) v1(319.32,24.96) v1(319.82,96.71) v1(320.41,75.73) v1(321.07,92.42) v1(321.09,28.01) v1(321.09,25.97) v1(321.72,94.13) v1(321.98,99.38) v1(321.92,96.14) v1(321.98,93.09) v1(322.8,102.38) v1(323.28,100.93) v1(323.94,38.55) v1(323.94,36.92) v1(324.27,34.1) v1(324.31,41.66) v1(324.35,39.84) v1(324.4,32.07) v1(324.65,102.43) v1(324.88,92.88) v1(324.95,96.04) v1(325.03,99.44) v1(325.01,97.65) v1(325.31,38.06) v1(325.4,36.67) v1(325.92,41.42) v1(326,39.89) v1(326.05,35.25) v1(326.17,76.14) v1(326.17,31.18) v1(326.28,91.46) v1(326.61,101.12) v1(327,36.9) v1(327.03,38.74) v1(327.37,43.25) v1(327.42,41.52) v1(327.95,32.2) v1(328.08,34.36) v1(328.14,99.44) v1(328.14,96.21) v1(328.18,65.6) v1(328.18,57.7) v1(328.18,51.27) v1(328.21,73.22) v1(328.38,94.5) v1(328.32,44.73) v1(328.33,39.98) v1(328.42,92.89) v1(328.56,24.58) v1(328.66,37.87) v1(328.79,100.75) v1(328.79,71.41) v1(328.79,58.94) v1(328.79,50.92) v1(328.79,43.86) v1(328.79,36.24) v3(55.96,95.06) v3(55.96,94.43) v3(59.92,89.6) v3(60.55,89.6) v3(66.29,5.39) v3(66.75,5.87) v3(66.81,4.93) v3(67.41,5.78) v3(67.49,5.11) v3(67.65,6.47) v3(68.17,5.46) v3(68.11,4.77) v3(68.24,6.89) v3(68.3,6.17) v3(68.94,7.62) v3(69,6.86) v3(69.06,5.97) v3(69.82,5.72) v3(70.01,8.11) v3(70.07,7.29) v3(70.08,6.54) v3(70.73,7.79) v3(70.92,8.64) v3(80.26,67.87) v3(80.3,68.58) v3(80.48,75.73) v3(81.11,75.73) v3(81.7,88.46) v3(82.33,88.46) v3(83.05,88.6) v3(83.15,87.76) v3(83.19,87.01) v3(83.81,88.56) v3(83.91,87.72) v3(83.95,86.97) v3(84.54,88.59) v3(84.65,87.75) v3(84.68,87) v3(85.52,88.55) v3(85.56,87.9) v3(85.89,79.86) v3(86.36,80.29) v3(88.51,88.57) v3(94.25,77.76) v3(94.88,77.76) v3(95.94,77.75) v3(96.61,77.76) v3(97.8,77.76) v3(98.44,77.76) v3(100.88,58.74) v3(100.88,57.15) v3(100.88,55.69) v3(102.4,58.74) v3(102.4,55.69) v3(103.8,71.19) v3(103.8,70.49) v3(103.8,69.79) v3(103.92,58.74) v3(103.92,57.22) v3(103.99,55.69) v3(104.69,71.19) v3(104.62,70.49) v3(104.62,69.79) v3(105.45,71.19) v3(105.45,70.49) v3(105.45,69.79) v3(111.76,84.97) v3(112.4,84.97) v3(113.77,86.62) v3(114.4,86.62) v3(120.88,89.47) v3(120.88,88.84) v3(121.51,89.47) v3(121.51,88.84) v3(122.15,89.47) v3(122.15,88.84) v3(122.78,89.47) v3(122.78,88.84) v3(123.42,90.43) v3(123.55,88.84) v3(124.05,90.43) v3(124.18,88.84) v3(125.26,90.43) v3(125.32,88.84) v3(125.96,88.84) v3(127.36,89.82) v3(127.36,88.78) v3(128.24,90.17) v3(128.23,88.78) v3(128.63,89.47) v3(129.13,90.17) v3(129.13,88.78) v3(129.5,89.42) v3(129.65,86.83) v3(129.78,86.2) v3(129.9,90.17) v3(129.9,88.78) v3(130.4,89.47) v3(130.59,90.17) v3(130.59,88.78) v3(202.25,52.9) v3(202.25,52.2) v3(203.17,51.95) v3(203.81,51.95) v3(204.95,51.95) v3(205.59,51.95) v3(206.46,52.78) v3(206.45,51.96) v3(209.61,67.55) v3(209.61,66.87) v3(210.48,68.9) v3(210.48,68.27) v3(210.99,64.84) v3(210.99,64.2) v3(211.04,50.43) v3(211.24,68.9) v3(211.24,68.27) v3(211.24,67.63) v3(211.24,67) v3(211.24,66.36) v3(211.2,49.68) v3(211.62,64.84) v3(211.62,64.2) v3(211.7,50.84) v3(211.7,50.19) v3(211.92,66.36) v3(212,68.9) v3(212,68.27) v3(212,67.63) v3(212,67) v3(212.26,64.84) v3(212.26,64.2) v3(212.45,50.24) v3(212.89,64.84) v3(212.89,64.2) v3(213.21,50.87) v3(213.21,50.23) v3(213.91,50.17) v3(213.91,49.53) v3(213.91,48.9) v3(214.54,50.42) v3(214.54,49.79) v3(214.92,61.79) v3(214.92,61.15) v3(214.92,60.39) v3(214.92,59.76) v3(215.05,52.01) v3(215.05,51.37) v3(215.18,50.74) v3(215.18,50.1) v3(215.18,49.47) v3(215.63,61.76) v3(218.1,72.76) v3(218.1,72.02) v3(218.02,64.2) v3(218.05,63.52) v3(218.83,72.76) v3(218.83,72.05) v3(218.83,64.2) v3(218.81,63.52) v3(228.26,62.68) v3(228.96,62.68) v3(241.9,27.59) v3(241.83,26.93) v3(241.92,30.27) v3(241.91,29.58) v3(241.92,28.95) v3(241.91,28.26) v3(242.54,26.94) v3(242.86,32.07) v3(243.75,32.07) v3(243.91,31.41) v3(244.51,32.07) v3(244.65,31.4) v3(245.28,32.07) v3(245.41,31.4) v3(246.04,32.07) v3(246.04,30.67) v3(246.18,31.4) v3(246.8,32.07) v3(246.8,30.67) v3(246.8,29.91) v3(246.94,31.4) v3(256.93,41.52) v3(256.96,38.6) v3(257.58,38.38) v3(258.42,37.47) v3(258.42,36.52) v3(258.48,34.61) v3(258.66,34) v3(259.31,37.47) v3(259.31,36.52) v4(78.02,112.03) v4(81.42,67.96) v4(83.78,90.16) v4(98.31,77.18) v4(101.38,112.33) v4(105.69,17.88) v4(106.29,70.32) v4(113.26,87.06) v4(123.51,82.92) v4(212.76,65.73) v4(212.89,15.81) v4(213.4,67.12) v4(218.48,62.93) v4(243.62,30.17) v4(243.62,27.12) v4(287.57,76.27) v4(309.06,85.69) v4(319.27,74.69) v4(322.72,95.99)
